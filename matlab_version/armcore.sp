v0 n1_979937_1820000 0 1.8
v1 n1_1620161_300000 0 1.8
R27-100-100 n1_295000_940095 n1_300000_940095 0.736842
R27-100-101 n1_300000_940095 n1_474796_940095 25.7594
R27-100-102 n1_474796_940095 n1_474906_940095 0.0162105
R27-101-100 n1_474686_957216 n1_474796_957216 0.01925
R27-101-101 n1_474796_957216 n1_493920_957216 3.3467
R27-101-102 n1_493920_957216 n1_532832_957216 6.8096000000000005
R27-101-103 n1_532832_957216 n1_570528_957216 6.5968
R27-101-104 n1_570528_957216 n1_609440_957216 6.8096000000000005
R27-101-105 n1_609440_957216 n1_647136_957216 6.5968
R27-101-106 n1_647136_957216 n1_686048_957216 6.8096000000000005
R27-101-107 n1_686048_957216 n1_723744_957216 6.5968
R27-101-108 n1_723744_957216 n1_761440_957216 6.5968
R27-101-109 n1_761440_957216 n1_800352_957216 6.8096000000000005
R27-101-110 n1_800352_957216 n1_838048_957216 6.5968
R27-101-111 n1_838048_957216 n1_876960_957216 6.8096000000000005
R27-101-112 n1_876960_957216 n1_914656_957216 6.5968
R27-101-113 n1_914656_957216 n1_952352_957216 6.5968
R27-101-114 n1_952352_957216 n1_991264_957216 6.8096000000000005
R27-101-115 n1_991264_957216 n1_1028960_957216 6.5968
R27-101-116 n1_1028960_957216 n1_1067872_957216 6.8096000000000005
R27-101-117 n1_1067872_957216 n1_1105568_957216 6.5968
R27-101-118 n1_1105568_957216 n1_1144480_957216 6.8096000000000005
R27-101-119 n1_1144480_957216 n1_1182176_957216 6.5968
R27-101-120 n1_1182176_957216 n1_1219872_957216 6.5968
R27-101-121 n1_1219872_957216 n1_1258784_957216 6.8096000000000005
R27-101-122 n1_1258784_957216 n1_1296480_957216 6.5968
R27-101-123 n1_1296480_957216 n1_1335392_957216 6.8096000000000005
R27-101-124 n1_1335392_957216 n1_1373088_957216 6.5968
R27-101-125 n1_1373088_957216 n1_1412000_957216 6.8096000000000005
R27-101-126 n1_1412000_957216 n1_1449696_957216 6.5968
R27-101-127 n1_1449696_957216 n1_1487392_957216 6.5968
R27-101-128 n1_1487392_957216 n1_1526304_957216 6.8096000000000005
R27-101-129 n1_1526304_957216 n1_1564000_957216 6.5968
R27-101-130 n1_1564000_957216 n1_1602912_957216 6.8096000000000005
R27-101-131 n1_1602912_957216 n1_1641180_957216 6.696899999999999
R27-101-132 n1_1641180_957216 n1_1641290_957216 0.01925
R27-102-100 n1_474686_993696 n1_474796_993696 0.01925
R27-102-101 n1_474796_993696 n1_493920_993696 3.3467
R27-102-102 n1_493920_993696 n1_532832_993696 6.8096000000000005
R27-102-103 n1_532832_993696 n1_570528_993696 6.5968
R27-102-104 n1_570528_993696 n1_609440_993696 6.8096000000000005
R27-102-105 n1_609440_993696 n1_647136_993696 6.5968
R27-102-106 n1_647136_993696 n1_686048_993696 6.8096000000000005
R27-102-107 n1_686048_993696 n1_723744_993696 6.5968
R27-102-108 n1_723744_993696 n1_761440_993696 6.5968
R27-102-109 n1_761440_993696 n1_800352_993696 6.8096000000000005
R27-102-110 n1_800352_993696 n1_838048_993696 6.5968
R27-102-111 n1_838048_993696 n1_876960_993696 6.8096000000000005
R27-102-112 n1_876960_993696 n1_914656_993696 6.5968
R27-102-113 n1_914656_993696 n1_952352_993696 6.5968
R27-102-114 n1_952352_993696 n1_991264_993696 6.8096000000000005
R27-102-115 n1_991264_993696 n1_1028960_993696 6.5968
R27-102-116 n1_1028960_993696 n1_1067872_993696 6.8096000000000005
R27-102-117 n1_1067872_993696 n1_1105568_993696 6.5968
R27-102-118 n1_1105568_993696 n1_1144480_993696 6.8096000000000005
R27-102-119 n1_1144480_993696 n1_1182176_993696 6.5968
R27-102-120 n1_1182176_993696 n1_1219872_993696 6.5968
R27-102-121 n1_1219872_993696 n1_1258784_993696 6.8096000000000005
R27-102-122 n1_1258784_993696 n1_1296480_993696 6.5968
R27-102-123 n1_1296480_993696 n1_1335392_993696 6.8096000000000005
R27-102-124 n1_1335392_993696 n1_1373088_993696 6.5968
R27-102-125 n1_1373088_993696 n1_1412000_993696 6.8096000000000005
R27-102-126 n1_1412000_993696 n1_1449696_993696 6.5968
R27-102-127 n1_1449696_993696 n1_1487392_993696 6.5968
R27-102-128 n1_1487392_993696 n1_1526304_993696 6.8096000000000005
R27-102-129 n1_1526304_993696 n1_1564000_993696 6.5968
R27-102-130 n1_1564000_993696 n1_1602912_993696 6.8096000000000005
R27-102-131 n1_1602912_993696 n1_1641180_993696 6.696899999999999
R27-102-132 n1_1641180_993696 n1_1641290_993696 0.01925
R27-103-100 n1_474686_1032608 n1_474796_1032608 0.01925
R27-103-101 n1_474796_1032608 n1_493920_1032608 3.3467
R27-103-102 n1_493920_1032608 n1_532832_1032608 6.8096000000000005
R27-103-103 n1_532832_1032608 n1_570528_1032608 6.5968
R27-103-104 n1_570528_1032608 n1_609440_1032608 6.8096000000000005
R27-103-105 n1_609440_1032608 n1_647136_1032608 6.5968
R27-103-106 n1_647136_1032608 n1_686048_1032608 6.8096000000000005
R27-103-107 n1_686048_1032608 n1_723744_1032608 6.5968
R27-103-108 n1_723744_1032608 n1_761440_1032608 6.5968
R27-103-109 n1_761440_1032608 n1_800352_1032608 6.8096000000000005
R27-103-110 n1_800352_1032608 n1_838048_1032608 6.5968
R27-103-111 n1_838048_1032608 n1_876960_1032608 6.8096000000000005
R27-103-112 n1_876960_1032608 n1_914656_1032608 6.5968
R27-103-113 n1_914656_1032608 n1_952352_1032608 6.5968
R27-103-114 n1_952352_1032608 n1_991264_1032608 6.8096000000000005
R27-103-115 n1_991264_1032608 n1_1028960_1032608 6.5968
R27-103-116 n1_1028960_1032608 n1_1067872_1032608 6.8096000000000005
R27-103-117 n1_1067872_1032608 n1_1105568_1032608 6.5968
R27-103-118 n1_1105568_1032608 n1_1144480_1032608 6.8096000000000005
R27-103-119 n1_1144480_1032608 n1_1182176_1032608 6.5968
R27-103-120 n1_1182176_1032608 n1_1219872_1032608 6.5968
R27-103-121 n1_1219872_1032608 n1_1258784_1032608 6.8096000000000005
R27-103-122 n1_1258784_1032608 n1_1296480_1032608 6.5968
R27-103-123 n1_1296480_1032608 n1_1335392_1032608 6.8096000000000005
R27-103-124 n1_1335392_1032608 n1_1373088_1032608 6.5968
R27-103-125 n1_1373088_1032608 n1_1412000_1032608 6.8096000000000005
R27-103-126 n1_1412000_1032608 n1_1449696_1032608 6.5968
R27-103-127 n1_1449696_1032608 n1_1487392_1032608 6.5968
R27-103-128 n1_1487392_1032608 n1_1526304_1032608 6.8096000000000005
R27-103-129 n1_1526304_1032608 n1_1564000_1032608 6.5968
R27-103-130 n1_1564000_1032608 n1_1602912_1032608 6.8096000000000005
R27-103-131 n1_1602912_1032608 n1_1641180_1032608 6.696899999999999
R27-103-132 n1_1641180_1032608 n1_1641290_1032608 0.01925
R27-104-100 n1_474686_1071520 n1_474796_1071520 0.01925
R27-104-101 n1_474796_1071520 n1_493920_1071520 3.3467
R27-104-102 n1_493920_1071520 n1_532832_1071520 6.8096000000000005
R27-104-103 n1_532832_1071520 n1_570528_1071520 6.5968
R27-104-104 n1_570528_1071520 n1_609440_1071520 6.8096000000000005
R27-104-105 n1_609440_1071520 n1_647136_1071520 6.5968
R27-104-106 n1_647136_1071520 n1_686048_1071520 6.8096000000000005
R27-104-107 n1_686048_1071520 n1_723744_1071520 6.5968
R27-104-108 n1_723744_1071520 n1_761440_1071520 6.5968
R27-104-109 n1_761440_1071520 n1_800352_1071520 6.8096000000000005
R27-104-110 n1_800352_1071520 n1_838048_1071520 6.5968
R27-104-111 n1_838048_1071520 n1_876960_1071520 6.8096000000000005
R27-104-112 n1_876960_1071520 n1_914656_1071520 6.5968
R27-104-113 n1_914656_1071520 n1_952352_1071520 6.5968
R27-104-114 n1_952352_1071520 n1_991264_1071520 6.8096000000000005
R27-104-115 n1_991264_1071520 n1_1028960_1071520 6.5968
R27-104-116 n1_1028960_1071520 n1_1067872_1071520 6.8096000000000005
R27-104-117 n1_1067872_1071520 n1_1105568_1071520 6.5968
R27-104-118 n1_1105568_1071520 n1_1144480_1071520 6.8096000000000005
R27-104-119 n1_1144480_1071520 n1_1182176_1071520 6.5968
R27-104-120 n1_1182176_1071520 n1_1219872_1071520 6.5968
R27-104-121 n1_1219872_1071520 n1_1258784_1071520 6.8096000000000005
R27-104-122 n1_1258784_1071520 n1_1296480_1071520 6.5968
R27-104-123 n1_1296480_1071520 n1_1335392_1071520 6.8096000000000005
R27-104-124 n1_1335392_1071520 n1_1373088_1071520 6.5968
R27-104-125 n1_1373088_1071520 n1_1412000_1071520 6.8096000000000005
R27-104-126 n1_1412000_1071520 n1_1449696_1071520 6.5968
R27-104-127 n1_1449696_1071520 n1_1487392_1071520 6.5968
R27-104-128 n1_1487392_1071520 n1_1526304_1071520 6.8096000000000005
R27-104-129 n1_1526304_1071520 n1_1564000_1071520 6.5968
R27-104-130 n1_1564000_1071520 n1_1602912_1071520 6.8096000000000005
R27-104-131 n1_1602912_1071520 n1_1641180_1071520 6.696899999999999
R27-104-132 n1_1641180_1071520 n1_1641290_1071520 0.01925
R27-105-100 n1_474686_1108000 n1_474796_1108000 0.01925
R27-105-101 n1_474796_1108000 n1_493920_1108000 3.3467
R27-105-102 n1_493920_1108000 n1_532832_1108000 6.8096000000000005
R27-105-103 n1_532832_1108000 n1_570528_1108000 6.5968
R27-105-104 n1_570528_1108000 n1_609440_1108000 6.8096000000000005
R27-105-105 n1_609440_1108000 n1_647136_1108000 6.5968
R27-105-106 n1_647136_1108000 n1_686048_1108000 6.8096000000000005
R27-105-107 n1_686048_1108000 n1_723744_1108000 6.5968
R27-105-108 n1_723744_1108000 n1_761440_1108000 6.5968
R27-105-109 n1_761440_1108000 n1_800352_1108000 6.8096000000000005
R27-105-110 n1_800352_1108000 n1_838048_1108000 6.5968
R27-105-111 n1_838048_1108000 n1_876960_1108000 6.8096000000000005
R27-105-112 n1_876960_1108000 n1_914656_1108000 6.5968
R27-105-113 n1_914656_1108000 n1_952352_1108000 6.5968
R27-105-114 n1_952352_1108000 n1_991264_1108000 6.8096000000000005
R27-105-115 n1_991264_1108000 n1_1028960_1108000 6.5968
R27-105-116 n1_1028960_1108000 n1_1067872_1108000 6.8096000000000005
R27-105-117 n1_1067872_1108000 n1_1105568_1108000 6.5968
R27-105-118 n1_1105568_1108000 n1_1144480_1108000 6.8096000000000005
R27-105-119 n1_1144480_1108000 n1_1182176_1108000 6.5968
R27-105-120 n1_1182176_1108000 n1_1219872_1108000 6.5968
R27-105-121 n1_1219872_1108000 n1_1258784_1108000 6.8096000000000005
R27-105-122 n1_1258784_1108000 n1_1296480_1108000 6.5968
R27-105-123 n1_1296480_1108000 n1_1335392_1108000 6.8096000000000005
R27-105-124 n1_1335392_1108000 n1_1373088_1108000 6.5968
R27-105-125 n1_1373088_1108000 n1_1412000_1108000 6.8096000000000005
R27-105-126 n1_1412000_1108000 n1_1449696_1108000 6.5968
R27-105-127 n1_1449696_1108000 n1_1487392_1108000 6.5968
R27-105-128 n1_1487392_1108000 n1_1526304_1108000 6.8096000000000005
R27-105-129 n1_1526304_1108000 n1_1564000_1108000 6.5968
R27-105-130 n1_1564000_1108000 n1_1602912_1108000 6.8096000000000005
R27-105-131 n1_1602912_1108000 n1_1641180_1108000 6.696899999999999
R27-105-132 n1_1641180_1108000 n1_1641290_1108000 0.01925
R27-106-100 n1_474686_1146912 n1_474796_1146912 0.01925
R27-106-101 n1_474796_1146912 n1_493920_1146912 3.3467
R27-106-102 n1_493920_1146912 n1_532832_1146912 6.8096000000000005
R27-106-103 n1_532832_1146912 n1_570528_1146912 6.5968
R27-106-104 n1_570528_1146912 n1_609440_1146912 6.8096000000000005
R27-106-105 n1_609440_1146912 n1_647136_1146912 6.5968
R27-106-106 n1_647136_1146912 n1_686048_1146912 6.8096000000000005
R27-106-107 n1_686048_1146912 n1_723744_1146912 6.5968
R27-106-108 n1_723744_1146912 n1_761440_1146912 6.5968
R27-106-109 n1_761440_1146912 n1_800352_1146912 6.8096000000000005
R27-106-110 n1_800352_1146912 n1_838048_1146912 6.5968
R27-106-111 n1_838048_1146912 n1_876960_1146912 6.8096000000000005
R27-106-112 n1_876960_1146912 n1_914656_1146912 6.5968
R27-106-113 n1_914656_1146912 n1_952352_1146912 6.5968
R27-106-114 n1_952352_1146912 n1_991264_1146912 6.8096000000000005
R27-106-115 n1_991264_1146912 n1_1028960_1146912 6.5968
R27-106-116 n1_1028960_1146912 n1_1067872_1146912 6.8096000000000005
R27-106-117 n1_1067872_1146912 n1_1105568_1146912 6.5968
R27-106-118 n1_1105568_1146912 n1_1144480_1146912 6.8096000000000005
R27-106-119 n1_1144480_1146912 n1_1182176_1146912 6.5968
R27-106-120 n1_1182176_1146912 n1_1219872_1146912 6.5968
R27-106-121 n1_1219872_1146912 n1_1258784_1146912 6.8096000000000005
R27-106-122 n1_1258784_1146912 n1_1296480_1146912 6.5968
R27-106-123 n1_1296480_1146912 n1_1335392_1146912 6.8096000000000005
R27-106-124 n1_1335392_1146912 n1_1373088_1146912 6.5968
R27-106-125 n1_1373088_1146912 n1_1412000_1146912 6.8096000000000005
R27-106-126 n1_1412000_1146912 n1_1449696_1146912 6.5968
R27-106-127 n1_1449696_1146912 n1_1487392_1146912 6.5968
R27-106-128 n1_1487392_1146912 n1_1526304_1146912 6.8096000000000005
R27-106-129 n1_1526304_1146912 n1_1564000_1146912 6.5968
R27-106-130 n1_1564000_1146912 n1_1602912_1146912 6.8096000000000005
R27-106-131 n1_1602912_1146912 n1_1641180_1146912 6.696899999999999
R27-106-132 n1_1641180_1146912 n1_1641290_1146912 0.01925
R27-107-100 n1_474686_1183392 n1_474796_1183392 0.01925
R27-107-101 n1_474796_1183392 n1_493920_1183392 3.3467
R27-107-102 n1_493920_1183392 n1_532832_1183392 6.8096000000000005
R27-107-103 n1_532832_1183392 n1_570528_1183392 6.5968
R27-107-104 n1_570528_1183392 n1_609440_1183392 6.8096000000000005
R27-107-105 n1_609440_1183392 n1_647136_1183392 6.5968
R27-107-106 n1_647136_1183392 n1_686048_1183392 6.8096000000000005
R27-107-107 n1_686048_1183392 n1_723744_1183392 6.5968
R27-107-108 n1_723744_1183392 n1_761440_1183392 6.5968
R27-107-109 n1_761440_1183392 n1_800352_1183392 6.8096000000000005
R27-107-110 n1_800352_1183392 n1_838048_1183392 6.5968
R27-107-111 n1_838048_1183392 n1_876960_1183392 6.8096000000000005
R27-107-112 n1_876960_1183392 n1_914656_1183392 6.5968
R27-107-113 n1_914656_1183392 n1_952352_1183392 6.5968
R27-107-114 n1_952352_1183392 n1_991264_1183392 6.8096000000000005
R27-107-115 n1_991264_1183392 n1_1028960_1183392 6.5968
R27-107-116 n1_1028960_1183392 n1_1067872_1183392 6.8096000000000005
R27-107-117 n1_1067872_1183392 n1_1105568_1183392 6.5968
R27-107-118 n1_1105568_1183392 n1_1144480_1183392 6.8096000000000005
R27-107-119 n1_1144480_1183392 n1_1182176_1183392 6.5968
R27-107-120 n1_1182176_1183392 n1_1219872_1183392 6.5968
R27-107-121 n1_1219872_1183392 n1_1258784_1183392 6.8096000000000005
R27-107-122 n1_1258784_1183392 n1_1296480_1183392 6.5968
R27-107-123 n1_1296480_1183392 n1_1335392_1183392 6.8096000000000005
R27-107-124 n1_1335392_1183392 n1_1373088_1183392 6.5968
R27-107-125 n1_1373088_1183392 n1_1412000_1183392 6.8096000000000005
R27-107-126 n1_1412000_1183392 n1_1449696_1183392 6.5968
R27-107-127 n1_1449696_1183392 n1_1487392_1183392 6.5968
R27-107-128 n1_1487392_1183392 n1_1526304_1183392 6.8096000000000005
R27-107-129 n1_1526304_1183392 n1_1564000_1183392 6.5968
R27-107-130 n1_1564000_1183392 n1_1602912_1183392 6.8096000000000005
R27-107-131 n1_1602912_1183392 n1_1641180_1183392 6.696899999999999
R27-107-132 n1_1641180_1183392 n1_1641290_1183392 0.01925
R27-108-100 n1_474686_1222304 n1_474796_1222304 0.01925
R27-108-101 n1_474796_1222304 n1_493920_1222304 3.3467
R27-108-102 n1_493920_1222304 n1_532832_1222304 6.8096000000000005
R27-108-103 n1_532832_1222304 n1_570528_1222304 6.5968
R27-108-104 n1_570528_1222304 n1_609440_1222304 6.8096000000000005
R27-108-105 n1_609440_1222304 n1_647136_1222304 6.5968
R27-108-106 n1_647136_1222304 n1_686048_1222304 6.8096000000000005
R27-108-107 n1_686048_1222304 n1_723744_1222304 6.5968
R27-108-108 n1_723744_1222304 n1_761440_1222304 6.5968
R27-108-109 n1_761440_1222304 n1_800352_1222304 6.8096000000000005
R27-108-110 n1_800352_1222304 n1_838048_1222304 6.5968
R27-108-111 n1_838048_1222304 n1_876960_1222304 6.8096000000000005
R27-108-112 n1_876960_1222304 n1_914656_1222304 6.5968
R27-108-113 n1_914656_1222304 n1_952352_1222304 6.5968
R27-108-114 n1_952352_1222304 n1_991264_1222304 6.8096000000000005
R27-108-115 n1_991264_1222304 n1_1028960_1222304 6.5968
R27-108-116 n1_1028960_1222304 n1_1067872_1222304 6.8096000000000005
R27-108-117 n1_1067872_1222304 n1_1105568_1222304 6.5968
R27-108-118 n1_1105568_1222304 n1_1144480_1222304 6.8096000000000005
R27-108-119 n1_1144480_1222304 n1_1182176_1222304 6.5968
R27-108-120 n1_1182176_1222304 n1_1219872_1222304 6.5968
R27-108-121 n1_1219872_1222304 n1_1258784_1222304 6.8096000000000005
R27-108-122 n1_1258784_1222304 n1_1296480_1222304 6.5968
R27-108-123 n1_1296480_1222304 n1_1335392_1222304 6.8096000000000005
R27-108-124 n1_1335392_1222304 n1_1373088_1222304 6.5968
R27-108-125 n1_1373088_1222304 n1_1412000_1222304 6.8096000000000005
R27-108-126 n1_1412000_1222304 n1_1449696_1222304 6.5968
R27-108-127 n1_1449696_1222304 n1_1487392_1222304 6.5968
R27-108-128 n1_1487392_1222304 n1_1526304_1222304 6.8096000000000005
R27-108-129 n1_1526304_1222304 n1_1564000_1222304 6.5968
R27-108-130 n1_1564000_1222304 n1_1602912_1222304 6.8096000000000005
R27-108-131 n1_1602912_1222304 n1_1641180_1222304 6.696899999999999
R27-108-132 n1_1641180_1222304 n1_1641290_1222304 0.01925
R27-109-100 n1_474686_1261216 n1_474796_1261216 0.01925
R27-109-101 n1_474796_1261216 n1_493920_1261216 3.3467
R27-109-102 n1_493920_1261216 n1_532832_1261216 6.8096000000000005
R27-109-103 n1_532832_1261216 n1_570528_1261216 6.5968
R27-109-104 n1_570528_1261216 n1_609440_1261216 6.8096000000000005
R27-109-105 n1_609440_1261216 n1_647136_1261216 6.5968
R27-109-106 n1_647136_1261216 n1_686048_1261216 6.8096000000000005
R27-109-107 n1_686048_1261216 n1_723744_1261216 6.5968
R27-109-108 n1_723744_1261216 n1_761440_1261216 6.5968
R27-109-109 n1_761440_1261216 n1_800352_1261216 6.8096000000000005
R27-109-110 n1_800352_1261216 n1_838048_1261216 6.5968
R27-109-111 n1_838048_1261216 n1_876960_1261216 6.8096000000000005
R27-109-112 n1_876960_1261216 n1_914656_1261216 6.5968
R27-109-113 n1_914656_1261216 n1_952352_1261216 6.5968
R27-109-114 n1_952352_1261216 n1_991264_1261216 6.8096000000000005
R27-109-115 n1_991264_1261216 n1_1028960_1261216 6.5968
R27-109-116 n1_1028960_1261216 n1_1067872_1261216 6.8096000000000005
R27-109-117 n1_1067872_1261216 n1_1105568_1261216 6.5968
R27-109-118 n1_1105568_1261216 n1_1144480_1261216 6.8096000000000005
R27-109-119 n1_1144480_1261216 n1_1182176_1261216 6.5968
R27-109-120 n1_1182176_1261216 n1_1219872_1261216 6.5968
R27-109-121 n1_1219872_1261216 n1_1258784_1261216 6.8096000000000005
R27-109-122 n1_1258784_1261216 n1_1296480_1261216 6.5968
R27-109-123 n1_1296480_1261216 n1_1335392_1261216 6.8096000000000005
R27-109-124 n1_1335392_1261216 n1_1373088_1261216 6.5968
R27-109-125 n1_1373088_1261216 n1_1412000_1261216 6.8096000000000005
R27-109-126 n1_1412000_1261216 n1_1449696_1261216 6.5968
R27-109-127 n1_1449696_1261216 n1_1487392_1261216 6.5968
R27-109-128 n1_1487392_1261216 n1_1526304_1261216 6.8096000000000005
R27-109-129 n1_1526304_1261216 n1_1564000_1261216 6.5968
R27-109-130 n1_1564000_1261216 n1_1602912_1261216 6.8096000000000005
R27-109-131 n1_1602912_1261216 n1_1641180_1261216 6.696899999999999
R27-109-132 n1_1641180_1261216 n1_1641290_1261216 0.01925
R27-110-100 n1_474686_1297696 n1_474796_1297696 0.01925
R27-110-101 n1_474796_1297696 n1_493920_1297696 3.3467
R27-110-102 n1_493920_1297696 n1_532832_1297696 6.8096000000000005
R27-110-103 n1_532832_1297696 n1_570528_1297696 6.5968
R27-110-104 n1_570528_1297696 n1_609440_1297696 6.8096000000000005
R27-110-105 n1_609440_1297696 n1_647136_1297696 6.5968
R27-110-106 n1_647136_1297696 n1_686048_1297696 6.8096000000000005
R27-110-107 n1_686048_1297696 n1_723744_1297696 6.5968
R27-110-108 n1_723744_1297696 n1_761440_1297696 6.5968
R27-110-109 n1_761440_1297696 n1_800352_1297696 6.8096000000000005
R27-110-110 n1_800352_1297696 n1_838048_1297696 6.5968
R27-110-111 n1_838048_1297696 n1_876960_1297696 6.8096000000000005
R27-110-112 n1_876960_1297696 n1_914656_1297696 6.5968
R27-110-113 n1_914656_1297696 n1_952352_1297696 6.5968
R27-110-114 n1_952352_1297696 n1_991264_1297696 6.8096000000000005
R27-110-115 n1_991264_1297696 n1_1028960_1297696 6.5968
R27-110-116 n1_1028960_1297696 n1_1067872_1297696 6.8096000000000005
R27-110-117 n1_1067872_1297696 n1_1105568_1297696 6.5968
R27-110-118 n1_1105568_1297696 n1_1144480_1297696 6.8096000000000005
R27-110-119 n1_1144480_1297696 n1_1182176_1297696 6.5968
R27-110-120 n1_1182176_1297696 n1_1219872_1297696 6.5968
R27-110-121 n1_1219872_1297696 n1_1258784_1297696 6.8096000000000005
R27-110-122 n1_1258784_1297696 n1_1296480_1297696 6.5968
R27-110-123 n1_1296480_1297696 n1_1335392_1297696 6.8096000000000005
R27-110-124 n1_1335392_1297696 n1_1373088_1297696 6.5968
R27-110-125 n1_1373088_1297696 n1_1412000_1297696 6.8096000000000005
R27-110-126 n1_1412000_1297696 n1_1449696_1297696 6.5968
R27-110-127 n1_1449696_1297696 n1_1487392_1297696 6.5968
R27-110-128 n1_1487392_1297696 n1_1526304_1297696 6.8096000000000005
R27-110-129 n1_1526304_1297696 n1_1564000_1297696 6.5968
R27-110-130 n1_1564000_1297696 n1_1602912_1297696 6.8096000000000005
R27-110-131 n1_1602912_1297696 n1_1641180_1297696 6.696899999999999
R27-110-132 n1_1641180_1297696 n1_1641290_1297696 0.01925
R27-111-100 n1_474686_1336608 n1_474796_1336608 0.01925
R27-111-101 n1_474796_1336608 n1_493920_1336608 3.3467
R27-111-102 n1_493920_1336608 n1_532832_1336608 6.8096000000000005
R27-111-103 n1_532832_1336608 n1_570528_1336608 6.5968
R27-111-104 n1_570528_1336608 n1_609440_1336608 6.8096000000000005
R27-111-105 n1_609440_1336608 n1_647136_1336608 6.5968
R27-111-106 n1_647136_1336608 n1_686048_1336608 6.8096000000000005
R27-111-107 n1_686048_1336608 n1_723744_1336608 6.5968
R27-111-108 n1_723744_1336608 n1_761440_1336608 6.5968
R27-111-109 n1_761440_1336608 n1_800352_1336608 6.8096000000000005
R27-111-110 n1_800352_1336608 n1_838048_1336608 6.5968
R27-111-111 n1_838048_1336608 n1_876960_1336608 6.8096000000000005
R27-111-112 n1_876960_1336608 n1_914656_1336608 6.5968
R27-111-113 n1_914656_1336608 n1_952352_1336608 6.5968
R27-111-114 n1_952352_1336608 n1_991264_1336608 6.8096000000000005
R27-111-115 n1_991264_1336608 n1_1028960_1336608 6.5968
R27-111-116 n1_1028960_1336608 n1_1067872_1336608 6.8096000000000005
R27-111-117 n1_1067872_1336608 n1_1105568_1336608 6.5968
R27-111-118 n1_1105568_1336608 n1_1144480_1336608 6.8096000000000005
R27-111-119 n1_1144480_1336608 n1_1182176_1336608 6.5968
R27-111-120 n1_1182176_1336608 n1_1219872_1336608 6.5968
R27-111-121 n1_1219872_1336608 n1_1258784_1336608 6.8096000000000005
R27-111-122 n1_1258784_1336608 n1_1296480_1336608 6.5968
R27-111-123 n1_1296480_1336608 n1_1335392_1336608 6.8096000000000005
R27-111-124 n1_1335392_1336608 n1_1373088_1336608 6.5968
R27-111-125 n1_1373088_1336608 n1_1412000_1336608 6.8096000000000005
R27-111-126 n1_1412000_1336608 n1_1449696_1336608 6.5968
R27-111-127 n1_1449696_1336608 n1_1487392_1336608 6.5968
R27-111-128 n1_1487392_1336608 n1_1526304_1336608 6.8096000000000005
R27-111-129 n1_1526304_1336608 n1_1564000_1336608 6.5968
R27-111-130 n1_1564000_1336608 n1_1602912_1336608 6.8096000000000005
R27-111-131 n1_1602912_1336608 n1_1641180_1336608 6.696899999999999
R27-111-132 n1_1641180_1336608 n1_1641290_1336608 0.01925
R27-112-100 n1_474686_1373088 n1_474796_1373088 0.01925
R27-112-101 n1_474796_1373088 n1_493920_1373088 3.3467
R27-112-102 n1_493920_1373088 n1_532832_1373088 6.8096000000000005
R27-112-103 n1_532832_1373088 n1_570528_1373088 6.5968
R27-112-104 n1_570528_1373088 n1_609440_1373088 6.8096000000000005
R27-112-105 n1_609440_1373088 n1_647136_1373088 6.5968
R27-112-106 n1_647136_1373088 n1_686048_1373088 6.8096000000000005
R27-112-107 n1_686048_1373088 n1_723744_1373088 6.5968
R27-112-108 n1_723744_1373088 n1_761440_1373088 6.5968
R27-112-109 n1_761440_1373088 n1_800352_1373088 6.8096000000000005
R27-112-110 n1_800352_1373088 n1_838048_1373088 6.5968
R27-112-111 n1_838048_1373088 n1_876960_1373088 6.8096000000000005
R27-112-112 n1_876960_1373088 n1_914656_1373088 6.5968
R27-112-113 n1_914656_1373088 n1_952352_1373088 6.5968
R27-112-114 n1_952352_1373088 n1_991264_1373088 6.8096000000000005
R27-112-115 n1_991264_1373088 n1_1028960_1373088 6.5968
R27-112-116 n1_1028960_1373088 n1_1067872_1373088 6.8096000000000005
R27-112-117 n1_1067872_1373088 n1_1105568_1373088 6.5968
R27-112-118 n1_1105568_1373088 n1_1144480_1373088 6.8096000000000005
R27-112-119 n1_1144480_1373088 n1_1182176_1373088 6.5968
R27-112-120 n1_1182176_1373088 n1_1219872_1373088 6.5968
R27-112-121 n1_1219872_1373088 n1_1258784_1373088 6.8096000000000005
R27-112-122 n1_1258784_1373088 n1_1296480_1373088 6.5968
R27-112-123 n1_1296480_1373088 n1_1335392_1373088 6.8096000000000005
R27-112-124 n1_1335392_1373088 n1_1373088_1373088 6.5968
R27-112-125 n1_1373088_1373088 n1_1412000_1373088 6.8096000000000005
R27-112-126 n1_1412000_1373088 n1_1449696_1373088 6.5968
R27-112-127 n1_1449696_1373088 n1_1487392_1373088 6.5968
R27-112-128 n1_1487392_1373088 n1_1526304_1373088 6.8096000000000005
R27-112-129 n1_1526304_1373088 n1_1564000_1373088 6.5968
R27-112-130 n1_1564000_1373088 n1_1602912_1373088 6.8096000000000005
R27-112-131 n1_1602912_1373088 n1_1641180_1373088 6.696899999999999
R27-112-132 n1_1641180_1373088 n1_1641290_1373088 0.01925
R27-113-100 n1_474686_1412000 n1_474796_1412000 0.01925
R27-113-101 n1_474796_1412000 n1_493920_1412000 3.3467
R27-113-102 n1_493920_1412000 n1_532832_1412000 6.8096000000000005
R27-113-103 n1_532832_1412000 n1_570528_1412000 6.5968
R27-113-104 n1_570528_1412000 n1_609440_1412000 6.8096000000000005
R27-113-105 n1_609440_1412000 n1_647136_1412000 6.5968
R27-113-106 n1_647136_1412000 n1_686048_1412000 6.8096000000000005
R27-113-107 n1_686048_1412000 n1_723744_1412000 6.5968
R27-113-108 n1_723744_1412000 n1_761440_1412000 6.5968
R27-113-109 n1_761440_1412000 n1_800352_1412000 6.8096000000000005
R27-113-110 n1_800352_1412000 n1_838048_1412000 6.5968
R27-113-111 n1_838048_1412000 n1_876960_1412000 6.8096000000000005
R27-113-112 n1_876960_1412000 n1_914656_1412000 6.5968
R27-113-113 n1_914656_1412000 n1_952352_1412000 6.5968
R27-113-114 n1_952352_1412000 n1_991264_1412000 6.8096000000000005
R27-113-115 n1_991264_1412000 n1_1028960_1412000 6.5968
R27-113-116 n1_1028960_1412000 n1_1067872_1412000 6.8096000000000005
R27-113-117 n1_1067872_1412000 n1_1105568_1412000 6.5968
R27-113-118 n1_1105568_1412000 n1_1144480_1412000 6.8096000000000005
R27-113-119 n1_1144480_1412000 n1_1182176_1412000 6.5968
R27-113-120 n1_1182176_1412000 n1_1219872_1412000 6.5968
R27-113-121 n1_1219872_1412000 n1_1258784_1412000 6.8096000000000005
R27-113-122 n1_1258784_1412000 n1_1296480_1412000 6.5968
R27-113-123 n1_1296480_1412000 n1_1335392_1412000 6.8096000000000005
R27-113-124 n1_1335392_1412000 n1_1373088_1412000 6.5968
R27-113-125 n1_1373088_1412000 n1_1412000_1412000 6.8096000000000005
R27-113-126 n1_1412000_1412000 n1_1449696_1412000 6.5968
R27-113-127 n1_1449696_1412000 n1_1487392_1412000 6.5968
R27-113-128 n1_1487392_1412000 n1_1526304_1412000 6.8096000000000005
R27-113-129 n1_1526304_1412000 n1_1564000_1412000 6.5968
R27-113-130 n1_1564000_1412000 n1_1602912_1412000 6.8096000000000005
R27-113-131 n1_1602912_1412000 n1_1641180_1412000 6.696899999999999
R27-113-132 n1_1641180_1412000 n1_1641290_1412000 0.01925
R27-114-100 n1_474686_1448480 n1_474796_1448480 0.01925
R27-114-101 n1_474796_1448480 n1_493920_1448480 3.3467
R27-114-102 n1_493920_1448480 n1_532832_1448480 6.8096000000000005
R27-114-103 n1_532832_1448480 n1_570528_1448480 6.5968
R27-114-104 n1_570528_1448480 n1_609440_1448480 6.8096000000000005
R27-114-105 n1_609440_1448480 n1_647136_1448480 6.5968
R27-114-106 n1_647136_1448480 n1_686048_1448480 6.8096000000000005
R27-114-107 n1_686048_1448480 n1_723744_1448480 6.5968
R27-114-108 n1_723744_1448480 n1_761440_1448480 6.5968
R27-114-109 n1_761440_1448480 n1_800352_1448480 6.8096000000000005
R27-114-110 n1_800352_1448480 n1_838048_1448480 6.5968
R27-114-111 n1_838048_1448480 n1_876960_1448480 6.8096000000000005
R27-114-112 n1_876960_1448480 n1_914656_1448480 6.5968
R27-114-113 n1_914656_1448480 n1_952352_1448480 6.5968
R27-114-114 n1_952352_1448480 n1_991264_1448480 6.8096000000000005
R27-114-115 n1_991264_1448480 n1_1028960_1448480 6.5968
R27-114-116 n1_1028960_1448480 n1_1067872_1448480 6.8096000000000005
R27-114-117 n1_1067872_1448480 n1_1105568_1448480 6.5968
R27-114-118 n1_1105568_1448480 n1_1144480_1448480 6.8096000000000005
R27-114-119 n1_1144480_1448480 n1_1182176_1448480 6.5968
R27-114-120 n1_1182176_1448480 n1_1219872_1448480 6.5968
R27-114-121 n1_1219872_1448480 n1_1258784_1448480 6.8096000000000005
R27-114-122 n1_1258784_1448480 n1_1296480_1448480 6.5968
R27-114-123 n1_1296480_1448480 n1_1335392_1448480 6.8096000000000005
R27-114-124 n1_1335392_1448480 n1_1373088_1448480 6.5968
R27-114-125 n1_1373088_1448480 n1_1412000_1448480 6.8096000000000005
R27-114-126 n1_1412000_1448480 n1_1449696_1448480 6.5968
R27-114-127 n1_1449696_1448480 n1_1487392_1448480 6.5968
R27-114-128 n1_1487392_1448480 n1_1526304_1448480 6.8096000000000005
R27-114-129 n1_1526304_1448480 n1_1564000_1448480 6.5968
R27-114-130 n1_1564000_1448480 n1_1602912_1448480 6.8096000000000005
R27-114-131 n1_1602912_1448480 n1_1641180_1448480 6.696899999999999
R27-114-132 n1_1641180_1448480 n1_1641290_1448480 0.01925
R27-115-100 n1_474686_1487392 n1_474796_1487392 0.01925
R27-115-101 n1_474796_1487392 n1_493920_1487392 3.3467
R27-115-102 n1_493920_1487392 n1_532832_1487392 6.8096000000000005
R27-115-103 n1_532832_1487392 n1_570528_1487392 6.5968
R27-115-104 n1_570528_1487392 n1_609440_1487392 6.8096000000000005
R27-115-105 n1_609440_1487392 n1_647136_1487392 6.5968
R27-115-106 n1_647136_1487392 n1_686048_1487392 6.8096000000000005
R27-115-107 n1_686048_1487392 n1_723744_1487392 6.5968
R27-115-108 n1_723744_1487392 n1_761440_1487392 6.5968
R27-115-109 n1_761440_1487392 n1_800352_1487392 6.8096000000000005
R27-115-110 n1_800352_1487392 n1_838048_1487392 6.5968
R27-115-111 n1_838048_1487392 n1_876960_1487392 6.8096000000000005
R27-115-112 n1_876960_1487392 n1_914656_1487392 6.5968
R27-115-113 n1_914656_1487392 n1_952352_1487392 6.5968
R27-115-114 n1_952352_1487392 n1_991264_1487392 6.8096000000000005
R27-115-115 n1_991264_1487392 n1_1028960_1487392 6.5968
R27-115-116 n1_1028960_1487392 n1_1067872_1487392 6.8096000000000005
R27-115-117 n1_1067872_1487392 n1_1105568_1487392 6.5968
R27-115-118 n1_1105568_1487392 n1_1144480_1487392 6.8096000000000005
R27-115-119 n1_1144480_1487392 n1_1182176_1487392 6.5968
R27-115-120 n1_1182176_1487392 n1_1219872_1487392 6.5968
R27-115-121 n1_1219872_1487392 n1_1258784_1487392 6.8096000000000005
R27-115-122 n1_1258784_1487392 n1_1296480_1487392 6.5968
R27-115-123 n1_1296480_1487392 n1_1335392_1487392 6.8096000000000005
R27-115-124 n1_1335392_1487392 n1_1373088_1487392 6.5968
R27-115-125 n1_1373088_1487392 n1_1412000_1487392 6.8096000000000005
R27-115-126 n1_1412000_1487392 n1_1449696_1487392 6.5968
R27-115-127 n1_1449696_1487392 n1_1487392_1487392 6.5968
R27-115-128 n1_1487392_1487392 n1_1526304_1487392 6.8096000000000005
R27-115-129 n1_1526304_1487392 n1_1564000_1487392 6.5968
R27-115-130 n1_1564000_1487392 n1_1602912_1487392 6.8096000000000005
R27-115-131 n1_1602912_1487392 n1_1641180_1487392 6.696899999999999
R27-115-132 n1_1641180_1487392 n1_1641290_1487392 0.01925
R27-116-100 n1_474686_1526304 n1_474796_1526304 0.01925
R27-116-101 n1_474796_1526304 n1_493920_1526304 3.3467
R27-116-102 n1_493920_1526304 n1_532832_1526304 6.8096000000000005
R27-116-103 n1_532832_1526304 n1_570528_1526304 6.5968
R27-116-104 n1_570528_1526304 n1_609440_1526304 6.8096000000000005
R27-116-105 n1_609440_1526304 n1_647136_1526304 6.5968
R27-116-106 n1_647136_1526304 n1_686048_1526304 6.8096000000000005
R27-116-107 n1_686048_1526304 n1_723744_1526304 6.5968
R27-116-108 n1_723744_1526304 n1_761440_1526304 6.5968
R27-116-109 n1_761440_1526304 n1_800352_1526304 6.8096000000000005
R27-116-110 n1_800352_1526304 n1_838048_1526304 6.5968
R27-116-111 n1_838048_1526304 n1_876960_1526304 6.8096000000000005
R27-116-112 n1_876960_1526304 n1_914656_1526304 6.5968
R27-116-113 n1_914656_1526304 n1_952352_1526304 6.5968
R27-116-114 n1_952352_1526304 n1_991264_1526304 6.8096000000000005
R27-116-115 n1_991264_1526304 n1_1028960_1526304 6.5968
R27-116-116 n1_1028960_1526304 n1_1067872_1526304 6.8096000000000005
R27-116-117 n1_1067872_1526304 n1_1105568_1526304 6.5968
R27-116-118 n1_1105568_1526304 n1_1144480_1526304 6.8096000000000005
R27-116-119 n1_1144480_1526304 n1_1182176_1526304 6.5968
R27-116-120 n1_1182176_1526304 n1_1219872_1526304 6.5968
R27-116-121 n1_1219872_1526304 n1_1258784_1526304 6.8096000000000005
R27-116-122 n1_1258784_1526304 n1_1296480_1526304 6.5968
R27-116-123 n1_1296480_1526304 n1_1335392_1526304 6.8096000000000005
R27-116-124 n1_1335392_1526304 n1_1373088_1526304 6.5968
R27-116-125 n1_1373088_1526304 n1_1412000_1526304 6.8096000000000005
R27-116-126 n1_1412000_1526304 n1_1449696_1526304 6.5968
R27-116-127 n1_1449696_1526304 n1_1487392_1526304 6.5968
R27-116-128 n1_1487392_1526304 n1_1526304_1526304 6.8096000000000005
R27-116-129 n1_1526304_1526304 n1_1564000_1526304 6.5968
R27-116-130 n1_1564000_1526304 n1_1602912_1526304 6.8096000000000005
R27-116-131 n1_1602912_1526304 n1_1641180_1526304 6.696899999999999
R27-116-132 n1_1641180_1526304 n1_1641290_1526304 0.01925
R27-117-100 n1_474686_1562784 n1_474796_1562784 0.01925
R27-117-101 n1_474796_1562784 n1_493920_1562784 3.3467
R27-117-102 n1_493920_1562784 n1_532832_1562784 6.8096000000000005
R27-117-103 n1_532832_1562784 n1_570528_1562784 6.5968
R27-117-104 n1_570528_1562784 n1_609440_1562784 6.8096000000000005
R27-117-105 n1_609440_1562784 n1_647136_1562784 6.5968
R27-117-106 n1_647136_1562784 n1_686048_1562784 6.8096000000000005
R27-117-107 n1_686048_1562784 n1_723744_1562784 6.5968
R27-117-108 n1_723744_1562784 n1_761440_1562784 6.5968
R27-117-109 n1_761440_1562784 n1_800352_1562784 6.8096000000000005
R27-117-110 n1_800352_1562784 n1_838048_1562784 6.5968
R27-117-111 n1_838048_1562784 n1_876960_1562784 6.8096000000000005
R27-117-112 n1_876960_1562784 n1_914656_1562784 6.5968
R27-117-113 n1_914656_1562784 n1_952352_1562784 6.5968
R27-117-114 n1_952352_1562784 n1_991264_1562784 6.8096000000000005
R27-117-115 n1_991264_1562784 n1_1028960_1562784 6.5968
R27-117-116 n1_1028960_1562784 n1_1067872_1562784 6.8096000000000005
R27-117-117 n1_1067872_1562784 n1_1105568_1562784 6.5968
R27-117-118 n1_1105568_1562784 n1_1144480_1562784 6.8096000000000005
R27-117-119 n1_1144480_1562784 n1_1182176_1562784 6.5968
R27-117-120 n1_1182176_1562784 n1_1219872_1562784 6.5968
R27-117-121 n1_1219872_1562784 n1_1258784_1562784 6.8096000000000005
R27-117-122 n1_1258784_1562784 n1_1296480_1562784 6.5968
R27-117-123 n1_1296480_1562784 n1_1335392_1562784 6.8096000000000005
R27-117-124 n1_1335392_1562784 n1_1373088_1562784 6.5968
R27-117-125 n1_1373088_1562784 n1_1412000_1562784 6.8096000000000005
R27-117-126 n1_1412000_1562784 n1_1449696_1562784 6.5968
R27-117-127 n1_1449696_1562784 n1_1487392_1562784 6.5968
R27-117-128 n1_1487392_1562784 n1_1526304_1562784 6.8096000000000005
R27-117-129 n1_1526304_1562784 n1_1564000_1562784 6.5968
R27-117-130 n1_1564000_1562784 n1_1602912_1562784 6.8096000000000005
R27-117-131 n1_1602912_1562784 n1_1641180_1562784 6.696899999999999
R27-117-132 n1_1641180_1562784 n1_1641290_1562784 0.01925
R27-118-100 n1_474686_1601696 n1_474796_1601696 0.01925
R27-118-101 n1_474796_1601696 n1_493920_1601696 3.3467
R27-118-102 n1_493920_1601696 n1_532832_1601696 6.8096000000000005
R27-118-103 n1_532832_1601696 n1_570528_1601696 6.5968
R27-118-104 n1_570528_1601696 n1_609440_1601696 6.8096000000000005
R27-118-105 n1_609440_1601696 n1_647136_1601696 6.5968
R27-118-106 n1_647136_1601696 n1_686048_1601696 6.8096000000000005
R27-118-107 n1_686048_1601696 n1_723744_1601696 6.5968
R27-118-108 n1_723744_1601696 n1_761440_1601696 6.5968
R27-118-109 n1_761440_1601696 n1_800352_1601696 6.8096000000000005
R27-118-110 n1_800352_1601696 n1_838048_1601696 6.5968
R27-118-111 n1_838048_1601696 n1_876960_1601696 6.8096000000000005
R27-118-112 n1_876960_1601696 n1_914656_1601696 6.5968
R27-118-113 n1_914656_1601696 n1_952352_1601696 6.5968
R27-118-114 n1_952352_1601696 n1_991264_1601696 6.8096000000000005
R27-118-115 n1_991264_1601696 n1_1028960_1601696 6.5968
R27-118-116 n1_1028960_1601696 n1_1067872_1601696 6.8096000000000005
R27-118-117 n1_1067872_1601696 n1_1105568_1601696 6.5968
R27-118-118 n1_1105568_1601696 n1_1144480_1601696 6.8096000000000005
R27-118-119 n1_1144480_1601696 n1_1182176_1601696 6.5968
R27-118-120 n1_1182176_1601696 n1_1219872_1601696 6.5968
R27-118-121 n1_1219872_1601696 n1_1258784_1601696 6.8096000000000005
R27-118-122 n1_1258784_1601696 n1_1296480_1601696 6.5968
R27-118-123 n1_1296480_1601696 n1_1335392_1601696 6.8096000000000005
R27-118-124 n1_1335392_1601696 n1_1373088_1601696 6.5968
R27-118-125 n1_1373088_1601696 n1_1412000_1601696 6.8096000000000005
R27-118-126 n1_1412000_1601696 n1_1449696_1601696 6.5968
R27-118-127 n1_1449696_1601696 n1_1487392_1601696 6.5968
R27-118-128 n1_1487392_1601696 n1_1526304_1601696 6.8096000000000005
R27-118-129 n1_1526304_1601696 n1_1564000_1601696 6.5968
R27-118-130 n1_1564000_1601696 n1_1602912_1601696 6.8096000000000005
R27-118-131 n1_1602912_1601696 n1_1641180_1601696 6.696899999999999
R27-118-132 n1_1641180_1601696 n1_1641290_1601696 0.01925
R27-119-100 n1_474686_1641130 n1_474796_1641130 0.009625
R27-119-101 n1_474796_1641130 n1_493920_1641130 1.67335
R27-119-102 n1_493920_1641130 n1_532832_1641130 3.4048000000000003
R27-119-103 n1_532832_1641130 n1_570528_1641130 3.2984
R27-119-104 n1_570528_1641130 n1_609440_1641130 3.4048000000000003
R27-119-105 n1_609440_1641130 n1_647136_1641130 3.2984
R27-119-106 n1_647136_1641130 n1_686048_1641130 3.4048000000000003
R27-119-107 n1_686048_1641130 n1_723744_1641130 3.2984
R27-119-108 n1_723744_1641130 n1_761440_1641130 3.2984
R27-119-109 n1_761440_1641130 n1_800352_1641130 3.4048000000000003
R27-119-110 n1_800352_1641130 n1_838048_1641130 3.2984
R27-119-111 n1_838048_1641130 n1_876960_1641130 3.4048000000000003
R27-119-112 n1_876960_1641130 n1_914656_1641130 3.2984
R27-119-113 n1_914656_1641130 n1_952352_1641130 3.2984
R27-119-114 n1_952352_1641130 n1_979937_1641130 2.41369
R27-119-115 n1_979937_1641130 n1_991264_1641130 0.991113
R27-119-116 n1_991264_1641130 n1_1028960_1641130 3.2984
R27-119-117 n1_1028960_1641130 n1_1067872_1641130 3.4048000000000003
R27-119-118 n1_1067872_1641130 n1_1105568_1641130 3.2984
R27-119-119 n1_1105568_1641130 n1_1144480_1641130 3.4048000000000003
R27-119-120 n1_1144480_1641130 n1_1182176_1641130 3.2984
R27-119-121 n1_1182176_1641130 n1_1219872_1641130 3.2984
R27-119-122 n1_1219872_1641130 n1_1258784_1641130 3.4048000000000003
R27-119-123 n1_1258784_1641130 n1_1296480_1641130 3.2984
R27-119-124 n1_1296480_1641130 n1_1335392_1641130 3.4048000000000003
R27-119-125 n1_1335392_1641130 n1_1373088_1641130 3.2984
R27-119-126 n1_1373088_1641130 n1_1412000_1641130 3.4048000000000003
R27-119-127 n1_1412000_1641130 n1_1449696_1641130 3.2984
R27-119-128 n1_1449696_1641130 n1_1487392_1641130 3.2984
R27-119-129 n1_1487392_1641130 n1_1526304_1641130 3.4048000000000003
R27-119-130 n1_1526304_1641130 n1_1564000_1641130 3.2984
R27-119-131 n1_1564000_1641130 n1_1602912_1641130 3.4048000000000003
R27-119-132 n1_1602912_1641130 n1_1641180_1641130 3.3484499999999997
R27-119-133 n1_1641180_1641130 n1_1641290_1641130 0.009625
R27-120-100 n1_1641070_1619905 n1_1641180_1619905 0.0162105
R27-120-101 n1_1641180_1619905 n1_1820088_1619905 26.3654
R27-120-102 n1_1820088_1619905 n1_1825088_1619905 0.736842
R27-121-100 n1_474686_918304 n1_474796_918304 0.01925
R27-121-101 n1_474796_918304 n1_493920_918304 3.3467
R27-121-102 n1_493920_918304 n1_532832_918304 6.8096000000000005
R27-121-103 n1_532832_918304 n1_570528_918304 6.5968
R27-121-104 n1_570528_918304 n1_609440_918304 6.8096000000000005
R27-121-105 n1_609440_918304 n1_647136_918304 6.5968
R27-121-106 n1_647136_918304 n1_686048_918304 6.8096000000000005
R27-121-107 n1_686048_918304 n1_723744_918304 6.5968
R27-121-108 n1_723744_918304 n1_761440_918304 6.5968
R27-121-109 n1_761440_918304 n1_800352_918304 6.8096000000000005
R27-121-110 n1_800352_918304 n1_838048_918304 6.5968
R27-121-111 n1_838048_918304 n1_876960_918304 6.8096000000000005
R27-121-112 n1_876960_918304 n1_914656_918304 6.5968
R27-121-113 n1_914656_918304 n1_952352_918304 6.5968
R27-121-114 n1_952352_918304 n1_991264_918304 6.8096000000000005
R27-121-115 n1_991264_918304 n1_1028960_918304 6.5968
R27-121-116 n1_1028960_918304 n1_1067872_918304 6.8096000000000005
R27-121-117 n1_1067872_918304 n1_1105568_918304 6.5968
R27-121-118 n1_1105568_918304 n1_1144480_918304 6.8096000000000005
R27-121-119 n1_1144480_918304 n1_1182176_918304 6.5968
R27-121-120 n1_1182176_918304 n1_1219872_918304 6.5968
R27-121-121 n1_1219872_918304 n1_1258784_918304 6.8096000000000005
R27-121-122 n1_1258784_918304 n1_1296480_918304 6.5968
R27-121-123 n1_1296480_918304 n1_1335392_918304 6.8096000000000005
R27-121-124 n1_1335392_918304 n1_1373088_918304 6.5968
R27-121-125 n1_1373088_918304 n1_1412000_918304 6.8096000000000005
R27-121-126 n1_1412000_918304 n1_1449696_918304 6.5968
R27-121-127 n1_1449696_918304 n1_1487392_918304 6.5968
R27-121-128 n1_1487392_918304 n1_1526304_918304 6.8096000000000005
R27-121-129 n1_1526304_918304 n1_1564000_918304 6.5968
R27-121-130 n1_1564000_918304 n1_1602912_918304 6.8096000000000005
R27-121-131 n1_1602912_918304 n1_1641180_918304 6.696899999999999
R27-121-132 n1_1641180_918304 n1_1641290_918304 0.01925
R27-122-100 n1_474686_881824 n1_474796_881824 0.01925
R27-122-101 n1_474796_881824 n1_493920_881824 3.3467
R27-122-102 n1_493920_881824 n1_532832_881824 6.8096000000000005
R27-122-103 n1_532832_881824 n1_570528_881824 6.5968
R27-122-104 n1_570528_881824 n1_609440_881824 6.8096000000000005
R27-122-105 n1_609440_881824 n1_647136_881824 6.5968
R27-122-106 n1_647136_881824 n1_686048_881824 6.8096000000000005
R27-122-107 n1_686048_881824 n1_723744_881824 6.5968
R27-122-108 n1_723744_881824 n1_761440_881824 6.5968
R27-122-109 n1_761440_881824 n1_800352_881824 6.8096000000000005
R27-122-110 n1_800352_881824 n1_838048_881824 6.5968
R27-122-111 n1_838048_881824 n1_876960_881824 6.8096000000000005
R27-122-112 n1_876960_881824 n1_914656_881824 6.5968
R27-122-113 n1_914656_881824 n1_952352_881824 6.5968
R27-122-114 n1_952352_881824 n1_991264_881824 6.8096000000000005
R27-122-115 n1_991264_881824 n1_1028960_881824 6.5968
R27-122-116 n1_1028960_881824 n1_1067872_881824 6.8096000000000005
R27-122-117 n1_1067872_881824 n1_1105568_881824 6.5968
R27-122-118 n1_1105568_881824 n1_1144480_881824 6.8096000000000005
R27-122-119 n1_1144480_881824 n1_1182176_881824 6.5968
R27-122-120 n1_1182176_881824 n1_1219872_881824 6.5968
R27-122-121 n1_1219872_881824 n1_1258784_881824 6.8096000000000005
R27-122-122 n1_1258784_881824 n1_1296480_881824 6.5968
R27-122-123 n1_1296480_881824 n1_1335392_881824 6.8096000000000005
R27-122-124 n1_1335392_881824 n1_1373088_881824 6.5968
R27-122-125 n1_1373088_881824 n1_1412000_881824 6.8096000000000005
R27-122-126 n1_1412000_881824 n1_1449696_881824 6.5968
R27-122-127 n1_1449696_881824 n1_1487392_881824 6.5968
R27-122-128 n1_1487392_881824 n1_1526304_881824 6.8096000000000005
R27-122-129 n1_1526304_881824 n1_1564000_881824 6.5968
R27-122-130 n1_1564000_881824 n1_1602912_881824 6.8096000000000005
R27-122-131 n1_1602912_881824 n1_1641180_881824 6.696899999999999
R27-122-132 n1_1641180_881824 n1_1641290_881824 0.01925
R27-123-100 n1_474686_842912 n1_474796_842912 0.01925
R27-123-101 n1_474796_842912 n1_493920_842912 3.3467
R27-123-102 n1_493920_842912 n1_532832_842912 6.8096000000000005
R27-123-103 n1_532832_842912 n1_570528_842912 6.5968
R27-123-104 n1_570528_842912 n1_609440_842912 6.8096000000000005
R27-123-105 n1_609440_842912 n1_647136_842912 6.5968
R27-123-106 n1_647136_842912 n1_686048_842912 6.8096000000000005
R27-123-107 n1_686048_842912 n1_723744_842912 6.5968
R27-123-108 n1_723744_842912 n1_761440_842912 6.5968
R27-123-109 n1_761440_842912 n1_800352_842912 6.8096000000000005
R27-123-110 n1_800352_842912 n1_838048_842912 6.5968
R27-123-111 n1_838048_842912 n1_876960_842912 6.8096000000000005
R27-123-112 n1_876960_842912 n1_914656_842912 6.5968
R27-123-113 n1_914656_842912 n1_952352_842912 6.5968
R27-123-114 n1_952352_842912 n1_991264_842912 6.8096000000000005
R27-123-115 n1_991264_842912 n1_1028960_842912 6.5968
R27-123-116 n1_1028960_842912 n1_1067872_842912 6.8096000000000005
R27-123-117 n1_1067872_842912 n1_1105568_842912 6.5968
R27-123-118 n1_1105568_842912 n1_1144480_842912 6.8096000000000005
R27-123-119 n1_1144480_842912 n1_1182176_842912 6.5968
R27-123-120 n1_1182176_842912 n1_1219872_842912 6.5968
R27-123-121 n1_1219872_842912 n1_1258784_842912 6.8096000000000005
R27-123-122 n1_1258784_842912 n1_1296480_842912 6.5968
R27-123-123 n1_1296480_842912 n1_1335392_842912 6.8096000000000005
R27-123-124 n1_1335392_842912 n1_1373088_842912 6.5968
R27-123-125 n1_1373088_842912 n1_1412000_842912 6.8096000000000005
R27-123-126 n1_1412000_842912 n1_1449696_842912 6.5968
R27-123-127 n1_1449696_842912 n1_1487392_842912 6.5968
R27-123-128 n1_1487392_842912 n1_1526304_842912 6.8096000000000005
R27-123-129 n1_1526304_842912 n1_1564000_842912 6.5968
R27-123-130 n1_1564000_842912 n1_1602912_842912 6.8096000000000005
R27-123-131 n1_1602912_842912 n1_1641180_842912 6.696899999999999
R27-123-132 n1_1641180_842912 n1_1641290_842912 0.01925
R27-124-100 n1_474686_804000 n1_474796_804000 0.01925
R27-124-101 n1_474796_804000 n1_493920_804000 3.3467
R27-124-102 n1_493920_804000 n1_532832_804000 6.8096000000000005
R27-124-103 n1_532832_804000 n1_570528_804000 6.5968
R27-124-104 n1_570528_804000 n1_609440_804000 6.8096000000000005
R27-124-105 n1_609440_804000 n1_647136_804000 6.5968
R27-124-106 n1_647136_804000 n1_686048_804000 6.8096000000000005
R27-124-107 n1_686048_804000 n1_723744_804000 6.5968
R27-124-108 n1_723744_804000 n1_761440_804000 6.5968
R27-124-109 n1_761440_804000 n1_800352_804000 6.8096000000000005
R27-124-110 n1_800352_804000 n1_838048_804000 6.5968
R27-124-111 n1_838048_804000 n1_876960_804000 6.8096000000000005
R27-124-112 n1_876960_804000 n1_914656_804000 6.5968
R27-124-113 n1_914656_804000 n1_952352_804000 6.5968
R27-124-114 n1_952352_804000 n1_991264_804000 6.8096000000000005
R27-124-115 n1_991264_804000 n1_1028960_804000 6.5968
R27-124-116 n1_1028960_804000 n1_1067872_804000 6.8096000000000005
R27-124-117 n1_1067872_804000 n1_1105568_804000 6.5968
R27-124-118 n1_1105568_804000 n1_1144480_804000 6.8096000000000005
R27-124-119 n1_1144480_804000 n1_1182176_804000 6.5968
R27-124-120 n1_1182176_804000 n1_1219872_804000 6.5968
R27-124-121 n1_1219872_804000 n1_1258784_804000 6.8096000000000005
R27-124-122 n1_1258784_804000 n1_1296480_804000 6.5968
R27-124-123 n1_1296480_804000 n1_1335392_804000 6.8096000000000005
R27-124-124 n1_1335392_804000 n1_1373088_804000 6.5968
R27-124-125 n1_1373088_804000 n1_1412000_804000 6.8096000000000005
R27-124-126 n1_1412000_804000 n1_1449696_804000 6.5968
R27-124-127 n1_1449696_804000 n1_1487392_804000 6.5968
R27-124-128 n1_1487392_804000 n1_1526304_804000 6.8096000000000005
R27-124-129 n1_1526304_804000 n1_1564000_804000 6.5968
R27-124-130 n1_1564000_804000 n1_1602912_804000 6.8096000000000005
R27-124-131 n1_1602912_804000 n1_1641180_804000 6.696899999999999
R27-124-132 n1_1641180_804000 n1_1641290_804000 0.01925
R27-125-100 n1_474686_767520 n1_474796_767520 0.01925
R27-125-101 n1_474796_767520 n1_493920_767520 3.3467
R27-125-102 n1_493920_767520 n1_532832_767520 6.8096000000000005
R27-125-103 n1_532832_767520 n1_570528_767520 6.5968
R27-125-104 n1_570528_767520 n1_609440_767520 6.8096000000000005
R27-125-105 n1_609440_767520 n1_647136_767520 6.5968
R27-125-106 n1_647136_767520 n1_686048_767520 6.8096000000000005
R27-125-107 n1_686048_767520 n1_723744_767520 6.5968
R27-125-108 n1_723744_767520 n1_761440_767520 6.5968
R27-125-109 n1_761440_767520 n1_800352_767520 6.8096000000000005
R27-125-110 n1_800352_767520 n1_838048_767520 6.5968
R27-125-111 n1_838048_767520 n1_876960_767520 6.8096000000000005
R27-125-112 n1_876960_767520 n1_914656_767520 6.5968
R27-125-113 n1_914656_767520 n1_952352_767520 6.5968
R27-125-114 n1_952352_767520 n1_991264_767520 6.8096000000000005
R27-125-115 n1_991264_767520 n1_1028960_767520 6.5968
R27-125-116 n1_1028960_767520 n1_1067872_767520 6.8096000000000005
R27-125-117 n1_1067872_767520 n1_1105568_767520 6.5968
R27-125-118 n1_1105568_767520 n1_1144480_767520 6.8096000000000005
R27-125-119 n1_1144480_767520 n1_1182176_767520 6.5968
R27-125-120 n1_1182176_767520 n1_1219872_767520 6.5968
R27-125-121 n1_1219872_767520 n1_1258784_767520 6.8096000000000005
R27-125-122 n1_1258784_767520 n1_1296480_767520 6.5968
R27-125-123 n1_1296480_767520 n1_1335392_767520 6.8096000000000005
R27-125-124 n1_1335392_767520 n1_1373088_767520 6.5968
R27-125-125 n1_1373088_767520 n1_1412000_767520 6.8096000000000005
R27-125-126 n1_1412000_767520 n1_1449696_767520 6.5968
R27-125-127 n1_1449696_767520 n1_1487392_767520 6.5968
R27-125-128 n1_1487392_767520 n1_1526304_767520 6.8096000000000005
R27-125-129 n1_1526304_767520 n1_1564000_767520 6.5968
R27-125-130 n1_1564000_767520 n1_1602912_767520 6.8096000000000005
R27-125-131 n1_1602912_767520 n1_1641180_767520 6.696899999999999
R27-125-132 n1_1641180_767520 n1_1641290_767520 0.01925
R27-126-100 n1_474686_728608 n1_474796_728608 0.01925
R27-126-101 n1_474796_728608 n1_493920_728608 3.3467
R27-126-102 n1_493920_728608 n1_532832_728608 6.8096000000000005
R27-126-103 n1_532832_728608 n1_570528_728608 6.5968
R27-126-104 n1_570528_728608 n1_609440_728608 6.8096000000000005
R27-126-105 n1_609440_728608 n1_647136_728608 6.5968
R27-126-106 n1_647136_728608 n1_686048_728608 6.8096000000000005
R27-126-107 n1_686048_728608 n1_723744_728608 6.5968
R27-126-108 n1_723744_728608 n1_761440_728608 6.5968
R27-126-109 n1_761440_728608 n1_800352_728608 6.8096000000000005
R27-126-110 n1_800352_728608 n1_838048_728608 6.5968
R27-126-111 n1_838048_728608 n1_876960_728608 6.8096000000000005
R27-126-112 n1_876960_728608 n1_914656_728608 6.5968
R27-126-113 n1_914656_728608 n1_952352_728608 6.5968
R27-126-114 n1_952352_728608 n1_991264_728608 6.8096000000000005
R27-126-115 n1_991264_728608 n1_1028960_728608 6.5968
R27-126-116 n1_1028960_728608 n1_1067872_728608 6.8096000000000005
R27-126-117 n1_1067872_728608 n1_1105568_728608 6.5968
R27-126-118 n1_1105568_728608 n1_1144480_728608 6.8096000000000005
R27-126-119 n1_1144480_728608 n1_1182176_728608 6.5968
R27-126-120 n1_1182176_728608 n1_1219872_728608 6.5968
R27-126-121 n1_1219872_728608 n1_1258784_728608 6.8096000000000005
R27-126-122 n1_1258784_728608 n1_1296480_728608 6.5968
R27-126-123 n1_1296480_728608 n1_1335392_728608 6.8096000000000005
R27-126-124 n1_1335392_728608 n1_1373088_728608 6.5968
R27-126-125 n1_1373088_728608 n1_1412000_728608 6.8096000000000005
R27-126-126 n1_1412000_728608 n1_1449696_728608 6.5968
R27-126-127 n1_1449696_728608 n1_1487392_728608 6.5968
R27-126-128 n1_1487392_728608 n1_1526304_728608 6.8096000000000005
R27-126-129 n1_1526304_728608 n1_1564000_728608 6.5968
R27-126-130 n1_1564000_728608 n1_1602912_728608 6.8096000000000005
R27-126-131 n1_1602912_728608 n1_1641180_728608 6.696899999999999
R27-126-132 n1_1641180_728608 n1_1641290_728608 0.01925
R27-127-100 n1_474686_692128 n1_474796_692128 0.01925
R27-127-101 n1_474796_692128 n1_493920_692128 3.3467
R27-127-102 n1_493920_692128 n1_532832_692128 6.8096000000000005
R27-127-103 n1_532832_692128 n1_570528_692128 6.5968
R27-127-104 n1_570528_692128 n1_609440_692128 6.8096000000000005
R27-127-105 n1_609440_692128 n1_647136_692128 6.5968
R27-127-106 n1_647136_692128 n1_686048_692128 6.8096000000000005
R27-127-107 n1_686048_692128 n1_723744_692128 6.5968
R27-127-108 n1_723744_692128 n1_761440_692128 6.5968
R27-127-109 n1_761440_692128 n1_800352_692128 6.8096000000000005
R27-127-110 n1_800352_692128 n1_838048_692128 6.5968
R27-127-111 n1_838048_692128 n1_876960_692128 6.8096000000000005
R27-127-112 n1_876960_692128 n1_914656_692128 6.5968
R27-127-113 n1_914656_692128 n1_952352_692128 6.5968
R27-127-114 n1_952352_692128 n1_991264_692128 6.8096000000000005
R27-127-115 n1_991264_692128 n1_1028960_692128 6.5968
R27-127-116 n1_1028960_692128 n1_1067872_692128 6.8096000000000005
R27-127-117 n1_1067872_692128 n1_1105568_692128 6.5968
R27-127-118 n1_1105568_692128 n1_1144480_692128 6.8096000000000005
R27-127-119 n1_1144480_692128 n1_1182176_692128 6.5968
R27-127-120 n1_1182176_692128 n1_1219872_692128 6.5968
R27-127-121 n1_1219872_692128 n1_1258784_692128 6.8096000000000005
R27-127-122 n1_1258784_692128 n1_1296480_692128 6.5968
R27-127-123 n1_1296480_692128 n1_1335392_692128 6.8096000000000005
R27-127-124 n1_1335392_692128 n1_1373088_692128 6.5968
R27-127-125 n1_1373088_692128 n1_1412000_692128 6.8096000000000005
R27-127-126 n1_1412000_692128 n1_1449696_692128 6.5968
R27-127-127 n1_1449696_692128 n1_1487392_692128 6.5968
R27-127-128 n1_1487392_692128 n1_1526304_692128 6.8096000000000005
R27-127-129 n1_1526304_692128 n1_1564000_692128 6.5968
R27-127-130 n1_1564000_692128 n1_1602912_692128 6.8096000000000005
R27-127-131 n1_1602912_692128 n1_1641180_692128 6.696899999999999
R27-127-132 n1_1641180_692128 n1_1641290_692128 0.01925
R27-128-100 n1_474686_653216 n1_474796_653216 0.01925
R27-128-101 n1_474796_653216 n1_493920_653216 3.3467
R27-128-102 n1_493920_653216 n1_532832_653216 6.8096000000000005
R27-128-103 n1_532832_653216 n1_570528_653216 6.5968
R27-128-104 n1_570528_653216 n1_609440_653216 6.8096000000000005
R27-128-105 n1_609440_653216 n1_647136_653216 6.5968
R27-128-106 n1_647136_653216 n1_686048_653216 6.8096000000000005
R27-128-107 n1_686048_653216 n1_723744_653216 6.5968
R27-128-108 n1_723744_653216 n1_761440_653216 6.5968
R27-128-109 n1_761440_653216 n1_800352_653216 6.8096000000000005
R27-128-110 n1_800352_653216 n1_838048_653216 6.5968
R27-128-111 n1_838048_653216 n1_876960_653216 6.8096000000000005
R27-128-112 n1_876960_653216 n1_914656_653216 6.5968
R27-128-113 n1_914656_653216 n1_952352_653216 6.5968
R27-128-114 n1_952352_653216 n1_991264_653216 6.8096000000000005
R27-128-115 n1_991264_653216 n1_1028960_653216 6.5968
R27-128-116 n1_1028960_653216 n1_1067872_653216 6.8096000000000005
R27-128-117 n1_1067872_653216 n1_1105568_653216 6.5968
R27-128-118 n1_1105568_653216 n1_1144480_653216 6.8096000000000005
R27-128-119 n1_1144480_653216 n1_1182176_653216 6.5968
R27-128-120 n1_1182176_653216 n1_1219872_653216 6.5968
R27-128-121 n1_1219872_653216 n1_1258784_653216 6.8096000000000005
R27-128-122 n1_1258784_653216 n1_1296480_653216 6.5968
R27-128-123 n1_1296480_653216 n1_1335392_653216 6.8096000000000005
R27-128-124 n1_1335392_653216 n1_1373088_653216 6.5968
R27-128-125 n1_1373088_653216 n1_1412000_653216 6.8096000000000005
R27-128-126 n1_1412000_653216 n1_1449696_653216 6.5968
R27-128-127 n1_1449696_653216 n1_1487392_653216 6.5968
R27-128-128 n1_1487392_653216 n1_1526304_653216 6.8096000000000005
R27-128-129 n1_1526304_653216 n1_1564000_653216 6.5968
R27-128-130 n1_1564000_653216 n1_1602912_653216 6.8096000000000005
R27-128-131 n1_1602912_653216 n1_1641180_653216 6.696899999999999
R27-128-132 n1_1641180_653216 n1_1641290_653216 0.01925
R27-129-100 n1_474686_614304 n1_474796_614304 0.01925
R27-129-101 n1_474796_614304 n1_493920_614304 3.3467
R27-129-102 n1_493920_614304 n1_532832_614304 6.8096000000000005
R27-129-103 n1_532832_614304 n1_570528_614304 6.5968
R27-129-104 n1_570528_614304 n1_609440_614304 6.8096000000000005
R27-129-105 n1_609440_614304 n1_647136_614304 6.5968
R27-129-106 n1_647136_614304 n1_686048_614304 6.8096000000000005
R27-129-107 n1_686048_614304 n1_723744_614304 6.5968
R27-129-108 n1_723744_614304 n1_761440_614304 6.5968
R27-129-109 n1_761440_614304 n1_800352_614304 6.8096000000000005
R27-129-110 n1_800352_614304 n1_838048_614304 6.5968
R27-129-111 n1_838048_614304 n1_876960_614304 6.8096000000000005
R27-129-112 n1_876960_614304 n1_914656_614304 6.5968
R27-129-113 n1_914656_614304 n1_952352_614304 6.5968
R27-129-114 n1_952352_614304 n1_991264_614304 6.8096000000000005
R27-129-115 n1_991264_614304 n1_1028960_614304 6.5968
R27-129-116 n1_1028960_614304 n1_1067872_614304 6.8096000000000005
R27-129-117 n1_1067872_614304 n1_1105568_614304 6.5968
R27-129-118 n1_1105568_614304 n1_1144480_614304 6.8096000000000005
R27-129-119 n1_1144480_614304 n1_1182176_614304 6.5968
R27-129-120 n1_1182176_614304 n1_1219872_614304 6.5968
R27-129-121 n1_1219872_614304 n1_1258784_614304 6.8096000000000005
R27-129-122 n1_1258784_614304 n1_1296480_614304 6.5968
R27-129-123 n1_1296480_614304 n1_1335392_614304 6.8096000000000005
R27-129-124 n1_1335392_614304 n1_1373088_614304 6.5968
R27-129-125 n1_1373088_614304 n1_1412000_614304 6.8096000000000005
R27-129-126 n1_1412000_614304 n1_1449696_614304 6.5968
R27-129-127 n1_1449696_614304 n1_1487392_614304 6.5968
R27-129-128 n1_1487392_614304 n1_1526304_614304 6.8096000000000005
R27-129-129 n1_1526304_614304 n1_1564000_614304 6.5968
R27-129-130 n1_1564000_614304 n1_1602912_614304 6.8096000000000005
R27-129-131 n1_1602912_614304 n1_1641180_614304 6.696899999999999
R27-129-132 n1_1641180_614304 n1_1641290_614304 0.01925
R27-130-100 n1_474686_577824 n1_474796_577824 0.01925
R27-130-101 n1_474796_577824 n1_493920_577824 3.3467
R27-130-102 n1_493920_577824 n1_532832_577824 6.8096000000000005
R27-130-103 n1_532832_577824 n1_570528_577824 6.5968
R27-130-104 n1_570528_577824 n1_609440_577824 6.8096000000000005
R27-130-105 n1_609440_577824 n1_647136_577824 6.5968
R27-130-106 n1_647136_577824 n1_686048_577824 6.8096000000000005
R27-130-107 n1_686048_577824 n1_723744_577824 6.5968
R27-130-108 n1_723744_577824 n1_761440_577824 6.5968
R27-130-109 n1_761440_577824 n1_800352_577824 6.8096000000000005
R27-130-110 n1_800352_577824 n1_838048_577824 6.5968
R27-130-111 n1_838048_577824 n1_876960_577824 6.8096000000000005
R27-130-112 n1_876960_577824 n1_914656_577824 6.5968
R27-130-113 n1_914656_577824 n1_952352_577824 6.5968
R27-130-114 n1_952352_577824 n1_991264_577824 6.8096000000000005
R27-130-115 n1_991264_577824 n1_1028960_577824 6.5968
R27-130-116 n1_1028960_577824 n1_1067872_577824 6.8096000000000005
R27-130-117 n1_1067872_577824 n1_1105568_577824 6.5968
R27-130-118 n1_1105568_577824 n1_1144480_577824 6.8096000000000005
R27-130-119 n1_1144480_577824 n1_1182176_577824 6.5968
R27-130-120 n1_1182176_577824 n1_1219872_577824 6.5968
R27-130-121 n1_1219872_577824 n1_1258784_577824 6.8096000000000005
R27-130-122 n1_1258784_577824 n1_1296480_577824 6.5968
R27-130-123 n1_1296480_577824 n1_1335392_577824 6.8096000000000005
R27-130-124 n1_1335392_577824 n1_1373088_577824 6.5968
R27-130-125 n1_1373088_577824 n1_1412000_577824 6.8096000000000005
R27-130-126 n1_1412000_577824 n1_1449696_577824 6.5968
R27-130-127 n1_1449696_577824 n1_1487392_577824 6.5968
R27-130-128 n1_1487392_577824 n1_1526304_577824 6.8096000000000005
R27-130-129 n1_1526304_577824 n1_1564000_577824 6.5968
R27-130-130 n1_1564000_577824 n1_1602912_577824 6.8096000000000005
R27-130-131 n1_1602912_577824 n1_1641180_577824 6.696899999999999
R27-130-132 n1_1641180_577824 n1_1641290_577824 0.01925
R27-131-100 n1_474686_538912 n1_474796_538912 0.01925
R27-131-101 n1_474796_538912 n1_493920_538912 3.3467
R27-131-102 n1_493920_538912 n1_532832_538912 6.8096000000000005
R27-131-103 n1_532832_538912 n1_570528_538912 6.5968
R27-131-104 n1_570528_538912 n1_609440_538912 6.8096000000000005
R27-131-105 n1_609440_538912 n1_647136_538912 6.5968
R27-131-106 n1_647136_538912 n1_686048_538912 6.8096000000000005
R27-131-107 n1_686048_538912 n1_723744_538912 6.5968
R27-131-108 n1_723744_538912 n1_761440_538912 6.5968
R27-131-109 n1_761440_538912 n1_800352_538912 6.8096000000000005
R27-131-110 n1_800352_538912 n1_838048_538912 6.5968
R27-131-111 n1_838048_538912 n1_876960_538912 6.8096000000000005
R27-131-112 n1_876960_538912 n1_914656_538912 6.5968
R27-131-113 n1_914656_538912 n1_952352_538912 6.5968
R27-131-114 n1_952352_538912 n1_991264_538912 6.8096000000000005
R27-131-115 n1_991264_538912 n1_1028960_538912 6.5968
R27-131-116 n1_1028960_538912 n1_1067872_538912 6.8096000000000005
R27-131-117 n1_1067872_538912 n1_1105568_538912 6.5968
R27-131-118 n1_1105568_538912 n1_1144480_538912 6.8096000000000005
R27-131-119 n1_1144480_538912 n1_1182176_538912 6.5968
R27-131-120 n1_1182176_538912 n1_1219872_538912 6.5968
R27-131-121 n1_1219872_538912 n1_1258784_538912 6.8096000000000005
R27-131-122 n1_1258784_538912 n1_1296480_538912 6.5968
R27-131-123 n1_1296480_538912 n1_1335392_538912 6.8096000000000005
R27-131-124 n1_1335392_538912 n1_1373088_538912 6.5968
R27-131-125 n1_1373088_538912 n1_1412000_538912 6.8096000000000005
R27-131-126 n1_1412000_538912 n1_1449696_538912 6.5968
R27-131-127 n1_1449696_538912 n1_1487392_538912 6.5968
R27-131-128 n1_1487392_538912 n1_1526304_538912 6.8096000000000005
R27-131-129 n1_1526304_538912 n1_1564000_538912 6.5968
R27-131-130 n1_1564000_538912 n1_1602912_538912 6.8096000000000005
R27-131-131 n1_1602912_538912 n1_1641180_538912 6.696899999999999
R27-131-132 n1_1641180_538912 n1_1641290_538912 0.01925
R27-132-100 n1_474686_502432 n1_474796_502432 0.01925
R27-132-101 n1_474796_502432 n1_493920_502432 3.3467
R27-132-102 n1_493920_502432 n1_532832_502432 6.8096000000000005
R27-132-103 n1_532832_502432 n1_570528_502432 6.5968
R27-132-104 n1_570528_502432 n1_609440_502432 6.8096000000000005
R27-132-105 n1_609440_502432 n1_647136_502432 6.5968
R27-132-106 n1_647136_502432 n1_686048_502432 6.8096000000000005
R27-132-107 n1_686048_502432 n1_723744_502432 6.5968
R27-132-108 n1_723744_502432 n1_761440_502432 6.5968
R27-132-109 n1_761440_502432 n1_800352_502432 6.8096000000000005
R27-132-110 n1_800352_502432 n1_838048_502432 6.5968
R27-132-111 n1_838048_502432 n1_876960_502432 6.8096000000000005
R27-132-112 n1_876960_502432 n1_914656_502432 6.5968
R27-132-113 n1_914656_502432 n1_952352_502432 6.5968
R27-132-114 n1_952352_502432 n1_991264_502432 6.8096000000000005
R27-132-115 n1_991264_502432 n1_1028960_502432 6.5968
R27-132-116 n1_1028960_502432 n1_1067872_502432 6.8096000000000005
R27-132-117 n1_1067872_502432 n1_1105568_502432 6.5968
R27-132-118 n1_1105568_502432 n1_1144480_502432 6.8096000000000005
R27-132-119 n1_1144480_502432 n1_1182176_502432 6.5968
R27-132-120 n1_1182176_502432 n1_1219872_502432 6.5968
R27-132-121 n1_1219872_502432 n1_1258784_502432 6.8096000000000005
R27-132-122 n1_1258784_502432 n1_1296480_502432 6.5968
R27-132-123 n1_1296480_502432 n1_1335392_502432 6.8096000000000005
R27-132-124 n1_1335392_502432 n1_1373088_502432 6.5968
R27-132-125 n1_1373088_502432 n1_1412000_502432 6.8096000000000005
R27-132-126 n1_1412000_502432 n1_1449696_502432 6.5968
R27-132-127 n1_1449696_502432 n1_1487392_502432 6.5968
R27-132-128 n1_1487392_502432 n1_1526304_502432 6.8096000000000005
R27-132-129 n1_1526304_502432 n1_1564000_502432 6.5968
R27-132-130 n1_1564000_502432 n1_1602912_502432 6.8096000000000005
R27-132-131 n1_1602912_502432 n1_1641180_502432 6.696899999999999
R27-132-132 n1_1641180_502432 n1_1641290_502432 0.01925
R27-133-100 n1_474686_480880 n1_474796_480880 0.009625
R27-133-101 n1_474796_480880 n1_493920_480880 1.67335
R27-133-102 n1_493920_480880 n1_532832_480880 3.4048000000000003
R27-133-103 n1_532832_480880 n1_570528_480880 3.2984
R27-133-104 n1_570528_480880 n1_609440_480880 3.4048000000000003
R27-133-105 n1_609440_480880 n1_647136_480880 3.2984
R27-133-106 n1_647136_480880 n1_686048_480880 3.4048000000000003
R27-133-107 n1_686048_480880 n1_723744_480880 3.2984
R27-133-108 n1_723744_480880 n1_761440_480880 3.2984
R27-133-109 n1_761440_480880 n1_800352_480880 3.4048000000000003
R27-133-110 n1_800352_480880 n1_838048_480880 3.2984
R27-133-111 n1_838048_480880 n1_876960_480880 3.4048000000000003
R27-133-112 n1_876960_480880 n1_914656_480880 3.2984
R27-133-113 n1_914656_480880 n1_952352_480880 3.2984
R27-133-114 n1_952352_480880 n1_991264_480880 3.4048000000000003
R27-133-115 n1_991264_480880 n1_1028960_480880 3.2984
R27-133-116 n1_1028960_480880 n1_1067872_480880 3.4048000000000003
R27-133-117 n1_1067872_480880 n1_1105568_480880 3.2984
R27-133-118 n1_1105568_480880 n1_1144480_480880 3.4048000000000003
R27-133-119 n1_1144480_480880 n1_1182176_480880 3.2984
R27-133-120 n1_1182176_480880 n1_1219872_480880 3.2984
R27-133-121 n1_1219872_480880 n1_1258784_480880 3.4048000000000003
R27-133-122 n1_1258784_480880 n1_1296480_480880 3.2984
R27-133-123 n1_1296480_480880 n1_1335392_480880 3.4048000000000003
R27-133-124 n1_1335392_480880 n1_1373088_480880 3.2984
R27-133-125 n1_1373088_480880 n1_1412000_480880 3.4048000000000003
R27-133-126 n1_1412000_480880 n1_1449696_480880 3.2984
R27-133-127 n1_1449696_480880 n1_1487392_480880 3.2984
R27-133-128 n1_1487392_480880 n1_1526304_480880 3.4048000000000003
R27-133-129 n1_1526304_480880 n1_1564000_480880 3.2984
R27-133-130 n1_1564000_480880 n1_1602912_480880 3.4048000000000003
R27-133-131 n1_1602912_480880 n1_1620161_480880 1.50929
R27-133-132 n1_1620161_480880 n1_1641180_480880 1.8391600000000001
R27-133-133 n1_1641180_480880 n1_1641290_480880 0.009625
R25-100-100 n1_474796_480880 n1_474796_480720 0.00727273
R25-100-101 n1_474796_502432 n1_474796_480880 0.979636
R25-100-102 n1_474796_538912 n1_474796_502432 1.6581800000000002
R25-100-103 n1_474796_577824 n1_474796_538912 1.7687300000000001
R25-100-104 n1_474796_614304 n1_474796_577824 1.6581800000000002
R25-100-105 n1_474796_653216 n1_474796_614304 1.7687300000000001
R25-100-106 n1_474796_692128 n1_474796_653216 1.7687300000000001
R25-100-107 n1_474796_728608 n1_474796_692128 1.6581800000000002
R25-100-108 n1_474796_767520 n1_474796_728608 1.7687300000000001
R25-100-109 n1_474796_804000 n1_474796_767520 1.6581800000000002
R25-100-110 n1_474796_842912 n1_474796_804000 1.7687300000000001
R25-100-111 n1_474796_881824 n1_474796_842912 1.7687300000000001
R25-100-112 n1_474796_918304 n1_474796_881824 1.6581800000000002
R25-100-113 n1_474796_940095 n1_474796_918304 0.9904999999999999
R25-100-114 n1_474796_957216 n1_474796_940095 0.778227
R25-100-115 n1_474796_993696 n1_474796_957216 1.6581800000000002
R25-100-116 n1_474796_1032608 n1_474796_993696 1.7687300000000001
R25-100-117 n1_474796_1071520 n1_474796_1032608 1.7687300000000001
R25-100-118 n1_474796_1108000 n1_474796_1071520 1.6581800000000002
R25-100-119 n1_474796_1146912 n1_474796_1108000 1.7687300000000001
R25-100-120 n1_474796_1183392 n1_474796_1146912 1.6581800000000002
R25-100-121 n1_474796_1222304 n1_474796_1183392 1.7687300000000001
R25-100-122 n1_474796_1261216 n1_474796_1222304 1.7687300000000001
R25-100-123 n1_474796_1297696 n1_474796_1261216 1.6581800000000002
R25-100-124 n1_474796_1336608 n1_474796_1297696 1.7687300000000001
R25-100-125 n1_474796_1373088 n1_474796_1336608 1.6581800000000002
R25-100-126 n1_474796_1412000 n1_474796_1373088 1.7687300000000001
R25-100-127 n1_474796_1448480 n1_474796_1412000 1.6581800000000002
R25-100-128 n1_474796_1487392 n1_474796_1448480 1.7687300000000001
R25-100-129 n1_474796_1526304 n1_474796_1487392 1.7687300000000001
R25-100-130 n1_474796_1562784 n1_474796_1526304 1.6581800000000002
R25-100-131 n1_474796_1601696 n1_474796_1562784 1.7687300000000001
R25-100-132 n1_474796_1641130 n1_474796_1601696 1.7924499999999999
R25-100-133 n1_474796_1641290 n1_474796_1641130 0.00727273
R25-101-100 n1_493920_480880 n1_493920_480720 0.0145455
R25-101-101 n1_493920_502432 n1_493920_480880 1.95927
R25-101-102 n1_493920_538912 n1_493920_502432 3.3163600000000004
R25-101-103 n1_493920_577824 n1_493920_538912 3.5374499999999998
R25-101-104 n1_493920_614304 n1_493920_577824 3.3163600000000004
R25-101-105 n1_493920_653216 n1_493920_614304 3.5374499999999998
R25-101-106 n1_493920_692128 n1_493920_653216 3.5374499999999998
R25-101-107 n1_493920_728608 n1_493920_692128 3.3163600000000004
R25-101-108 n1_493920_767520 n1_493920_728608 3.5374499999999998
R25-101-109 n1_493920_804000 n1_493920_767520 3.3163600000000004
R25-101-110 n1_493920_842912 n1_493920_804000 3.5374499999999998
R25-101-111 n1_493920_881824 n1_493920_842912 3.5374499999999998
R25-101-112 n1_493920_918304 n1_493920_881824 3.3163600000000004
R25-101-113 n1_493920_957216 n1_493920_918304 3.5374499999999998
R25-101-114 n1_493920_993696 n1_493920_957216 3.3163600000000004
R25-101-115 n1_493920_1032608 n1_493920_993696 3.5374499999999998
R25-101-116 n1_493920_1071520 n1_493920_1032608 3.5374499999999998
R25-101-117 n1_493920_1108000 n1_493920_1071520 3.3163600000000004
R25-101-118 n1_493920_1146912 n1_493920_1108000 3.5374499999999998
R25-101-119 n1_493920_1183392 n1_493920_1146912 3.3163600000000004
R25-101-120 n1_493920_1222304 n1_493920_1183392 3.5374499999999998
R25-101-121 n1_493920_1261216 n1_493920_1222304 3.5374499999999998
R25-101-122 n1_493920_1297696 n1_493920_1261216 3.3163600000000004
R25-101-123 n1_493920_1336608 n1_493920_1297696 3.5374499999999998
R25-101-124 n1_493920_1373088 n1_493920_1336608 3.3163600000000004
R25-101-125 n1_493920_1412000 n1_493920_1373088 3.5374499999999998
R25-101-126 n1_493920_1448480 n1_493920_1412000 3.3163600000000004
R25-101-127 n1_493920_1487392 n1_493920_1448480 3.5374499999999998
R25-101-128 n1_493920_1526304 n1_493920_1487392 3.5374499999999998
R25-101-129 n1_493920_1562784 n1_493920_1526304 3.3163600000000004
R25-101-130 n1_493920_1601696 n1_493920_1562784 3.5374499999999998
R25-101-131 n1_493920_1641130 n1_493920_1601696 3.58491
R25-101-132 n1_493920_1641290 n1_493920_1641130 0.0145455
R25-102-100 n1_532832_480880 n1_532832_480720 0.0145455
R25-102-101 n1_532832_502432 n1_532832_480880 1.95927
R25-102-102 n1_532832_538912 n1_532832_502432 3.3163600000000004
R25-102-103 n1_532832_577824 n1_532832_538912 3.5374499999999998
R25-102-104 n1_532832_614304 n1_532832_577824 3.3163600000000004
R25-102-105 n1_532832_653216 n1_532832_614304 3.5374499999999998
R25-102-106 n1_532832_692128 n1_532832_653216 3.5374499999999998
R25-102-107 n1_532832_728608 n1_532832_692128 3.3163600000000004
R25-102-108 n1_532832_767520 n1_532832_728608 3.5374499999999998
R25-102-109 n1_532832_804000 n1_532832_767520 3.3163600000000004
R25-102-110 n1_532832_842912 n1_532832_804000 3.5374499999999998
R25-102-111 n1_532832_881824 n1_532832_842912 3.5374499999999998
R25-102-112 n1_532832_918304 n1_532832_881824 3.3163600000000004
R25-102-113 n1_532832_957216 n1_532832_918304 3.5374499999999998
R25-102-114 n1_532832_993696 n1_532832_957216 3.3163600000000004
R25-102-115 n1_532832_1032608 n1_532832_993696 3.5374499999999998
R25-102-116 n1_532832_1071520 n1_532832_1032608 3.5374499999999998
R25-102-117 n1_532832_1108000 n1_532832_1071520 3.3163600000000004
R25-102-118 n1_532832_1146912 n1_532832_1108000 3.5374499999999998
R25-102-119 n1_532832_1183392 n1_532832_1146912 3.3163600000000004
R25-102-120 n1_532832_1222304 n1_532832_1183392 3.5374499999999998
R25-102-121 n1_532832_1261216 n1_532832_1222304 3.5374499999999998
R25-102-122 n1_532832_1297696 n1_532832_1261216 3.3163600000000004
R25-102-123 n1_532832_1336608 n1_532832_1297696 3.5374499999999998
R25-102-124 n1_532832_1373088 n1_532832_1336608 3.3163600000000004
R25-102-125 n1_532832_1412000 n1_532832_1373088 3.5374499999999998
R25-102-126 n1_532832_1448480 n1_532832_1412000 3.3163600000000004
R25-102-127 n1_532832_1487392 n1_532832_1448480 3.5374499999999998
R25-102-128 n1_532832_1526304 n1_532832_1487392 3.5374499999999998
R25-102-129 n1_532832_1562784 n1_532832_1526304 3.3163600000000004
R25-102-130 n1_532832_1601696 n1_532832_1562784 3.5374499999999998
R25-102-131 n1_532832_1641130 n1_532832_1601696 3.58491
R25-102-132 n1_532832_1641290 n1_532832_1641130 0.0145455
R25-103-100 n1_570528_480880 n1_570528_480720 0.0145455
R25-103-101 n1_570528_502432 n1_570528_480880 1.95927
R25-103-102 n1_570528_538912 n1_570528_502432 3.3163600000000004
R25-103-103 n1_570528_577824 n1_570528_538912 3.5374499999999998
R25-103-104 n1_570528_614304 n1_570528_577824 3.3163600000000004
R25-103-105 n1_570528_653216 n1_570528_614304 3.5374499999999998
R25-103-106 n1_570528_692128 n1_570528_653216 3.5374499999999998
R25-103-107 n1_570528_728608 n1_570528_692128 3.3163600000000004
R25-103-108 n1_570528_767520 n1_570528_728608 3.5374499999999998
R25-103-109 n1_570528_804000 n1_570528_767520 3.3163600000000004
R25-103-110 n1_570528_842912 n1_570528_804000 3.5374499999999998
R25-103-111 n1_570528_881824 n1_570528_842912 3.5374499999999998
R25-103-112 n1_570528_918304 n1_570528_881824 3.3163600000000004
R25-103-113 n1_570528_957216 n1_570528_918304 3.5374499999999998
R25-103-114 n1_570528_993696 n1_570528_957216 3.3163600000000004
R25-103-115 n1_570528_1032608 n1_570528_993696 3.5374499999999998
R25-103-116 n1_570528_1071520 n1_570528_1032608 3.5374499999999998
R25-103-117 n1_570528_1108000 n1_570528_1071520 3.3163600000000004
R25-103-118 n1_570528_1146912 n1_570528_1108000 3.5374499999999998
R25-103-119 n1_570528_1183392 n1_570528_1146912 3.3163600000000004
R25-103-120 n1_570528_1222304 n1_570528_1183392 3.5374499999999998
R25-103-121 n1_570528_1261216 n1_570528_1222304 3.5374499999999998
R25-103-122 n1_570528_1297696 n1_570528_1261216 3.3163600000000004
R25-103-123 n1_570528_1336608 n1_570528_1297696 3.5374499999999998
R25-103-124 n1_570528_1373088 n1_570528_1336608 3.3163600000000004
R25-103-125 n1_570528_1412000 n1_570528_1373088 3.5374499999999998
R25-103-126 n1_570528_1448480 n1_570528_1412000 3.3163600000000004
R25-103-127 n1_570528_1487392 n1_570528_1448480 3.5374499999999998
R25-103-128 n1_570528_1526304 n1_570528_1487392 3.5374499999999998
R25-103-129 n1_570528_1562784 n1_570528_1526304 3.3163600000000004
R25-103-130 n1_570528_1601696 n1_570528_1562784 3.5374499999999998
R25-103-131 n1_570528_1641130 n1_570528_1601696 3.58491
R25-103-132 n1_570528_1641290 n1_570528_1641130 0.0145455
R25-104-100 n1_609440_480880 n1_609440_480720 0.0145455
R25-104-101 n1_609440_502432 n1_609440_480880 1.95927
R25-104-102 n1_609440_538912 n1_609440_502432 3.3163600000000004
R25-104-103 n1_609440_577824 n1_609440_538912 3.5374499999999998
R25-104-104 n1_609440_614304 n1_609440_577824 3.3163600000000004
R25-104-105 n1_609440_653216 n1_609440_614304 3.5374499999999998
R25-104-106 n1_609440_692128 n1_609440_653216 3.5374499999999998
R25-104-107 n1_609440_728608 n1_609440_692128 3.3163600000000004
R25-104-108 n1_609440_767520 n1_609440_728608 3.5374499999999998
R25-104-109 n1_609440_804000 n1_609440_767520 3.3163600000000004
R25-104-110 n1_609440_842912 n1_609440_804000 3.5374499999999998
R25-104-111 n1_609440_881824 n1_609440_842912 3.5374499999999998
R25-104-112 n1_609440_918304 n1_609440_881824 3.3163600000000004
R25-104-113 n1_609440_957216 n1_609440_918304 3.5374499999999998
R25-104-114 n1_609440_993696 n1_609440_957216 3.3163600000000004
R25-104-115 n1_609440_1032608 n1_609440_993696 3.5374499999999998
R25-104-116 n1_609440_1071520 n1_609440_1032608 3.5374499999999998
R25-104-117 n1_609440_1108000 n1_609440_1071520 3.3163600000000004
R25-104-118 n1_609440_1146912 n1_609440_1108000 3.5374499999999998
R25-104-119 n1_609440_1183392 n1_609440_1146912 3.3163600000000004
R25-104-120 n1_609440_1222304 n1_609440_1183392 3.5374499999999998
R25-104-121 n1_609440_1261216 n1_609440_1222304 3.5374499999999998
R25-104-122 n1_609440_1297696 n1_609440_1261216 3.3163600000000004
R25-104-123 n1_609440_1336608 n1_609440_1297696 3.5374499999999998
R25-104-124 n1_609440_1373088 n1_609440_1336608 3.3163600000000004
R25-104-125 n1_609440_1412000 n1_609440_1373088 3.5374499999999998
R25-104-126 n1_609440_1448480 n1_609440_1412000 3.3163600000000004
R25-104-127 n1_609440_1487392 n1_609440_1448480 3.5374499999999998
R25-104-128 n1_609440_1526304 n1_609440_1487392 3.5374499999999998
R25-104-129 n1_609440_1562784 n1_609440_1526304 3.3163600000000004
R25-104-130 n1_609440_1601696 n1_609440_1562784 3.5374499999999998
R25-104-131 n1_609440_1641130 n1_609440_1601696 3.58491
R25-104-132 n1_609440_1641290 n1_609440_1641130 0.0145455
R25-105-100 n1_647136_480880 n1_647136_480720 0.0145455
R25-105-101 n1_647136_502432 n1_647136_480880 1.95927
R25-105-102 n1_647136_538912 n1_647136_502432 3.3163600000000004
R25-105-103 n1_647136_577824 n1_647136_538912 3.5374499999999998
R25-105-104 n1_647136_614304 n1_647136_577824 3.3163600000000004
R25-105-105 n1_647136_653216 n1_647136_614304 3.5374499999999998
R25-105-106 n1_647136_692128 n1_647136_653216 3.5374499999999998
R25-105-107 n1_647136_728608 n1_647136_692128 3.3163600000000004
R25-105-108 n1_647136_767520 n1_647136_728608 3.5374499999999998
R25-105-109 n1_647136_804000 n1_647136_767520 3.3163600000000004
R25-105-110 n1_647136_842912 n1_647136_804000 3.5374499999999998
R25-105-111 n1_647136_881824 n1_647136_842912 3.5374499999999998
R25-105-112 n1_647136_918304 n1_647136_881824 3.3163600000000004
R25-105-113 n1_647136_957216 n1_647136_918304 3.5374499999999998
R25-105-114 n1_647136_993696 n1_647136_957216 3.3163600000000004
R25-105-115 n1_647136_1032608 n1_647136_993696 3.5374499999999998
R25-105-116 n1_647136_1071520 n1_647136_1032608 3.5374499999999998
R25-105-117 n1_647136_1108000 n1_647136_1071520 3.3163600000000004
R25-105-118 n1_647136_1146912 n1_647136_1108000 3.5374499999999998
R25-105-119 n1_647136_1183392 n1_647136_1146912 3.3163600000000004
R25-105-120 n1_647136_1222304 n1_647136_1183392 3.5374499999999998
R25-105-121 n1_647136_1261216 n1_647136_1222304 3.5374499999999998
R25-105-122 n1_647136_1297696 n1_647136_1261216 3.3163600000000004
R25-105-123 n1_647136_1336608 n1_647136_1297696 3.5374499999999998
R25-105-124 n1_647136_1373088 n1_647136_1336608 3.3163600000000004
R25-105-125 n1_647136_1412000 n1_647136_1373088 3.5374499999999998
R25-105-126 n1_647136_1448480 n1_647136_1412000 3.3163600000000004
R25-105-127 n1_647136_1487392 n1_647136_1448480 3.5374499999999998
R25-105-128 n1_647136_1526304 n1_647136_1487392 3.5374499999999998
R25-105-129 n1_647136_1562784 n1_647136_1526304 3.3163600000000004
R25-105-130 n1_647136_1601696 n1_647136_1562784 3.5374499999999998
R25-105-131 n1_647136_1641130 n1_647136_1601696 3.58491
R25-105-132 n1_647136_1641290 n1_647136_1641130 0.0145455
R25-106-100 n1_686048_480880 n1_686048_480720 0.0145455
R25-106-101 n1_686048_502432 n1_686048_480880 1.95927
R25-106-102 n1_686048_538912 n1_686048_502432 3.3163600000000004
R25-106-103 n1_686048_577824 n1_686048_538912 3.5374499999999998
R25-106-104 n1_686048_614304 n1_686048_577824 3.3163600000000004
R25-106-105 n1_686048_653216 n1_686048_614304 3.5374499999999998
R25-106-106 n1_686048_692128 n1_686048_653216 3.5374499999999998
R25-106-107 n1_686048_728608 n1_686048_692128 3.3163600000000004
R25-106-108 n1_686048_767520 n1_686048_728608 3.5374499999999998
R25-106-109 n1_686048_804000 n1_686048_767520 3.3163600000000004
R25-106-110 n1_686048_842912 n1_686048_804000 3.5374499999999998
R25-106-111 n1_686048_881824 n1_686048_842912 3.5374499999999998
R25-106-112 n1_686048_918304 n1_686048_881824 3.3163600000000004
R25-106-113 n1_686048_957216 n1_686048_918304 3.5374499999999998
R25-106-114 n1_686048_993696 n1_686048_957216 3.3163600000000004
R25-106-115 n1_686048_1032608 n1_686048_993696 3.5374499999999998
R25-106-116 n1_686048_1071520 n1_686048_1032608 3.5374499999999998
R25-106-117 n1_686048_1108000 n1_686048_1071520 3.3163600000000004
R25-106-118 n1_686048_1146912 n1_686048_1108000 3.5374499999999998
R25-106-119 n1_686048_1183392 n1_686048_1146912 3.3163600000000004
R25-106-120 n1_686048_1222304 n1_686048_1183392 3.5374499999999998
R25-106-121 n1_686048_1261216 n1_686048_1222304 3.5374499999999998
R25-106-122 n1_686048_1297696 n1_686048_1261216 3.3163600000000004
R25-106-123 n1_686048_1336608 n1_686048_1297696 3.5374499999999998
R25-106-124 n1_686048_1373088 n1_686048_1336608 3.3163600000000004
R25-106-125 n1_686048_1412000 n1_686048_1373088 3.5374499999999998
R25-106-126 n1_686048_1448480 n1_686048_1412000 3.3163600000000004
R25-106-127 n1_686048_1487392 n1_686048_1448480 3.5374499999999998
R25-106-128 n1_686048_1526304 n1_686048_1487392 3.5374499999999998
R25-106-129 n1_686048_1562784 n1_686048_1526304 3.3163600000000004
R25-106-130 n1_686048_1601696 n1_686048_1562784 3.5374499999999998
R25-106-131 n1_686048_1641130 n1_686048_1601696 3.58491
R25-106-132 n1_686048_1641290 n1_686048_1641130 0.0145455
R25-107-100 n1_723744_480880 n1_723744_480720 0.0145455
R25-107-101 n1_723744_502432 n1_723744_480880 1.95927
R25-107-102 n1_723744_538912 n1_723744_502432 3.3163600000000004
R25-107-103 n1_723744_577824 n1_723744_538912 3.5374499999999998
R25-107-104 n1_723744_614304 n1_723744_577824 3.3163600000000004
R25-107-105 n1_723744_653216 n1_723744_614304 3.5374499999999998
R25-107-106 n1_723744_692128 n1_723744_653216 3.5374499999999998
R25-107-107 n1_723744_728608 n1_723744_692128 3.3163600000000004
R25-107-108 n1_723744_767520 n1_723744_728608 3.5374499999999998
R25-107-109 n1_723744_804000 n1_723744_767520 3.3163600000000004
R25-107-110 n1_723744_842912 n1_723744_804000 3.5374499999999998
R25-107-111 n1_723744_881824 n1_723744_842912 3.5374499999999998
R25-107-112 n1_723744_918304 n1_723744_881824 3.3163600000000004
R25-107-113 n1_723744_957216 n1_723744_918304 3.5374499999999998
R25-107-114 n1_723744_993696 n1_723744_957216 3.3163600000000004
R25-107-115 n1_723744_1032608 n1_723744_993696 3.5374499999999998
R25-107-116 n1_723744_1071520 n1_723744_1032608 3.5374499999999998
R25-107-117 n1_723744_1108000 n1_723744_1071520 3.3163600000000004
R25-107-118 n1_723744_1146912 n1_723744_1108000 3.5374499999999998
R25-107-119 n1_723744_1183392 n1_723744_1146912 3.3163600000000004
R25-107-120 n1_723744_1222304 n1_723744_1183392 3.5374499999999998
R25-107-121 n1_723744_1261216 n1_723744_1222304 3.5374499999999998
R25-107-122 n1_723744_1297696 n1_723744_1261216 3.3163600000000004
R25-107-123 n1_723744_1336608 n1_723744_1297696 3.5374499999999998
R25-107-124 n1_723744_1373088 n1_723744_1336608 3.3163600000000004
R25-107-125 n1_723744_1412000 n1_723744_1373088 3.5374499999999998
R25-107-126 n1_723744_1448480 n1_723744_1412000 3.3163600000000004
R25-107-127 n1_723744_1487392 n1_723744_1448480 3.5374499999999998
R25-107-128 n1_723744_1526304 n1_723744_1487392 3.5374499999999998
R25-107-129 n1_723744_1562784 n1_723744_1526304 3.3163600000000004
R25-107-130 n1_723744_1601696 n1_723744_1562784 3.5374499999999998
R25-107-131 n1_723744_1641130 n1_723744_1601696 3.58491
R25-107-132 n1_723744_1641290 n1_723744_1641130 0.0145455
R25-108-100 n1_761440_480880 n1_761440_480720 0.0145455
R25-108-101 n1_761440_502432 n1_761440_480880 1.95927
R25-108-102 n1_761440_538912 n1_761440_502432 3.3163600000000004
R25-108-103 n1_761440_577824 n1_761440_538912 3.5374499999999998
R25-108-104 n1_761440_614304 n1_761440_577824 3.3163600000000004
R25-108-105 n1_761440_653216 n1_761440_614304 3.5374499999999998
R25-108-106 n1_761440_692128 n1_761440_653216 3.5374499999999998
R25-108-107 n1_761440_728608 n1_761440_692128 3.3163600000000004
R25-108-108 n1_761440_767520 n1_761440_728608 3.5374499999999998
R25-108-109 n1_761440_804000 n1_761440_767520 3.3163600000000004
R25-108-110 n1_761440_842912 n1_761440_804000 3.5374499999999998
R25-108-111 n1_761440_881824 n1_761440_842912 3.5374499999999998
R25-108-112 n1_761440_918304 n1_761440_881824 3.3163600000000004
R25-108-113 n1_761440_957216 n1_761440_918304 3.5374499999999998
R25-108-114 n1_761440_993696 n1_761440_957216 3.3163600000000004
R25-108-115 n1_761440_1032608 n1_761440_993696 3.5374499999999998
R25-108-116 n1_761440_1071520 n1_761440_1032608 3.5374499999999998
R25-108-117 n1_761440_1108000 n1_761440_1071520 3.3163600000000004
R25-108-118 n1_761440_1146912 n1_761440_1108000 3.5374499999999998
R25-108-119 n1_761440_1183392 n1_761440_1146912 3.3163600000000004
R25-108-120 n1_761440_1222304 n1_761440_1183392 3.5374499999999998
R25-108-121 n1_761440_1261216 n1_761440_1222304 3.5374499999999998
R25-108-122 n1_761440_1297696 n1_761440_1261216 3.3163600000000004
R25-108-123 n1_761440_1336608 n1_761440_1297696 3.5374499999999998
R25-108-124 n1_761440_1373088 n1_761440_1336608 3.3163600000000004
R25-108-125 n1_761440_1412000 n1_761440_1373088 3.5374499999999998
R25-108-126 n1_761440_1448480 n1_761440_1412000 3.3163600000000004
R25-108-127 n1_761440_1487392 n1_761440_1448480 3.5374499999999998
R25-108-128 n1_761440_1526304 n1_761440_1487392 3.5374499999999998
R25-108-129 n1_761440_1562784 n1_761440_1526304 3.3163600000000004
R25-108-130 n1_761440_1601696 n1_761440_1562784 3.5374499999999998
R25-108-131 n1_761440_1641130 n1_761440_1601696 3.58491
R25-108-132 n1_761440_1641290 n1_761440_1641130 0.0145455
R25-109-100 n1_800352_480880 n1_800352_480720 0.0145455
R25-109-101 n1_800352_502432 n1_800352_480880 1.95927
R25-109-102 n1_800352_538912 n1_800352_502432 3.3163600000000004
R25-109-103 n1_800352_577824 n1_800352_538912 3.5374499999999998
R25-109-104 n1_800352_614304 n1_800352_577824 3.3163600000000004
R25-109-105 n1_800352_653216 n1_800352_614304 3.5374499999999998
R25-109-106 n1_800352_692128 n1_800352_653216 3.5374499999999998
R25-109-107 n1_800352_728608 n1_800352_692128 3.3163600000000004
R25-109-108 n1_800352_767520 n1_800352_728608 3.5374499999999998
R25-109-109 n1_800352_804000 n1_800352_767520 3.3163600000000004
R25-109-110 n1_800352_842912 n1_800352_804000 3.5374499999999998
R25-109-111 n1_800352_881824 n1_800352_842912 3.5374499999999998
R25-109-112 n1_800352_918304 n1_800352_881824 3.3163600000000004
R25-109-113 n1_800352_957216 n1_800352_918304 3.5374499999999998
R25-109-114 n1_800352_993696 n1_800352_957216 3.3163600000000004
R25-109-115 n1_800352_1032608 n1_800352_993696 3.5374499999999998
R25-109-116 n1_800352_1071520 n1_800352_1032608 3.5374499999999998
R25-109-117 n1_800352_1108000 n1_800352_1071520 3.3163600000000004
R25-109-118 n1_800352_1146912 n1_800352_1108000 3.5374499999999998
R25-109-119 n1_800352_1183392 n1_800352_1146912 3.3163600000000004
R25-109-120 n1_800352_1222304 n1_800352_1183392 3.5374499999999998
R25-109-121 n1_800352_1261216 n1_800352_1222304 3.5374499999999998
R25-109-122 n1_800352_1297696 n1_800352_1261216 3.3163600000000004
R25-109-123 n1_800352_1336608 n1_800352_1297696 3.5374499999999998
R25-109-124 n1_800352_1373088 n1_800352_1336608 3.3163600000000004
R25-109-125 n1_800352_1412000 n1_800352_1373088 3.5374499999999998
R25-109-126 n1_800352_1448480 n1_800352_1412000 3.3163600000000004
R25-109-127 n1_800352_1487392 n1_800352_1448480 3.5374499999999998
R25-109-128 n1_800352_1526304 n1_800352_1487392 3.5374499999999998
R25-109-129 n1_800352_1562784 n1_800352_1526304 3.3163600000000004
R25-109-130 n1_800352_1601696 n1_800352_1562784 3.5374499999999998
R25-109-131 n1_800352_1641130 n1_800352_1601696 3.58491
R25-109-132 n1_800352_1641290 n1_800352_1641130 0.0145455
R25-110-100 n1_838048_480880 n1_838048_480720 0.0145455
R25-110-101 n1_838048_502432 n1_838048_480880 1.95927
R25-110-102 n1_838048_538912 n1_838048_502432 3.3163600000000004
R25-110-103 n1_838048_577824 n1_838048_538912 3.5374499999999998
R25-110-104 n1_838048_614304 n1_838048_577824 3.3163600000000004
R25-110-105 n1_838048_653216 n1_838048_614304 3.5374499999999998
R25-110-106 n1_838048_692128 n1_838048_653216 3.5374499999999998
R25-110-107 n1_838048_728608 n1_838048_692128 3.3163600000000004
R25-110-108 n1_838048_767520 n1_838048_728608 3.5374499999999998
R25-110-109 n1_838048_804000 n1_838048_767520 3.3163600000000004
R25-110-110 n1_838048_842912 n1_838048_804000 3.5374499999999998
R25-110-111 n1_838048_881824 n1_838048_842912 3.5374499999999998
R25-110-112 n1_838048_918304 n1_838048_881824 3.3163600000000004
R25-110-113 n1_838048_957216 n1_838048_918304 3.5374499999999998
R25-110-114 n1_838048_993696 n1_838048_957216 3.3163600000000004
R25-110-115 n1_838048_1032608 n1_838048_993696 3.5374499999999998
R25-110-116 n1_838048_1071520 n1_838048_1032608 3.5374499999999998
R25-110-117 n1_838048_1108000 n1_838048_1071520 3.3163600000000004
R25-110-118 n1_838048_1146912 n1_838048_1108000 3.5374499999999998
R25-110-119 n1_838048_1183392 n1_838048_1146912 3.3163600000000004
R25-110-120 n1_838048_1222304 n1_838048_1183392 3.5374499999999998
R25-110-121 n1_838048_1261216 n1_838048_1222304 3.5374499999999998
R25-110-122 n1_838048_1297696 n1_838048_1261216 3.3163600000000004
R25-110-123 n1_838048_1336608 n1_838048_1297696 3.5374499999999998
R25-110-124 n1_838048_1373088 n1_838048_1336608 3.3163600000000004
R25-110-125 n1_838048_1412000 n1_838048_1373088 3.5374499999999998
R25-110-126 n1_838048_1448480 n1_838048_1412000 3.3163600000000004
R25-110-127 n1_838048_1487392 n1_838048_1448480 3.5374499999999998
R25-110-128 n1_838048_1526304 n1_838048_1487392 3.5374499999999998
R25-110-129 n1_838048_1562784 n1_838048_1526304 3.3163600000000004
R25-110-130 n1_838048_1601696 n1_838048_1562784 3.5374499999999998
R25-110-131 n1_838048_1641130 n1_838048_1601696 3.58491
R25-110-132 n1_838048_1641290 n1_838048_1641130 0.0145455
R25-111-100 n1_876960_480880 n1_876960_480720 0.0145455
R25-111-101 n1_876960_502432 n1_876960_480880 1.95927
R25-111-102 n1_876960_538912 n1_876960_502432 3.3163600000000004
R25-111-103 n1_876960_577824 n1_876960_538912 3.5374499999999998
R25-111-104 n1_876960_614304 n1_876960_577824 3.3163600000000004
R25-111-105 n1_876960_653216 n1_876960_614304 3.5374499999999998
R25-111-106 n1_876960_692128 n1_876960_653216 3.5374499999999998
R25-111-107 n1_876960_728608 n1_876960_692128 3.3163600000000004
R25-111-108 n1_876960_767520 n1_876960_728608 3.5374499999999998
R25-111-109 n1_876960_804000 n1_876960_767520 3.3163600000000004
R25-111-110 n1_876960_842912 n1_876960_804000 3.5374499999999998
R25-111-111 n1_876960_881824 n1_876960_842912 3.5374499999999998
R25-111-112 n1_876960_918304 n1_876960_881824 3.3163600000000004
R25-111-113 n1_876960_957216 n1_876960_918304 3.5374499999999998
R25-111-114 n1_876960_993696 n1_876960_957216 3.3163600000000004
R25-111-115 n1_876960_1032608 n1_876960_993696 3.5374499999999998
R25-111-116 n1_876960_1071520 n1_876960_1032608 3.5374499999999998
R25-111-117 n1_876960_1108000 n1_876960_1071520 3.3163600000000004
R25-111-118 n1_876960_1146912 n1_876960_1108000 3.5374499999999998
R25-111-119 n1_876960_1183392 n1_876960_1146912 3.3163600000000004
R25-111-120 n1_876960_1222304 n1_876960_1183392 3.5374499999999998
R25-111-121 n1_876960_1261216 n1_876960_1222304 3.5374499999999998
R25-111-122 n1_876960_1297696 n1_876960_1261216 3.3163600000000004
R25-111-123 n1_876960_1336608 n1_876960_1297696 3.5374499999999998
R25-111-124 n1_876960_1373088 n1_876960_1336608 3.3163600000000004
R25-111-125 n1_876960_1412000 n1_876960_1373088 3.5374499999999998
R25-111-126 n1_876960_1448480 n1_876960_1412000 3.3163600000000004
R25-111-127 n1_876960_1487392 n1_876960_1448480 3.5374499999999998
R25-111-128 n1_876960_1526304 n1_876960_1487392 3.5374499999999998
R25-111-129 n1_876960_1562784 n1_876960_1526304 3.3163600000000004
R25-111-130 n1_876960_1601696 n1_876960_1562784 3.5374499999999998
R25-111-131 n1_876960_1641130 n1_876960_1601696 3.58491
R25-111-132 n1_876960_1641290 n1_876960_1641130 0.0145455
R25-112-100 n1_914656_480880 n1_914656_480720 0.0145455
R25-112-101 n1_914656_502432 n1_914656_480880 1.95927
R25-112-102 n1_914656_538912 n1_914656_502432 3.3163600000000004
R25-112-103 n1_914656_577824 n1_914656_538912 3.5374499999999998
R25-112-104 n1_914656_614304 n1_914656_577824 3.3163600000000004
R25-112-105 n1_914656_653216 n1_914656_614304 3.5374499999999998
R25-112-106 n1_914656_692128 n1_914656_653216 3.5374499999999998
R25-112-107 n1_914656_728608 n1_914656_692128 3.3163600000000004
R25-112-108 n1_914656_767520 n1_914656_728608 3.5374499999999998
R25-112-109 n1_914656_804000 n1_914656_767520 3.3163600000000004
R25-112-110 n1_914656_842912 n1_914656_804000 3.5374499999999998
R25-112-111 n1_914656_881824 n1_914656_842912 3.5374499999999998
R25-112-112 n1_914656_918304 n1_914656_881824 3.3163600000000004
R25-112-113 n1_914656_957216 n1_914656_918304 3.5374499999999998
R25-112-114 n1_914656_993696 n1_914656_957216 3.3163600000000004
R25-112-115 n1_914656_1032608 n1_914656_993696 3.5374499999999998
R25-112-116 n1_914656_1071520 n1_914656_1032608 3.5374499999999998
R25-112-117 n1_914656_1108000 n1_914656_1071520 3.3163600000000004
R25-112-118 n1_914656_1146912 n1_914656_1108000 3.5374499999999998
R25-112-119 n1_914656_1183392 n1_914656_1146912 3.3163600000000004
R25-112-120 n1_914656_1222304 n1_914656_1183392 3.5374499999999998
R25-112-121 n1_914656_1261216 n1_914656_1222304 3.5374499999999998
R25-112-122 n1_914656_1297696 n1_914656_1261216 3.3163600000000004
R25-112-123 n1_914656_1336608 n1_914656_1297696 3.5374499999999998
R25-112-124 n1_914656_1373088 n1_914656_1336608 3.3163600000000004
R25-112-125 n1_914656_1412000 n1_914656_1373088 3.5374499999999998
R25-112-126 n1_914656_1448480 n1_914656_1412000 3.3163600000000004
R25-112-127 n1_914656_1487392 n1_914656_1448480 3.5374499999999998
R25-112-128 n1_914656_1526304 n1_914656_1487392 3.5374499999999998
R25-112-129 n1_914656_1562784 n1_914656_1526304 3.3163600000000004
R25-112-130 n1_914656_1601696 n1_914656_1562784 3.5374499999999998
R25-112-131 n1_914656_1641130 n1_914656_1601696 3.58491
R25-112-132 n1_914656_1641290 n1_914656_1641130 0.0145455
R25-113-100 n1_952352_480880 n1_952352_480720 0.0145455
R25-113-101 n1_952352_502432 n1_952352_480880 1.95927
R25-113-102 n1_952352_538912 n1_952352_502432 3.3163600000000004
R25-113-103 n1_952352_577824 n1_952352_538912 3.5374499999999998
R25-113-104 n1_952352_614304 n1_952352_577824 3.3163600000000004
R25-113-105 n1_952352_653216 n1_952352_614304 3.5374499999999998
R25-113-106 n1_952352_692128 n1_952352_653216 3.5374499999999998
R25-113-107 n1_952352_728608 n1_952352_692128 3.3163600000000004
R25-113-108 n1_952352_767520 n1_952352_728608 3.5374499999999998
R25-113-109 n1_952352_804000 n1_952352_767520 3.3163600000000004
R25-113-110 n1_952352_842912 n1_952352_804000 3.5374499999999998
R25-113-111 n1_952352_881824 n1_952352_842912 3.5374499999999998
R25-113-112 n1_952352_918304 n1_952352_881824 3.3163600000000004
R25-113-113 n1_952352_957216 n1_952352_918304 3.5374499999999998
R25-113-114 n1_952352_993696 n1_952352_957216 3.3163600000000004
R25-113-115 n1_952352_1032608 n1_952352_993696 3.5374499999999998
R25-113-116 n1_952352_1071520 n1_952352_1032608 3.5374499999999998
R25-113-117 n1_952352_1108000 n1_952352_1071520 3.3163600000000004
R25-113-118 n1_952352_1146912 n1_952352_1108000 3.5374499999999998
R25-113-119 n1_952352_1183392 n1_952352_1146912 3.3163600000000004
R25-113-120 n1_952352_1222304 n1_952352_1183392 3.5374499999999998
R25-113-121 n1_952352_1261216 n1_952352_1222304 3.5374499999999998
R25-113-122 n1_952352_1297696 n1_952352_1261216 3.3163600000000004
R25-113-123 n1_952352_1336608 n1_952352_1297696 3.5374499999999998
R25-113-124 n1_952352_1373088 n1_952352_1336608 3.3163600000000004
R25-113-125 n1_952352_1412000 n1_952352_1373088 3.5374499999999998
R25-113-126 n1_952352_1448480 n1_952352_1412000 3.3163600000000004
R25-113-127 n1_952352_1487392 n1_952352_1448480 3.5374499999999998
R25-113-128 n1_952352_1526304 n1_952352_1487392 3.5374499999999998
R25-113-129 n1_952352_1562784 n1_952352_1526304 3.3163600000000004
R25-113-130 n1_952352_1601696 n1_952352_1562784 3.5374499999999998
R25-113-131 n1_952352_1641130 n1_952352_1601696 3.58491
R25-113-132 n1_952352_1641290 n1_952352_1641130 0.0145455
R25-114-100 n1_991264_480880 n1_991264_480720 0.0145455
R25-114-101 n1_991264_502432 n1_991264_480880 1.95927
R25-114-102 n1_991264_538912 n1_991264_502432 3.3163600000000004
R25-114-103 n1_991264_577824 n1_991264_538912 3.5374499999999998
R25-114-104 n1_991264_614304 n1_991264_577824 3.3163600000000004
R25-114-105 n1_991264_653216 n1_991264_614304 3.5374499999999998
R25-114-106 n1_991264_692128 n1_991264_653216 3.5374499999999998
R25-114-107 n1_991264_728608 n1_991264_692128 3.3163600000000004
R25-114-108 n1_991264_767520 n1_991264_728608 3.5374499999999998
R25-114-109 n1_991264_804000 n1_991264_767520 3.3163600000000004
R25-114-110 n1_991264_842912 n1_991264_804000 3.5374499999999998
R25-114-111 n1_991264_881824 n1_991264_842912 3.5374499999999998
R25-114-112 n1_991264_918304 n1_991264_881824 3.3163600000000004
R25-114-113 n1_991264_957216 n1_991264_918304 3.5374499999999998
R25-114-114 n1_991264_993696 n1_991264_957216 3.3163600000000004
R25-114-115 n1_991264_1032608 n1_991264_993696 3.5374499999999998
R25-114-116 n1_991264_1071520 n1_991264_1032608 3.5374499999999998
R25-114-117 n1_991264_1108000 n1_991264_1071520 3.3163600000000004
R25-114-118 n1_991264_1146912 n1_991264_1108000 3.5374499999999998
R25-114-119 n1_991264_1183392 n1_991264_1146912 3.3163600000000004
R25-114-120 n1_991264_1222304 n1_991264_1183392 3.5374499999999998
R25-114-121 n1_991264_1261216 n1_991264_1222304 3.5374499999999998
R25-114-122 n1_991264_1297696 n1_991264_1261216 3.3163600000000004
R25-114-123 n1_991264_1336608 n1_991264_1297696 3.5374499999999998
R25-114-124 n1_991264_1373088 n1_991264_1336608 3.3163600000000004
R25-114-125 n1_991264_1412000 n1_991264_1373088 3.5374499999999998
R25-114-126 n1_991264_1448480 n1_991264_1412000 3.3163600000000004
R25-114-127 n1_991264_1487392 n1_991264_1448480 3.5374499999999998
R25-114-128 n1_991264_1526304 n1_991264_1487392 3.5374499999999998
R25-114-129 n1_991264_1562784 n1_991264_1526304 3.3163600000000004
R25-114-130 n1_991264_1601696 n1_991264_1562784 3.5374499999999998
R25-114-131 n1_991264_1641130 n1_991264_1601696 3.58491
R25-114-132 n1_991264_1641290 n1_991264_1641130 0.0145455
R25-115-100 n1_1028960_480880 n1_1028960_480720 0.0145455
R25-115-101 n1_1028960_502432 n1_1028960_480880 1.95927
R25-115-102 n1_1028960_538912 n1_1028960_502432 3.3163600000000004
R25-115-103 n1_1028960_577824 n1_1028960_538912 3.5374499999999998
R25-115-104 n1_1028960_614304 n1_1028960_577824 3.3163600000000004
R25-115-105 n1_1028960_653216 n1_1028960_614304 3.5374499999999998
R25-115-106 n1_1028960_692128 n1_1028960_653216 3.5374499999999998
R25-115-107 n1_1028960_728608 n1_1028960_692128 3.3163600000000004
R25-115-108 n1_1028960_767520 n1_1028960_728608 3.5374499999999998
R25-115-109 n1_1028960_804000 n1_1028960_767520 3.3163600000000004
R25-115-110 n1_1028960_842912 n1_1028960_804000 3.5374499999999998
R25-115-111 n1_1028960_881824 n1_1028960_842912 3.5374499999999998
R25-115-112 n1_1028960_918304 n1_1028960_881824 3.3163600000000004
R25-115-113 n1_1028960_957216 n1_1028960_918304 3.5374499999999998
R25-115-114 n1_1028960_993696 n1_1028960_957216 3.3163600000000004
R25-115-115 n1_1028960_1032608 n1_1028960_993696 3.5374499999999998
R25-115-116 n1_1028960_1071520 n1_1028960_1032608 3.5374499999999998
R25-115-117 n1_1028960_1108000 n1_1028960_1071520 3.3163600000000004
R25-115-118 n1_1028960_1146912 n1_1028960_1108000 3.5374499999999998
R25-115-119 n1_1028960_1183392 n1_1028960_1146912 3.3163600000000004
R25-115-120 n1_1028960_1222304 n1_1028960_1183392 3.5374499999999998
R25-115-121 n1_1028960_1261216 n1_1028960_1222304 3.5374499999999998
R25-115-122 n1_1028960_1297696 n1_1028960_1261216 3.3163600000000004
R25-115-123 n1_1028960_1336608 n1_1028960_1297696 3.5374499999999998
R25-115-124 n1_1028960_1373088 n1_1028960_1336608 3.3163600000000004
R25-115-125 n1_1028960_1412000 n1_1028960_1373088 3.5374499999999998
R25-115-126 n1_1028960_1448480 n1_1028960_1412000 3.3163600000000004
R25-115-127 n1_1028960_1487392 n1_1028960_1448480 3.5374499999999998
R25-115-128 n1_1028960_1526304 n1_1028960_1487392 3.5374499999999998
R25-115-129 n1_1028960_1562784 n1_1028960_1526304 3.3163600000000004
R25-115-130 n1_1028960_1601696 n1_1028960_1562784 3.5374499999999998
R25-115-131 n1_1028960_1641130 n1_1028960_1601696 3.58491
R25-115-132 n1_1028960_1641290 n1_1028960_1641130 0.0145455
R25-116-100 n1_1067872_480880 n1_1067872_480720 0.0145455
R25-116-101 n1_1067872_502432 n1_1067872_480880 1.95927
R25-116-102 n1_1067872_538912 n1_1067872_502432 3.3163600000000004
R25-116-103 n1_1067872_577824 n1_1067872_538912 3.5374499999999998
R25-116-104 n1_1067872_614304 n1_1067872_577824 3.3163600000000004
R25-116-105 n1_1067872_653216 n1_1067872_614304 3.5374499999999998
R25-116-106 n1_1067872_692128 n1_1067872_653216 3.5374499999999998
R25-116-107 n1_1067872_728608 n1_1067872_692128 3.3163600000000004
R25-116-108 n1_1067872_767520 n1_1067872_728608 3.5374499999999998
R25-116-109 n1_1067872_804000 n1_1067872_767520 3.3163600000000004
R25-116-110 n1_1067872_842912 n1_1067872_804000 3.5374499999999998
R25-116-111 n1_1067872_881824 n1_1067872_842912 3.5374499999999998
R25-116-112 n1_1067872_918304 n1_1067872_881824 3.3163600000000004
R25-116-113 n1_1067872_957216 n1_1067872_918304 3.5374499999999998
R25-116-114 n1_1067872_993696 n1_1067872_957216 3.3163600000000004
R25-116-115 n1_1067872_1032608 n1_1067872_993696 3.5374499999999998
R25-116-116 n1_1067872_1071520 n1_1067872_1032608 3.5374499999999998
R25-116-117 n1_1067872_1108000 n1_1067872_1071520 3.3163600000000004
R25-116-118 n1_1067872_1146912 n1_1067872_1108000 3.5374499999999998
R25-116-119 n1_1067872_1183392 n1_1067872_1146912 3.3163600000000004
R25-116-120 n1_1067872_1222304 n1_1067872_1183392 3.5374499999999998
R25-116-121 n1_1067872_1261216 n1_1067872_1222304 3.5374499999999998
R25-116-122 n1_1067872_1297696 n1_1067872_1261216 3.3163600000000004
R25-116-123 n1_1067872_1336608 n1_1067872_1297696 3.5374499999999998
R25-116-124 n1_1067872_1373088 n1_1067872_1336608 3.3163600000000004
R25-116-125 n1_1067872_1412000 n1_1067872_1373088 3.5374499999999998
R25-116-126 n1_1067872_1448480 n1_1067872_1412000 3.3163600000000004
R25-116-127 n1_1067872_1487392 n1_1067872_1448480 3.5374499999999998
R25-116-128 n1_1067872_1526304 n1_1067872_1487392 3.5374499999999998
R25-116-129 n1_1067872_1562784 n1_1067872_1526304 3.3163600000000004
R25-116-130 n1_1067872_1601696 n1_1067872_1562784 3.5374499999999998
R25-116-131 n1_1067872_1641130 n1_1067872_1601696 3.58491
R25-116-132 n1_1067872_1641290 n1_1067872_1641130 0.0145455
R25-117-100 n1_1105568_480880 n1_1105568_480720 0.0145455
R25-117-101 n1_1105568_502432 n1_1105568_480880 1.95927
R25-117-102 n1_1105568_538912 n1_1105568_502432 3.3163600000000004
R25-117-103 n1_1105568_577824 n1_1105568_538912 3.5374499999999998
R25-117-104 n1_1105568_614304 n1_1105568_577824 3.3163600000000004
R25-117-105 n1_1105568_653216 n1_1105568_614304 3.5374499999999998
R25-117-106 n1_1105568_692128 n1_1105568_653216 3.5374499999999998
R25-117-107 n1_1105568_728608 n1_1105568_692128 3.3163600000000004
R25-117-108 n1_1105568_767520 n1_1105568_728608 3.5374499999999998
R25-117-109 n1_1105568_804000 n1_1105568_767520 3.3163600000000004
R25-117-110 n1_1105568_842912 n1_1105568_804000 3.5374499999999998
R25-117-111 n1_1105568_881824 n1_1105568_842912 3.5374499999999998
R25-117-112 n1_1105568_918304 n1_1105568_881824 3.3163600000000004
R25-117-113 n1_1105568_957216 n1_1105568_918304 3.5374499999999998
R25-117-114 n1_1105568_993696 n1_1105568_957216 3.3163600000000004
R25-117-115 n1_1105568_1032608 n1_1105568_993696 3.5374499999999998
R25-117-116 n1_1105568_1071520 n1_1105568_1032608 3.5374499999999998
R25-117-117 n1_1105568_1108000 n1_1105568_1071520 3.3163600000000004
R25-117-118 n1_1105568_1146912 n1_1105568_1108000 3.5374499999999998
R25-117-119 n1_1105568_1183392 n1_1105568_1146912 3.3163600000000004
R25-117-120 n1_1105568_1222304 n1_1105568_1183392 3.5374499999999998
R25-117-121 n1_1105568_1261216 n1_1105568_1222304 3.5374499999999998
R25-117-122 n1_1105568_1297696 n1_1105568_1261216 3.3163600000000004
R25-117-123 n1_1105568_1336608 n1_1105568_1297696 3.5374499999999998
R25-117-124 n1_1105568_1373088 n1_1105568_1336608 3.3163600000000004
R25-117-125 n1_1105568_1412000 n1_1105568_1373088 3.5374499999999998
R25-117-126 n1_1105568_1448480 n1_1105568_1412000 3.3163600000000004
R25-117-127 n1_1105568_1487392 n1_1105568_1448480 3.5374499999999998
R25-117-128 n1_1105568_1526304 n1_1105568_1487392 3.5374499999999998
R25-117-129 n1_1105568_1562784 n1_1105568_1526304 3.3163600000000004
R25-117-130 n1_1105568_1601696 n1_1105568_1562784 3.5374499999999998
R25-117-131 n1_1105568_1641130 n1_1105568_1601696 3.58491
R25-117-132 n1_1105568_1641290 n1_1105568_1641130 0.0145455
R25-118-100 n1_1144480_480880 n1_1144480_480720 0.0145455
R25-118-101 n1_1144480_502432 n1_1144480_480880 1.95927
R25-118-102 n1_1144480_538912 n1_1144480_502432 3.3163600000000004
R25-118-103 n1_1144480_577824 n1_1144480_538912 3.5374499999999998
R25-118-104 n1_1144480_614304 n1_1144480_577824 3.3163600000000004
R25-118-105 n1_1144480_653216 n1_1144480_614304 3.5374499999999998
R25-118-106 n1_1144480_692128 n1_1144480_653216 3.5374499999999998
R25-118-107 n1_1144480_728608 n1_1144480_692128 3.3163600000000004
R25-118-108 n1_1144480_767520 n1_1144480_728608 3.5374499999999998
R25-118-109 n1_1144480_804000 n1_1144480_767520 3.3163600000000004
R25-118-110 n1_1144480_842912 n1_1144480_804000 3.5374499999999998
R25-118-111 n1_1144480_881824 n1_1144480_842912 3.5374499999999998
R25-118-112 n1_1144480_918304 n1_1144480_881824 3.3163600000000004
R25-118-113 n1_1144480_957216 n1_1144480_918304 3.5374499999999998
R25-118-114 n1_1144480_993696 n1_1144480_957216 3.3163600000000004
R25-118-115 n1_1144480_1032608 n1_1144480_993696 3.5374499999999998
R25-118-116 n1_1144480_1071520 n1_1144480_1032608 3.5374499999999998
R25-118-117 n1_1144480_1108000 n1_1144480_1071520 3.3163600000000004
R25-118-118 n1_1144480_1146912 n1_1144480_1108000 3.5374499999999998
R25-118-119 n1_1144480_1183392 n1_1144480_1146912 3.3163600000000004
R25-118-120 n1_1144480_1222304 n1_1144480_1183392 3.5374499999999998
R25-118-121 n1_1144480_1261216 n1_1144480_1222304 3.5374499999999998
R25-118-122 n1_1144480_1297696 n1_1144480_1261216 3.3163600000000004
R25-118-123 n1_1144480_1336608 n1_1144480_1297696 3.5374499999999998
R25-118-124 n1_1144480_1373088 n1_1144480_1336608 3.3163600000000004
R25-118-125 n1_1144480_1412000 n1_1144480_1373088 3.5374499999999998
R25-118-126 n1_1144480_1448480 n1_1144480_1412000 3.3163600000000004
R25-118-127 n1_1144480_1487392 n1_1144480_1448480 3.5374499999999998
R25-118-128 n1_1144480_1526304 n1_1144480_1487392 3.5374499999999998
R25-118-129 n1_1144480_1562784 n1_1144480_1526304 3.3163600000000004
R25-118-130 n1_1144480_1601696 n1_1144480_1562784 3.5374499999999998
R25-118-131 n1_1144480_1641130 n1_1144480_1601696 3.58491
R25-118-132 n1_1144480_1641290 n1_1144480_1641130 0.0145455
R25-119-100 n1_1182176_480880 n1_1182176_480720 0.0145455
R25-119-101 n1_1182176_502432 n1_1182176_480880 1.95927
R25-119-102 n1_1182176_538912 n1_1182176_502432 3.3163600000000004
R25-119-103 n1_1182176_577824 n1_1182176_538912 3.5374499999999998
R25-119-104 n1_1182176_614304 n1_1182176_577824 3.3163600000000004
R25-119-105 n1_1182176_653216 n1_1182176_614304 3.5374499999999998
R25-119-106 n1_1182176_692128 n1_1182176_653216 3.5374499999999998
R25-119-107 n1_1182176_728608 n1_1182176_692128 3.3163600000000004
R25-119-108 n1_1182176_767520 n1_1182176_728608 3.5374499999999998
R25-119-109 n1_1182176_804000 n1_1182176_767520 3.3163600000000004
R25-119-110 n1_1182176_842912 n1_1182176_804000 3.5374499999999998
R25-119-111 n1_1182176_881824 n1_1182176_842912 3.5374499999999998
R25-119-112 n1_1182176_918304 n1_1182176_881824 3.3163600000000004
R25-119-113 n1_1182176_957216 n1_1182176_918304 3.5374499999999998
R25-119-114 n1_1182176_993696 n1_1182176_957216 3.3163600000000004
R25-119-115 n1_1182176_1032608 n1_1182176_993696 3.5374499999999998
R25-119-116 n1_1182176_1071520 n1_1182176_1032608 3.5374499999999998
R25-119-117 n1_1182176_1108000 n1_1182176_1071520 3.3163600000000004
R25-119-118 n1_1182176_1146912 n1_1182176_1108000 3.5374499999999998
R25-119-119 n1_1182176_1183392 n1_1182176_1146912 3.3163600000000004
R25-119-120 n1_1182176_1222304 n1_1182176_1183392 3.5374499999999998
R25-119-121 n1_1182176_1261216 n1_1182176_1222304 3.5374499999999998
R25-119-122 n1_1182176_1297696 n1_1182176_1261216 3.3163600000000004
R25-119-123 n1_1182176_1336608 n1_1182176_1297696 3.5374499999999998
R25-119-124 n1_1182176_1373088 n1_1182176_1336608 3.3163600000000004
R25-119-125 n1_1182176_1412000 n1_1182176_1373088 3.5374499999999998
R25-119-126 n1_1182176_1448480 n1_1182176_1412000 3.3163600000000004
R25-119-127 n1_1182176_1487392 n1_1182176_1448480 3.5374499999999998
R25-119-128 n1_1182176_1526304 n1_1182176_1487392 3.5374499999999998
R25-119-129 n1_1182176_1562784 n1_1182176_1526304 3.3163600000000004
R25-119-130 n1_1182176_1601696 n1_1182176_1562784 3.5374499999999998
R25-119-131 n1_1182176_1641130 n1_1182176_1601696 3.58491
R25-119-132 n1_1182176_1641290 n1_1182176_1641130 0.0145455
R25-120-100 n1_1219872_480880 n1_1219872_480720 0.0145455
R25-120-101 n1_1219872_502432 n1_1219872_480880 1.95927
R25-120-102 n1_1219872_538912 n1_1219872_502432 3.3163600000000004
R25-120-103 n1_1219872_577824 n1_1219872_538912 3.5374499999999998
R25-120-104 n1_1219872_614304 n1_1219872_577824 3.3163600000000004
R25-120-105 n1_1219872_653216 n1_1219872_614304 3.5374499999999998
R25-120-106 n1_1219872_692128 n1_1219872_653216 3.5374499999999998
R25-120-107 n1_1219872_728608 n1_1219872_692128 3.3163600000000004
R25-120-108 n1_1219872_767520 n1_1219872_728608 3.5374499999999998
R25-120-109 n1_1219872_804000 n1_1219872_767520 3.3163600000000004
R25-120-110 n1_1219872_842912 n1_1219872_804000 3.5374499999999998
R25-120-111 n1_1219872_881824 n1_1219872_842912 3.5374499999999998
R25-120-112 n1_1219872_918304 n1_1219872_881824 3.3163600000000004
R25-120-113 n1_1219872_957216 n1_1219872_918304 3.5374499999999998
R25-120-114 n1_1219872_993696 n1_1219872_957216 3.3163600000000004
R25-120-115 n1_1219872_1032608 n1_1219872_993696 3.5374499999999998
R25-120-116 n1_1219872_1071520 n1_1219872_1032608 3.5374499999999998
R25-120-117 n1_1219872_1108000 n1_1219872_1071520 3.3163600000000004
R25-120-118 n1_1219872_1146912 n1_1219872_1108000 3.5374499999999998
R25-120-119 n1_1219872_1183392 n1_1219872_1146912 3.3163600000000004
R25-120-120 n1_1219872_1222304 n1_1219872_1183392 3.5374499999999998
R25-120-121 n1_1219872_1261216 n1_1219872_1222304 3.5374499999999998
R25-120-122 n1_1219872_1297696 n1_1219872_1261216 3.3163600000000004
R25-120-123 n1_1219872_1336608 n1_1219872_1297696 3.5374499999999998
R25-120-124 n1_1219872_1373088 n1_1219872_1336608 3.3163600000000004
R25-120-125 n1_1219872_1412000 n1_1219872_1373088 3.5374499999999998
R25-120-126 n1_1219872_1448480 n1_1219872_1412000 3.3163600000000004
R25-120-127 n1_1219872_1487392 n1_1219872_1448480 3.5374499999999998
R25-120-128 n1_1219872_1526304 n1_1219872_1487392 3.5374499999999998
R25-120-129 n1_1219872_1562784 n1_1219872_1526304 3.3163600000000004
R25-120-130 n1_1219872_1601696 n1_1219872_1562784 3.5374499999999998
R25-120-131 n1_1219872_1641130 n1_1219872_1601696 3.58491
R25-120-132 n1_1219872_1641290 n1_1219872_1641130 0.0145455
R25-121-100 n1_1258784_480880 n1_1258784_480720 0.0145455
R25-121-101 n1_1258784_502432 n1_1258784_480880 1.95927
R25-121-102 n1_1258784_538912 n1_1258784_502432 3.3163600000000004
R25-121-103 n1_1258784_577824 n1_1258784_538912 3.5374499999999998
R25-121-104 n1_1258784_614304 n1_1258784_577824 3.3163600000000004
R25-121-105 n1_1258784_653216 n1_1258784_614304 3.5374499999999998
R25-121-106 n1_1258784_692128 n1_1258784_653216 3.5374499999999998
R25-121-107 n1_1258784_728608 n1_1258784_692128 3.3163600000000004
R25-121-108 n1_1258784_767520 n1_1258784_728608 3.5374499999999998
R25-121-109 n1_1258784_804000 n1_1258784_767520 3.3163600000000004
R25-121-110 n1_1258784_842912 n1_1258784_804000 3.5374499999999998
R25-121-111 n1_1258784_881824 n1_1258784_842912 3.5374499999999998
R25-121-112 n1_1258784_918304 n1_1258784_881824 3.3163600000000004
R25-121-113 n1_1258784_957216 n1_1258784_918304 3.5374499999999998
R25-121-114 n1_1258784_993696 n1_1258784_957216 3.3163600000000004
R25-121-115 n1_1258784_1032608 n1_1258784_993696 3.5374499999999998
R25-121-116 n1_1258784_1071520 n1_1258784_1032608 3.5374499999999998
R25-121-117 n1_1258784_1108000 n1_1258784_1071520 3.3163600000000004
R25-121-118 n1_1258784_1146912 n1_1258784_1108000 3.5374499999999998
R25-121-119 n1_1258784_1183392 n1_1258784_1146912 3.3163600000000004
R25-121-120 n1_1258784_1222304 n1_1258784_1183392 3.5374499999999998
R25-121-121 n1_1258784_1261216 n1_1258784_1222304 3.5374499999999998
R25-121-122 n1_1258784_1297696 n1_1258784_1261216 3.3163600000000004
R25-121-123 n1_1258784_1336608 n1_1258784_1297696 3.5374499999999998
R25-121-124 n1_1258784_1373088 n1_1258784_1336608 3.3163600000000004
R25-121-125 n1_1258784_1412000 n1_1258784_1373088 3.5374499999999998
R25-121-126 n1_1258784_1448480 n1_1258784_1412000 3.3163600000000004
R25-121-127 n1_1258784_1487392 n1_1258784_1448480 3.5374499999999998
R25-121-128 n1_1258784_1526304 n1_1258784_1487392 3.5374499999999998
R25-121-129 n1_1258784_1562784 n1_1258784_1526304 3.3163600000000004
R25-121-130 n1_1258784_1601696 n1_1258784_1562784 3.5374499999999998
R25-121-131 n1_1258784_1641130 n1_1258784_1601696 3.58491
R25-121-132 n1_1258784_1641290 n1_1258784_1641130 0.0145455
R25-122-100 n1_1296480_480880 n1_1296480_480720 0.0145455
R25-122-101 n1_1296480_502432 n1_1296480_480880 1.95927
R25-122-102 n1_1296480_538912 n1_1296480_502432 3.3163600000000004
R25-122-103 n1_1296480_577824 n1_1296480_538912 3.5374499999999998
R25-122-104 n1_1296480_614304 n1_1296480_577824 3.3163600000000004
R25-122-105 n1_1296480_653216 n1_1296480_614304 3.5374499999999998
R25-122-106 n1_1296480_692128 n1_1296480_653216 3.5374499999999998
R25-122-107 n1_1296480_728608 n1_1296480_692128 3.3163600000000004
R25-122-108 n1_1296480_767520 n1_1296480_728608 3.5374499999999998
R25-122-109 n1_1296480_804000 n1_1296480_767520 3.3163600000000004
R25-122-110 n1_1296480_842912 n1_1296480_804000 3.5374499999999998
R25-122-111 n1_1296480_881824 n1_1296480_842912 3.5374499999999998
R25-122-112 n1_1296480_918304 n1_1296480_881824 3.3163600000000004
R25-122-113 n1_1296480_957216 n1_1296480_918304 3.5374499999999998
R25-122-114 n1_1296480_993696 n1_1296480_957216 3.3163600000000004
R25-122-115 n1_1296480_1032608 n1_1296480_993696 3.5374499999999998
R25-122-116 n1_1296480_1071520 n1_1296480_1032608 3.5374499999999998
R25-122-117 n1_1296480_1108000 n1_1296480_1071520 3.3163600000000004
R25-122-118 n1_1296480_1146912 n1_1296480_1108000 3.5374499999999998
R25-122-119 n1_1296480_1183392 n1_1296480_1146912 3.3163600000000004
R25-122-120 n1_1296480_1222304 n1_1296480_1183392 3.5374499999999998
R25-122-121 n1_1296480_1261216 n1_1296480_1222304 3.5374499999999998
R25-122-122 n1_1296480_1297696 n1_1296480_1261216 3.3163600000000004
R25-122-123 n1_1296480_1336608 n1_1296480_1297696 3.5374499999999998
R25-122-124 n1_1296480_1373088 n1_1296480_1336608 3.3163600000000004
R25-122-125 n1_1296480_1412000 n1_1296480_1373088 3.5374499999999998
R25-122-126 n1_1296480_1448480 n1_1296480_1412000 3.3163600000000004
R25-122-127 n1_1296480_1487392 n1_1296480_1448480 3.5374499999999998
R25-122-128 n1_1296480_1526304 n1_1296480_1487392 3.5374499999999998
R25-122-129 n1_1296480_1562784 n1_1296480_1526304 3.3163600000000004
R25-122-130 n1_1296480_1601696 n1_1296480_1562784 3.5374499999999998
R25-122-131 n1_1296480_1641130 n1_1296480_1601696 3.58491
R25-122-132 n1_1296480_1641290 n1_1296480_1641130 0.0145455
R25-123-100 n1_1335392_480880 n1_1335392_480720 0.0145455
R25-123-101 n1_1335392_502432 n1_1335392_480880 1.95927
R25-123-102 n1_1335392_538912 n1_1335392_502432 3.3163600000000004
R25-123-103 n1_1335392_577824 n1_1335392_538912 3.5374499999999998
R25-123-104 n1_1335392_614304 n1_1335392_577824 3.3163600000000004
R25-123-105 n1_1335392_653216 n1_1335392_614304 3.5374499999999998
R25-123-106 n1_1335392_692128 n1_1335392_653216 3.5374499999999998
R25-123-107 n1_1335392_728608 n1_1335392_692128 3.3163600000000004
R25-123-108 n1_1335392_767520 n1_1335392_728608 3.5374499999999998
R25-123-109 n1_1335392_804000 n1_1335392_767520 3.3163600000000004
R25-123-110 n1_1335392_842912 n1_1335392_804000 3.5374499999999998
R25-123-111 n1_1335392_881824 n1_1335392_842912 3.5374499999999998
R25-123-112 n1_1335392_918304 n1_1335392_881824 3.3163600000000004
R25-123-113 n1_1335392_957216 n1_1335392_918304 3.5374499999999998
R25-123-114 n1_1335392_993696 n1_1335392_957216 3.3163600000000004
R25-123-115 n1_1335392_1032608 n1_1335392_993696 3.5374499999999998
R25-123-116 n1_1335392_1071520 n1_1335392_1032608 3.5374499999999998
R25-123-117 n1_1335392_1108000 n1_1335392_1071520 3.3163600000000004
R25-123-118 n1_1335392_1146912 n1_1335392_1108000 3.5374499999999998
R25-123-119 n1_1335392_1183392 n1_1335392_1146912 3.3163600000000004
R25-123-120 n1_1335392_1222304 n1_1335392_1183392 3.5374499999999998
R25-123-121 n1_1335392_1261216 n1_1335392_1222304 3.5374499999999998
R25-123-122 n1_1335392_1297696 n1_1335392_1261216 3.3163600000000004
R25-123-123 n1_1335392_1336608 n1_1335392_1297696 3.5374499999999998
R25-123-124 n1_1335392_1373088 n1_1335392_1336608 3.3163600000000004
R25-123-125 n1_1335392_1412000 n1_1335392_1373088 3.5374499999999998
R25-123-126 n1_1335392_1448480 n1_1335392_1412000 3.3163600000000004
R25-123-127 n1_1335392_1487392 n1_1335392_1448480 3.5374499999999998
R25-123-128 n1_1335392_1526304 n1_1335392_1487392 3.5374499999999998
R25-123-129 n1_1335392_1562784 n1_1335392_1526304 3.3163600000000004
R25-123-130 n1_1335392_1601696 n1_1335392_1562784 3.5374499999999998
R25-123-131 n1_1335392_1641130 n1_1335392_1601696 3.58491
R25-123-132 n1_1335392_1641290 n1_1335392_1641130 0.0145455
R25-124-100 n1_1373088_480880 n1_1373088_480720 0.0145455
R25-124-101 n1_1373088_502432 n1_1373088_480880 1.95927
R25-124-102 n1_1373088_538912 n1_1373088_502432 3.3163600000000004
R25-124-103 n1_1373088_577824 n1_1373088_538912 3.5374499999999998
R25-124-104 n1_1373088_614304 n1_1373088_577824 3.3163600000000004
R25-124-105 n1_1373088_653216 n1_1373088_614304 3.5374499999999998
R25-124-106 n1_1373088_692128 n1_1373088_653216 3.5374499999999998
R25-124-107 n1_1373088_728608 n1_1373088_692128 3.3163600000000004
R25-124-108 n1_1373088_767520 n1_1373088_728608 3.5374499999999998
R25-124-109 n1_1373088_804000 n1_1373088_767520 3.3163600000000004
R25-124-110 n1_1373088_842912 n1_1373088_804000 3.5374499999999998
R25-124-111 n1_1373088_881824 n1_1373088_842912 3.5374499999999998
R25-124-112 n1_1373088_918304 n1_1373088_881824 3.3163600000000004
R25-124-113 n1_1373088_957216 n1_1373088_918304 3.5374499999999998
R25-124-114 n1_1373088_993696 n1_1373088_957216 3.3163600000000004
R25-124-115 n1_1373088_1032608 n1_1373088_993696 3.5374499999999998
R25-124-116 n1_1373088_1071520 n1_1373088_1032608 3.5374499999999998
R25-124-117 n1_1373088_1108000 n1_1373088_1071520 3.3163600000000004
R25-124-118 n1_1373088_1146912 n1_1373088_1108000 3.5374499999999998
R25-124-119 n1_1373088_1183392 n1_1373088_1146912 3.3163600000000004
R25-124-120 n1_1373088_1222304 n1_1373088_1183392 3.5374499999999998
R25-124-121 n1_1373088_1261216 n1_1373088_1222304 3.5374499999999998
R25-124-122 n1_1373088_1297696 n1_1373088_1261216 3.3163600000000004
R25-124-123 n1_1373088_1336608 n1_1373088_1297696 3.5374499999999998
R25-124-124 n1_1373088_1373088 n1_1373088_1336608 3.3163600000000004
R25-124-125 n1_1373088_1412000 n1_1373088_1373088 3.5374499999999998
R25-124-126 n1_1373088_1448480 n1_1373088_1412000 3.3163600000000004
R25-124-127 n1_1373088_1487392 n1_1373088_1448480 3.5374499999999998
R25-124-128 n1_1373088_1526304 n1_1373088_1487392 3.5374499999999998
R25-124-129 n1_1373088_1562784 n1_1373088_1526304 3.3163600000000004
R25-124-130 n1_1373088_1601696 n1_1373088_1562784 3.5374499999999998
R25-124-131 n1_1373088_1641130 n1_1373088_1601696 3.58491
R25-124-132 n1_1373088_1641290 n1_1373088_1641130 0.0145455
R25-125-100 n1_1412000_480880 n1_1412000_480720 0.0145455
R25-125-101 n1_1412000_502432 n1_1412000_480880 1.95927
R25-125-102 n1_1412000_538912 n1_1412000_502432 3.3163600000000004
R25-125-103 n1_1412000_577824 n1_1412000_538912 3.5374499999999998
R25-125-104 n1_1412000_614304 n1_1412000_577824 3.3163600000000004
R25-125-105 n1_1412000_653216 n1_1412000_614304 3.5374499999999998
R25-125-106 n1_1412000_692128 n1_1412000_653216 3.5374499999999998
R25-125-107 n1_1412000_728608 n1_1412000_692128 3.3163600000000004
R25-125-108 n1_1412000_767520 n1_1412000_728608 3.5374499999999998
R25-125-109 n1_1412000_804000 n1_1412000_767520 3.3163600000000004
R25-125-110 n1_1412000_842912 n1_1412000_804000 3.5374499999999998
R25-125-111 n1_1412000_881824 n1_1412000_842912 3.5374499999999998
R25-125-112 n1_1412000_918304 n1_1412000_881824 3.3163600000000004
R25-125-113 n1_1412000_957216 n1_1412000_918304 3.5374499999999998
R25-125-114 n1_1412000_993696 n1_1412000_957216 3.3163600000000004
R25-125-115 n1_1412000_1032608 n1_1412000_993696 3.5374499999999998
R25-125-116 n1_1412000_1071520 n1_1412000_1032608 3.5374499999999998
R25-125-117 n1_1412000_1108000 n1_1412000_1071520 3.3163600000000004
R25-125-118 n1_1412000_1146912 n1_1412000_1108000 3.5374499999999998
R25-125-119 n1_1412000_1183392 n1_1412000_1146912 3.3163600000000004
R25-125-120 n1_1412000_1222304 n1_1412000_1183392 3.5374499999999998
R25-125-121 n1_1412000_1261216 n1_1412000_1222304 3.5374499999999998
R25-125-122 n1_1412000_1297696 n1_1412000_1261216 3.3163600000000004
R25-125-123 n1_1412000_1336608 n1_1412000_1297696 3.5374499999999998
R25-125-124 n1_1412000_1373088 n1_1412000_1336608 3.3163600000000004
R25-125-125 n1_1412000_1412000 n1_1412000_1373088 3.5374499999999998
R25-125-126 n1_1412000_1448480 n1_1412000_1412000 3.3163600000000004
R25-125-127 n1_1412000_1487392 n1_1412000_1448480 3.5374499999999998
R25-125-128 n1_1412000_1526304 n1_1412000_1487392 3.5374499999999998
R25-125-129 n1_1412000_1562784 n1_1412000_1526304 3.3163600000000004
R25-125-130 n1_1412000_1601696 n1_1412000_1562784 3.5374499999999998
R25-125-131 n1_1412000_1641130 n1_1412000_1601696 3.58491
R25-125-132 n1_1412000_1641290 n1_1412000_1641130 0.0145455
R25-126-100 n1_1449696_480880 n1_1449696_480720 0.0145455
R25-126-101 n1_1449696_502432 n1_1449696_480880 1.95927
R25-126-102 n1_1449696_538912 n1_1449696_502432 3.3163600000000004
R25-126-103 n1_1449696_577824 n1_1449696_538912 3.5374499999999998
R25-126-104 n1_1449696_614304 n1_1449696_577824 3.3163600000000004
R25-126-105 n1_1449696_653216 n1_1449696_614304 3.5374499999999998
R25-126-106 n1_1449696_692128 n1_1449696_653216 3.5374499999999998
R25-126-107 n1_1449696_728608 n1_1449696_692128 3.3163600000000004
R25-126-108 n1_1449696_767520 n1_1449696_728608 3.5374499999999998
R25-126-109 n1_1449696_804000 n1_1449696_767520 3.3163600000000004
R25-126-110 n1_1449696_842912 n1_1449696_804000 3.5374499999999998
R25-126-111 n1_1449696_881824 n1_1449696_842912 3.5374499999999998
R25-126-112 n1_1449696_918304 n1_1449696_881824 3.3163600000000004
R25-126-113 n1_1449696_957216 n1_1449696_918304 3.5374499999999998
R25-126-114 n1_1449696_993696 n1_1449696_957216 3.3163600000000004
R25-126-115 n1_1449696_1032608 n1_1449696_993696 3.5374499999999998
R25-126-116 n1_1449696_1071520 n1_1449696_1032608 3.5374499999999998
R25-126-117 n1_1449696_1108000 n1_1449696_1071520 3.3163600000000004
R25-126-118 n1_1449696_1146912 n1_1449696_1108000 3.5374499999999998
R25-126-119 n1_1449696_1183392 n1_1449696_1146912 3.3163600000000004
R25-126-120 n1_1449696_1222304 n1_1449696_1183392 3.5374499999999998
R25-126-121 n1_1449696_1261216 n1_1449696_1222304 3.5374499999999998
R25-126-122 n1_1449696_1297696 n1_1449696_1261216 3.3163600000000004
R25-126-123 n1_1449696_1336608 n1_1449696_1297696 3.5374499999999998
R25-126-124 n1_1449696_1373088 n1_1449696_1336608 3.3163600000000004
R25-126-125 n1_1449696_1412000 n1_1449696_1373088 3.5374499999999998
R25-126-126 n1_1449696_1448480 n1_1449696_1412000 3.3163600000000004
R25-126-127 n1_1449696_1487392 n1_1449696_1448480 3.5374499999999998
R25-126-128 n1_1449696_1526304 n1_1449696_1487392 3.5374499999999998
R25-126-129 n1_1449696_1562784 n1_1449696_1526304 3.3163600000000004
R25-126-130 n1_1449696_1601696 n1_1449696_1562784 3.5374499999999998
R25-126-131 n1_1449696_1641130 n1_1449696_1601696 3.58491
R25-126-132 n1_1449696_1641290 n1_1449696_1641130 0.0145455
R25-127-100 n1_1487392_480880 n1_1487392_480720 0.0145455
R25-127-101 n1_1487392_502432 n1_1487392_480880 1.95927
R25-127-102 n1_1487392_538912 n1_1487392_502432 3.3163600000000004
R25-127-103 n1_1487392_577824 n1_1487392_538912 3.5374499999999998
R25-127-104 n1_1487392_614304 n1_1487392_577824 3.3163600000000004
R25-127-105 n1_1487392_653216 n1_1487392_614304 3.5374499999999998
R25-127-106 n1_1487392_692128 n1_1487392_653216 3.5374499999999998
R25-127-107 n1_1487392_728608 n1_1487392_692128 3.3163600000000004
R25-127-108 n1_1487392_767520 n1_1487392_728608 3.5374499999999998
R25-127-109 n1_1487392_804000 n1_1487392_767520 3.3163600000000004
R25-127-110 n1_1487392_842912 n1_1487392_804000 3.5374499999999998
R25-127-111 n1_1487392_881824 n1_1487392_842912 3.5374499999999998
R25-127-112 n1_1487392_918304 n1_1487392_881824 3.3163600000000004
R25-127-113 n1_1487392_957216 n1_1487392_918304 3.5374499999999998
R25-127-114 n1_1487392_993696 n1_1487392_957216 3.3163600000000004
R25-127-115 n1_1487392_1032608 n1_1487392_993696 3.5374499999999998
R25-127-116 n1_1487392_1071520 n1_1487392_1032608 3.5374499999999998
R25-127-117 n1_1487392_1108000 n1_1487392_1071520 3.3163600000000004
R25-127-118 n1_1487392_1146912 n1_1487392_1108000 3.5374499999999998
R25-127-119 n1_1487392_1183392 n1_1487392_1146912 3.3163600000000004
R25-127-120 n1_1487392_1222304 n1_1487392_1183392 3.5374499999999998
R25-127-121 n1_1487392_1261216 n1_1487392_1222304 3.5374499999999998
R25-127-122 n1_1487392_1297696 n1_1487392_1261216 3.3163600000000004
R25-127-123 n1_1487392_1336608 n1_1487392_1297696 3.5374499999999998
R25-127-124 n1_1487392_1373088 n1_1487392_1336608 3.3163600000000004
R25-127-125 n1_1487392_1412000 n1_1487392_1373088 3.5374499999999998
R25-127-126 n1_1487392_1448480 n1_1487392_1412000 3.3163600000000004
R25-127-127 n1_1487392_1487392 n1_1487392_1448480 3.5374499999999998
R25-127-128 n1_1487392_1526304 n1_1487392_1487392 3.5374499999999998
R25-127-129 n1_1487392_1562784 n1_1487392_1526304 3.3163600000000004
R25-127-130 n1_1487392_1601696 n1_1487392_1562784 3.5374499999999998
R25-127-131 n1_1487392_1641130 n1_1487392_1601696 3.58491
R25-127-132 n1_1487392_1641290 n1_1487392_1641130 0.0145455
R25-128-100 n1_1526304_480880 n1_1526304_480720 0.0145455
R25-128-101 n1_1526304_502432 n1_1526304_480880 1.95927
R25-128-102 n1_1526304_538912 n1_1526304_502432 3.3163600000000004
R25-128-103 n1_1526304_577824 n1_1526304_538912 3.5374499999999998
R25-128-104 n1_1526304_614304 n1_1526304_577824 3.3163600000000004
R25-128-105 n1_1526304_653216 n1_1526304_614304 3.5374499999999998
R25-128-106 n1_1526304_692128 n1_1526304_653216 3.5374499999999998
R25-128-107 n1_1526304_728608 n1_1526304_692128 3.3163600000000004
R25-128-108 n1_1526304_767520 n1_1526304_728608 3.5374499999999998
R25-128-109 n1_1526304_804000 n1_1526304_767520 3.3163600000000004
R25-128-110 n1_1526304_842912 n1_1526304_804000 3.5374499999999998
R25-128-111 n1_1526304_881824 n1_1526304_842912 3.5374499999999998
R25-128-112 n1_1526304_918304 n1_1526304_881824 3.3163600000000004
R25-128-113 n1_1526304_957216 n1_1526304_918304 3.5374499999999998
R25-128-114 n1_1526304_993696 n1_1526304_957216 3.3163600000000004
R25-128-115 n1_1526304_1032608 n1_1526304_993696 3.5374499999999998
R25-128-116 n1_1526304_1071520 n1_1526304_1032608 3.5374499999999998
R25-128-117 n1_1526304_1108000 n1_1526304_1071520 3.3163600000000004
R25-128-118 n1_1526304_1146912 n1_1526304_1108000 3.5374499999999998
R25-128-119 n1_1526304_1183392 n1_1526304_1146912 3.3163600000000004
R25-128-120 n1_1526304_1222304 n1_1526304_1183392 3.5374499999999998
R25-128-121 n1_1526304_1261216 n1_1526304_1222304 3.5374499999999998
R25-128-122 n1_1526304_1297696 n1_1526304_1261216 3.3163600000000004
R25-128-123 n1_1526304_1336608 n1_1526304_1297696 3.5374499999999998
R25-128-124 n1_1526304_1373088 n1_1526304_1336608 3.3163600000000004
R25-128-125 n1_1526304_1412000 n1_1526304_1373088 3.5374499999999998
R25-128-126 n1_1526304_1448480 n1_1526304_1412000 3.3163600000000004
R25-128-127 n1_1526304_1487392 n1_1526304_1448480 3.5374499999999998
R25-128-128 n1_1526304_1526304 n1_1526304_1487392 3.5374499999999998
R25-128-129 n1_1526304_1562784 n1_1526304_1526304 3.3163600000000004
R25-128-130 n1_1526304_1601696 n1_1526304_1562784 3.5374499999999998
R25-128-131 n1_1526304_1641130 n1_1526304_1601696 3.58491
R25-128-132 n1_1526304_1641290 n1_1526304_1641130 0.0145455
R25-129-100 n1_1564000_480880 n1_1564000_480720 0.0145455
R25-129-101 n1_1564000_502432 n1_1564000_480880 1.95927
R25-129-102 n1_1564000_538912 n1_1564000_502432 3.3163600000000004
R25-129-103 n1_1564000_577824 n1_1564000_538912 3.5374499999999998
R25-129-104 n1_1564000_614304 n1_1564000_577824 3.3163600000000004
R25-129-105 n1_1564000_653216 n1_1564000_614304 3.5374499999999998
R25-129-106 n1_1564000_692128 n1_1564000_653216 3.5374499999999998
R25-129-107 n1_1564000_728608 n1_1564000_692128 3.3163600000000004
R25-129-108 n1_1564000_767520 n1_1564000_728608 3.5374499999999998
R25-129-109 n1_1564000_804000 n1_1564000_767520 3.3163600000000004
R25-129-110 n1_1564000_842912 n1_1564000_804000 3.5374499999999998
R25-129-111 n1_1564000_881824 n1_1564000_842912 3.5374499999999998
R25-129-112 n1_1564000_918304 n1_1564000_881824 3.3163600000000004
R25-129-113 n1_1564000_957216 n1_1564000_918304 3.5374499999999998
R25-129-114 n1_1564000_993696 n1_1564000_957216 3.3163600000000004
R25-129-115 n1_1564000_1032608 n1_1564000_993696 3.5374499999999998
R25-129-116 n1_1564000_1071520 n1_1564000_1032608 3.5374499999999998
R25-129-117 n1_1564000_1108000 n1_1564000_1071520 3.3163600000000004
R25-129-118 n1_1564000_1146912 n1_1564000_1108000 3.5374499999999998
R25-129-119 n1_1564000_1183392 n1_1564000_1146912 3.3163600000000004
R25-129-120 n1_1564000_1222304 n1_1564000_1183392 3.5374499999999998
R25-129-121 n1_1564000_1261216 n1_1564000_1222304 3.5374499999999998
R25-129-122 n1_1564000_1297696 n1_1564000_1261216 3.3163600000000004
R25-129-123 n1_1564000_1336608 n1_1564000_1297696 3.5374499999999998
R25-129-124 n1_1564000_1373088 n1_1564000_1336608 3.3163600000000004
R25-129-125 n1_1564000_1412000 n1_1564000_1373088 3.5374499999999998
R25-129-126 n1_1564000_1448480 n1_1564000_1412000 3.3163600000000004
R25-129-127 n1_1564000_1487392 n1_1564000_1448480 3.5374499999999998
R25-129-128 n1_1564000_1526304 n1_1564000_1487392 3.5374499999999998
R25-129-129 n1_1564000_1562784 n1_1564000_1526304 3.3163600000000004
R25-129-130 n1_1564000_1601696 n1_1564000_1562784 3.5374499999999998
R25-129-131 n1_1564000_1641130 n1_1564000_1601696 3.58491
R25-129-132 n1_1564000_1641290 n1_1564000_1641130 0.0145455
R25-130-100 n1_1602912_480880 n1_1602912_480720 0.0145455
R25-130-101 n1_1602912_502432 n1_1602912_480880 1.95927
R25-130-102 n1_1602912_538912 n1_1602912_502432 3.3163600000000004
R25-130-103 n1_1602912_577824 n1_1602912_538912 3.5374499999999998
R25-130-104 n1_1602912_614304 n1_1602912_577824 3.3163600000000004
R25-130-105 n1_1602912_653216 n1_1602912_614304 3.5374499999999998
R25-130-106 n1_1602912_692128 n1_1602912_653216 3.5374499999999998
R25-130-107 n1_1602912_728608 n1_1602912_692128 3.3163600000000004
R25-130-108 n1_1602912_767520 n1_1602912_728608 3.5374499999999998
R25-130-109 n1_1602912_804000 n1_1602912_767520 3.3163600000000004
R25-130-110 n1_1602912_842912 n1_1602912_804000 3.5374499999999998
R25-130-111 n1_1602912_881824 n1_1602912_842912 3.5374499999999998
R25-130-112 n1_1602912_918304 n1_1602912_881824 3.3163600000000004
R25-130-113 n1_1602912_957216 n1_1602912_918304 3.5374499999999998
R25-130-114 n1_1602912_993696 n1_1602912_957216 3.3163600000000004
R25-130-115 n1_1602912_1032608 n1_1602912_993696 3.5374499999999998
R25-130-116 n1_1602912_1071520 n1_1602912_1032608 3.5374499999999998
R25-130-117 n1_1602912_1108000 n1_1602912_1071520 3.3163600000000004
R25-130-118 n1_1602912_1146912 n1_1602912_1108000 3.5374499999999998
R25-130-119 n1_1602912_1183392 n1_1602912_1146912 3.3163600000000004
R25-130-120 n1_1602912_1222304 n1_1602912_1183392 3.5374499999999998
R25-130-121 n1_1602912_1261216 n1_1602912_1222304 3.5374499999999998
R25-130-122 n1_1602912_1297696 n1_1602912_1261216 3.3163600000000004
R25-130-123 n1_1602912_1336608 n1_1602912_1297696 3.5374499999999998
R25-130-124 n1_1602912_1373088 n1_1602912_1336608 3.3163600000000004
R25-130-125 n1_1602912_1412000 n1_1602912_1373088 3.5374499999999998
R25-130-126 n1_1602912_1448480 n1_1602912_1412000 3.3163600000000004
R25-130-127 n1_1602912_1487392 n1_1602912_1448480 3.5374499999999998
R25-130-128 n1_1602912_1526304 n1_1602912_1487392 3.5374499999999998
R25-130-129 n1_1602912_1562784 n1_1602912_1526304 3.3163600000000004
R25-130-130 n1_1602912_1601696 n1_1602912_1562784 3.5374499999999998
R25-130-131 n1_1602912_1641130 n1_1602912_1601696 3.58491
R25-130-132 n1_1602912_1641290 n1_1602912_1641130 0.0145455
R25-131-100 n1_1641180_480880 n1_1641180_480720 0.00727273
R25-131-101 n1_1641180_502432 n1_1641180_480880 0.979636
R25-131-102 n1_1641180_538912 n1_1641180_502432 1.6581800000000002
R25-131-103 n1_1641180_577824 n1_1641180_538912 1.7687300000000001
R25-131-104 n1_1641180_614304 n1_1641180_577824 1.6581800000000002
R25-131-105 n1_1641180_653216 n1_1641180_614304 1.7687300000000001
R25-131-106 n1_1641180_692128 n1_1641180_653216 1.7687300000000001
R25-131-107 n1_1641180_728608 n1_1641180_692128 1.6581800000000002
R25-131-108 n1_1641180_767520 n1_1641180_728608 1.7687300000000001
R25-131-109 n1_1641180_804000 n1_1641180_767520 1.6581800000000002
R25-131-110 n1_1641180_842912 n1_1641180_804000 1.7687300000000001
R25-131-111 n1_1641180_881824 n1_1641180_842912 1.7687300000000001
R25-131-112 n1_1641180_918304 n1_1641180_881824 1.6581800000000002
R25-131-113 n1_1641180_957216 n1_1641180_918304 1.7687300000000001
R25-131-114 n1_1641180_993696 n1_1641180_957216 1.6581800000000002
R25-131-115 n1_1641180_1032608 n1_1641180_993696 1.7687300000000001
R25-131-116 n1_1641180_1071520 n1_1641180_1032608 1.7687300000000001
R25-131-117 n1_1641180_1108000 n1_1641180_1071520 1.6581800000000002
R25-131-118 n1_1641180_1146912 n1_1641180_1108000 1.7687300000000001
R25-131-119 n1_1641180_1183392 n1_1641180_1146912 1.6581800000000002
R25-131-120 n1_1641180_1222304 n1_1641180_1183392 1.7687300000000001
R25-131-121 n1_1641180_1261216 n1_1641180_1222304 1.7687300000000001
R25-131-122 n1_1641180_1297696 n1_1641180_1261216 1.6581800000000002
R25-131-123 n1_1641180_1336608 n1_1641180_1297696 1.7687300000000001
R25-131-124 n1_1641180_1373088 n1_1641180_1336608 1.6581800000000002
R25-131-125 n1_1641180_1412000 n1_1641180_1373088 1.7687300000000001
R25-131-126 n1_1641180_1448480 n1_1641180_1412000 1.6581800000000002
R25-131-127 n1_1641180_1487392 n1_1641180_1448480 1.7687300000000001
R25-131-128 n1_1641180_1526304 n1_1641180_1487392 1.7687300000000001
R25-131-129 n1_1641180_1562784 n1_1641180_1526304 1.6581800000000002
R25-131-130 n1_1641180_1601696 n1_1641180_1562784 1.7687300000000001
R25-131-131 n1_1641180_1619905 n1_1641180_1601696 0.827682
R25-131-132 n1_1641180_1641130 n1_1641180_1619905 0.9647729999999999
R25-131-133 n1_1641180_1641290 n1_1641180_1641130 0.00727273
R41-100-100 n1_979937_1641130 n1_979937_1640970 0.0028
R41-100-101 n1_979937_1820000 n1_979937_1641130 3.13023
R41-100-102 n1_979937_1825000 n1_979937_1820000 0.0875
R41-101-100 n1_1620161_300000 n1_1620161_295000 0.0875
R41-101-101 n1_1620161_480880 n1_1620161_300000 3.1654
R41-101-102 n1_1620161_481040 n1_1620161_480880 0.0028
iB00_0_v n1_295000_940095 0 -0.00295234
iB00_1_v n1_300000_940095 0 -0.033065960000000005
iB00_2_v n1_474796_940095 0 1.0699720189716322e-14
iB00_3_v n1_474906_940095 0 -1.07012e-14
iB00_4_v n1_474796_918304 0 -1.6940658945086007e-18
iB00_5_v n1_474796_957216 0 8.470329472543003e-19
iB00_6_v n1_474796_993696 0 0.0
iB00_7_v n1_493920_957216 0 0.0001151050000000001
iB00_8_v n1_474686_957216 0 0.0
iB00_9_v n1_532832_957216 0 0.0003419320000000005
iB00_10_v n1_493920_918304 0 0.00010713500000000012
iB00_11_v n1_493920_993696 0 7.250000000000015e-05
iB00_12_v n1_493920_1032608 0 0.00014500999999999932
iB00_13_v n1_532832_993696 0 0.0002470130000000003
iB00_14_v n1_474686_993696 0 0.0
iB00_15_v n1_474796_1032608 0 -1.999999999970504e-08
iB00_16_v n1_474796_1071520 0 0.0
iB00_17_v n1_474686_1032608 0 0.0
iB00_18_v n1_532832_1032608 0 0.0002698900000000001
iB00_19_v n1_493920_1071520 0 0.0001450049999999998
iB00_20_v n1_493920_1108000 0 0.00010713000000000008
iB00_21_v n1_532832_1071520 0 0.00029544
iB00_22_v n1_474686_1071520 0 0.0
iB00_23_v n1_474796_1108000 0 -4.99999999992626e-09
iB00_24_v n1_474796_1146912 0 0.0
iB00_25_v n1_474686_1108000 0 0.0
iB00_26_v n1_532832_1108000 0 0.00021204399999999977
iB00_27_v n1_493920_1146912 0 8.325e-05
iB00_28_v n1_493920_1183392 0 0.00014500399999999987
iB00_29_v n1_532832_1146912 0 0.000360937
iB00_30_v n1_474686_1146912 0 0.0
iB00_31_v n1_474796_1183392 0 1.0587911840678754e-19
iB00_32_v n1_474796_1222304 0 5.000000000138018e-10
iB00_33_v n1_474686_1183392 0 0.0
iB00_34_v n1_532832_1183392 0 0.00023930974999999987
iB00_35_v n1_493920_1222304 0 7.250400000000005e-05
iB00_36_v n1_493920_1261216 0 0.00014500650000000002
iB00_37_v n1_532832_1222304 0 0.00026183274999999986
iB00_38_v n1_474686_1222304 0 0.0
iB00_39_v n1_474796_1261216 0 -3.499999999990734e-10
iB00_40_v n1_474796_1297696 0 3.499999999461338e-10
iB00_41_v n1_474686_1261216 0 0.0
iB00_42_v n1_532832_1261216 0 0.00028244450000000003
iB00_43_v n1_493920_1297696 0 0.00013482050000000002
iB00_44_v n1_493920_1336608 0 0.00013549499999999996
iB00_45_v n1_532832_1297696 0 0.00032117000000000007
iB00_46_v n1_474686_1297696 0 0.0
iB00_47_v n1_474796_1336608 0 -9.999999999746641e-10
iB00_48_v n1_474796_1373088 0 -5.000000000138018e-10
iB00_49_v n1_474686_1336608 0 0.0
iB00_50_v n1_532832_1336608 0 0.000313297
iB00_51_v n1_493920_1373088 0 0.00014731399999999995
iB00_52_v n1_493920_1412000 0 9.742685e-05
iB00_53_v n1_532832_1373088 0 0.0002595940000000001
iB00_54_v n1_474686_1373088 0 0.0
iB00_55_v n1_474796_1412000 0 9.99999999987899e-10
iB00_56_v n1_474796_1448480 0 1.9999999999493283e-09
iB00_57_v n1_474686_1412000 0 0.0
iB00_58_v n1_532832_1412000 0 0.00021750814999999993
iB00_59_v n1_493920_1448480 0 0.00014500475000000008
iB00_60_v n1_493920_1487392 0 0.00012886971000000008
iB00_61_v n1_532832_1448480 0 0.0002566627500000001
iB00_62_v n1_474686_1448480 0 0.0
iB00_63_v n1_474796_1487392 0 -4.709999999987672e-09
iB00_64_v n1_474796_1526304 0 2.0000000000552074e-09
iB00_65_v n1_474686_1487392 0 0.0
iB00_66_v n1_532832_1487392 0 0.00033021000000000005
iB00_67_v n1_493920_1526304 0 8.015749999999992e-05
iB00_68_v n1_493920_1562784 0 0.0001450065000000001
iB00_69_v n1_532832_1526304 0 0.00025540599999999996
iB00_70_v n1_474686_1526304 0 0.0
iB00_71_v n1_474796_1562784 0 -9.999999999746641e-10
iB00_72_v n1_474796_1601696 0 1.9999999999493283e-09
iB00_73_v n1_474686_1562784 0 0.0
iB00_74_v n1_532832_1562784 0 0.000424834
iB00_75_v n1_493920_1601696 0 7.250299999999997e-05
iB00_76_v n1_493920_1641130 0 -1.4999880739472848e-09
iB00_77_v n1_532832_1601696 0 0.0003996564999999999
iB00_78_v n1_474686_1601696 0 0.0
iB00_79_v n1_474796_1641130 0 2.3852447794681098e-14
iB00_80_v n1_474796_1641290 0 -2.385245e-14
iB00_81_v n1_474686_1641130 0 0.0
iB00_82_v n1_532832_1641130 0 1.1926305879118407e-14
iB00_83_v n1_493920_1641290 0 -1.19262e-14
iB00_84_v n1_570528_1641130 0 -4.999988073702363e-09
iB00_85_v n1_532832_1641290 0 -1.19262e-14
iB00_86_v n1_570528_1601696 0 0.00034347000000000007
iB00_87_v n1_609440_1601696 0 0.0003954849999999999
iB00_88_v n1_570528_1562784 0 0.0003839399999999999
iB00_89_v n1_570528_1641290 0 -1.19262e-14
iB00_90_v n1_609440_1641130 0 1.1925776483526373e-14
iB00_91_v n1_647136_1641130 0 -4.9999880724318135e-09
iB00_92_v n1_609440_1641290 0 -1.19262e-14
iB00_93_v n1_609440_1562784 0 0.0003536450000000003
iB00_94_v n1_647136_1601696 0 0.00034038499999999974
iB00_95_v n1_686048_1601696 0 0.00039589000000000047
iB00_96_v n1_647136_1562784 0 0.0005196799999999998
iB00_97_v n1_647136_1641290 0 -1.19262e-14
iB00_98_v n1_686048_1641130 0 -9.99998807365252e-09
iB00_99_v n1_723744_1641130 0 1.1926223897340549e-14
iB00_100_v n1_686048_1641290 0 -1.19262e-14
iB00_101_v n1_686048_1562784 0 0.0003365500000000004
iB00_102_v n1_723744_1601696 0 0.00047110499999999977
iB00_103_v n1_761440_1601696 0 0.0003263050000000001
iB00_104_v n1_723744_1562784 0 0.00040619499999999966
iB00_105_v n1_723744_1641290 0 -1.19262e-14
iB00_106_v n1_761440_1641130 0 1.1925776483526373e-14
iB00_107_v n1_800352_1641130 0 1.192452983144604e-14
iB00_108_v n1_761440_1641290 0 -1.19262e-14
iB00_109_v n1_761440_1562784 0 0.0002790849999999998
iB00_110_v n1_800352_1601696 0 0.0003643699999999999
iB00_111_v n1_838048_1601696 0 0.00038629499999999966
iB00_112_v n1_800352_1562784 0 0.0004194950000000013
iB00_113_v n1_800352_1641290 0 -1.19262e-14
iB00_114_v n1_838048_1641130 0 -1.4999988070614167e-08
iB00_115_v n1_876960_1641130 0 5.0000005963221584e-08
iB00_116_v n1_838048_1641290 0 -1.19262e-14
iB00_117_v n1_838048_1562784 0 0.0003369149999999995
iB00_118_v n1_876960_1601696 0 0.0003920500000000008
iB00_119_v n1_914656_1601696 0 0.00038299999999999787
iB00_120_v n1_876960_1562784 0 0.00027925000000000074
iB00_121_v n1_876960_1641290 0 -5.9631e-15
iB00_122_v n1_914656_1641130 0 -4.999999403531557e-08
iB00_123_v n1_952352_1641130 0 5.963111948670274e-15
iB00_124_v n1_914656_1641290 0 -5.9631e-15
iB00_125_v n1_914656_1562784 0 0.00040980000000000075
iB00_126_v n1_952352_1601696 0 0.0003680549999999976
iB00_127_v n1_991264_1601696 0 0.0004408950000000025
iB00_128_v n1_952352_1562784 0 0.00041073999999999955
iB00_129_v n1_952352_1641290 0 -5.9631e-15
iB00_130_v n1_979937_1641130 0 0.0
iB00_131_v n1_991264_1641130 0 -4.999999402684524e-08
iB00_132_v n1_979937_1640970 0 0.0
iB00_133_v n1_979937_1820000 0 -0.054402
iB00_134_v n1_979937_1825000 0 -0.0818085
iB00_135_v n1_1028960_1641130 0 5.963111948670274e-15
iB00_136_v n1_991264_1641290 0 -5.9631e-15
iB00_137_v n1_991264_1562784 0 0.00037824499999999895
iB00_138_v n1_1028960_1601696 0 0.00032814999999999955
iB00_139_v n1_1067872_1601696 0 0.00028705000000000007
iB00_140_v n1_1028960_1562784 0 0.0003863149999999994
iB00_141_v n1_1028960_1641290 0 -5.9631e-15
iB00_142_v n1_1067872_1641130 0 -4.999999403700964e-08
iB00_143_v n1_1105568_1641130 0 2.0000011927623004e-08
iB00_144_v n1_1067872_1641290 0 -5.9631e-15
iB00_145_v n1_1067872_1562784 0 0.0004271999999999999
iB00_146_v n1_1105568_1601696 0 0.00028223
iB00_147_v n1_1144480_1601696 0 0.00029828499999999997
iB00_148_v n1_1105568_1562784 0 0.0004015950000000002
iB00_149_v n1_1105568_1641290 0 -1.19262e-14
iB00_150_v n1_1144480_1641130 0 -1.4999988074425815e-08
iB00_151_v n1_1182176_1641130 0 2.5000011925431682e-08
iB00_152_v n1_1144480_1641290 0 -1.19262e-14
iB00_153_v n1_1144480_1562784 0 0.0003665100000000005
iB00_154_v n1_1182176_1601696 0 0.0002596950000000003
iB00_155_v n1_1219872_1601696 0 0.0003289049999999999
iB00_156_v n1_1182176_1562784 0 0.00037632999999999964
iB00_157_v n1_1182176_1641290 0 -1.19262e-14
iB00_158_v n1_1219872_1641130 0 -1.9999988073505043e-08
iB00_159_v n1_1258784_1641130 0 1.0000011925652901e-08
iB00_160_v n1_1219872_1641290 0 -1.19262e-14
iB00_161_v n1_1219872_1562784 0 0.00045922999999999933
iB00_162_v n1_1258784_1601696 0 0.0003451549999999997
iB00_163_v n1_1296480_1601696 0 0.00036879500000000005
iB00_164_v n1_1258784_1562784 0 0.0004446550000000002
iB00_165_v n1_1258784_1641290 0 -1.19262e-14
iB00_166_v n1_1296480_1641130 0 1.19262e-14
iB00_167_v n1_1335392_1641130 0 1.1926329776458956e-14
iB00_168_v n1_1296480_1641290 0 -1.19262e-14
iB00_169_v n1_1296480_1562784 0 0.000427855
iB00_170_v n1_1335392_1601696 0 0.0003271159999999998
iB00_171_v n1_1373088_1601696 0 0.0003929974999999997
iB00_172_v n1_1335392_1562784 0 0.0003554260000000002
iB00_173_v n1_1335392_1641290 0 -1.19262e-14
iB00_174_v n1_1373088_1641130 0 5.00011926319681e-10
iB00_175_v n1_1412000_1641130 0 -4.999880736840254e-10
iB00_176_v n1_1373088_1641290 0 -1.19262e-14
iB00_177_v n1_1373088_1562784 0 0.0004415189999999998
iB00_178_v n1_1412000_1601696 0 0.0003520664999999999
iB00_179_v n1_1449696_1601696 0 0.00039202000000000014
iB00_180_v n1_1412000_1562784 0 0.00035986
iB00_181_v n1_1412000_1641290 0 -1.19262e-14
iB00_182_v n1_1449696_1641130 0 1.1925988241763187e-14
iB00_183_v n1_1487392_1641130 0 1.1927070930287803e-14
iB00_184_v n1_1449696_1641290 0 -1.19262e-14
iB00_185_v n1_1449696_1562784 0 0.0003692500000000001
iB00_186_v n1_1487392_1601696 0 0.0003468899999999999
iB00_187_v n1_1526304_1601696 0 0.0002735150000000002
iB00_188_v n1_1487392_1562784 0 0.0004050299999999999
iB00_189_v n1_1487392_1641290 0 -1.19262e-14
iB00_190_v n1_1526304_1641130 0 1.0000011926264279e-08
iB00_191_v n1_1564000_1641130 0 -2.4999988072136855e-08
iB00_192_v n1_1526304_1641290 0 -1.19262e-14
iB00_193_v n1_1526304_1562784 0 0.0003633500000000001
iB00_194_v n1_1564000_1601696 0 0.00032589499999999933
iB00_195_v n1_1602912_1601696 0 0.0003157100000000001
iB00_196_v n1_1564000_1562784 0 0.0003125500000000005
iB00_197_v n1_1564000_1641290 0 -1.19262e-14
iB00_198_v n1_1602912_1641130 0 1.5000011925555263e-08
iB00_199_v n1_1641180_1641130 0 2.385245e-14
iB00_200_v n1_1602912_1641290 0 -1.19262e-14
iB00_201_v n1_1602912_1562784 0 0.00030646500000000045
iB00_202_v n1_1641180_1601696 0 0.0
iB00_203_v n1_1641290_1601696 0 0.0
iB00_204_v n1_1641180_1562784 0 2.0000000000128558e-08
iB00_205_v n1_1641180_1619905 0 1.07012e-14
iB00_206_v n1_1820088_1619905 0 -0.028103720000000002
iB00_207_v n1_1641070_1619905 0 -1.07012e-14
iB00_208_v n1_1825088_1619905 0 -0.00250928
iB00_209_v n1_1641180_1641290 0 -2.385245e-14
iB00_210_v n1_1641290_1641130 0 0.0
iB00_211_v n1_1641180_1526304 0 5.000000000349777e-09
iB00_212_v n1_1641290_1562784 0 0.0
iB00_213_v n1_1602912_1526304 0 0.00028913999999999974
iB00_214_v n1_1602912_1487392 0 0.0002856399999999997
iB00_215_v n1_1564000_1526304 0 0.0003929999999999999
iB00_216_v n1_1526304_1526304 0 0.00041643999999999996
iB00_217_v n1_1564000_1487392 0 0.00036228
iB00_218_v n1_1526304_1487392 0 0.0005054199999999996
iB00_219_v n1_1487392_1526304 0 0.00043050000000000016
iB00_220_v n1_1449696_1526304 0 0.0005377099999999998
iB00_221_v n1_1487392_1487392 0 0.0005717599999999999
iB00_222_v n1_1449696_1487392 0 0.00057118
iB00_223_v n1_1412000_1526304 0 0.0004596269999999999
iB00_224_v n1_1373088_1526304 0 0.00039970800000000003
iB00_225_v n1_1412000_1487392 0 0.0004186330000000002
iB00_226_v n1_1373088_1487392 0 0.0005060140000000003
iB00_227_v n1_1335392_1526304 0 0.00053938
iB00_228_v n1_1296480_1526304 0 0.0005180149999999997
iB00_229_v n1_1335392_1487392 0 0.00046687800000000005
iB00_230_v n1_1296480_1487392 0 0.00041686000000000034
iB00_231_v n1_1258784_1526304 0 0.0005013750000000003
iB00_232_v n1_1219872_1526304 0 0.0004689400000000001
iB00_233_v n1_1258784_1487392 0 0.0005689449999999997
iB00_234_v n1_1219872_1487392 0 0.00041788000000000014
iB00_235_v n1_1182176_1526304 0 0.00044865499999999984
iB00_236_v n1_1144480_1526304 0 0.0003079949999999999
iB00_237_v n1_1182176_1487392 0 0.0006697650000000004
iB00_238_v n1_1144480_1487392 0 0.0003500300000000004
iB00_239_v n1_1105568_1526304 0 0.00033728000000000046
iB00_240_v n1_1067872_1526304 0 0.00030510999999999885
iB00_241_v n1_1105568_1487392 0 0.00034753999999999905
iB00_242_v n1_1067872_1487392 0 0.000383650000000001
iB00_243_v n1_1028960_1526304 0 0.00032671000000000045
iB00_244_v n1_991264_1526304 0 0.0003051550000000011
iB00_245_v n1_1028960_1487392 0 0.0003761200000000015
iB00_246_v n1_991264_1487392 0 0.00042722500000000167
iB00_247_v n1_952352_1526304 0 0.00038775500000000015
iB00_248_v n1_914656_1526304 0 0.0003115100000000002
iB00_249_v n1_952352_1487392 0 0.0004441699999999997
iB00_250_v n1_914656_1487392 0 0.0003260050000000003
iB00_251_v n1_876960_1526304 0 0.00029226999999999845
iB00_252_v n1_838048_1526304 0 0.000281970000000003
iB00_253_v n1_876960_1487392 0 0.00034865499999999996
iB00_254_v n1_838048_1487392 0 0.00046584500000000043
iB00_255_v n1_800352_1526304 0 0.00041484999999999867
iB00_256_v n1_761440_1526304 0 0.00035766500000000007
iB00_257_v n1_800352_1487392 0 0.0004106250000000004
iB00_258_v n1_761440_1487392 0 0.00038362000000000015
iB00_259_v n1_723744_1526304 0 0.0003454249999999993
iB00_260_v n1_686048_1526304 0 0.00041762000000000017
iB00_261_v n1_723744_1487392 0 0.0003101799999999995
iB00_262_v n1_686048_1487392 0 0.0003546350000000003
iB00_263_v n1_647136_1526304 0 0.0003831699999999998
iB00_264_v n1_609440_1526304 0 0.00032524999999999975
iB00_265_v n1_647136_1487392 0 0.0003668250000000001
iB00_266_v n1_609440_1487392 0 0.00033438000000000044
iB00_267_v n1_570528_1526304 0 0.0004386149999999999
iB00_268_v n1_570528_1487392 0 0.00027245000000000004
iB00_269_v n1_570528_1448480 0 0.00033994900000000003
iB00_270_v n1_570528_1412000 0 0.00032743399999999993
iB00_271_v n1_609440_1448480 0 0.00034327999999999995
iB00_272_v n1_609440_1412000 0 0.0003402365
iB00_273_v n1_570528_1373088 0 0.00023017899999999998
iB00_274_v n1_570528_1336608 0 0.0003677465
iB00_275_v n1_609440_1373088 0 0.00037800499999999994
iB00_276_v n1_609440_1336608 0 0.0003066645000000001
iB00_277_v n1_570528_1297696 0 0.00031899889499999997
iB00_278_v n1_570528_1261216 0 0.0002601989999999998
iB00_279_v n1_609440_1297696 0 0.0003174241049999999
iB00_280_v n1_609440_1261216 0 0.0003202658000000001
iB00_281_v n1_570528_1222304 0 0.0003501855000000002
iB00_282_v n1_570528_1183392 0 0.00025183500000000006
iB00_283_v n1_609440_1222304 0 0.0002564380000000001
iB00_284_v n1_609440_1183392 0 0.00028630050000000003
iB00_285_v n1_570528_1146912 0 0.00028442150000000015
iB00_286_v n1_570528_1108000 0 0.0003129382000000001
iB00_287_v n1_609440_1146912 0 0.00022980999999999986
iB00_288_v n1_609440_1108000 0 0.00031689
iB00_289_v n1_570528_1071520 0 0.00016730129999999993
iB00_290_v n1_570528_1032608 0 0.0003848120000000002
iB00_291_v n1_609440_1071520 0 0.00038027
iB00_292_v n1_609440_1032608 0 0.00022221000000000025
iB00_293_v n1_570528_993696 0 0.00022037849999999998
iB00_294_v n1_570528_957216 0 0.0002597224999999997
iB00_295_v n1_609440_993696 0 0.00031016499999999967
iB00_296_v n1_532832_918304 0 0.00029956000000000026
iB00_297_v n1_609440_957216 0 0.0003233050000000003
iB00_298_v n1_570528_918304 0 0.00033058000000000013
iB00_299_v n1_570528_881824 0 0.00022949499999999975
iB00_300_v n1_609440_918304 0 0.00026171
iB00_301_v n1_532832_881824 0 0.0003093550000000002
iB00_302_v n1_532832_842912 0 0.0003509100000000002
iB00_303_v n1_493920_881824 0 7.72099999999993e-05
iB00_304_v n1_474796_881824 0 -1.999999999970504e-08
iB00_305_v n1_493920_842912 0 0.00016629500000000093
iB00_306_v n1_474686_918304 0 0.0
iB00_307_v n1_474796_842912 0 1.4999999999355264e-08
iB00_308_v n1_474686_881824 0 0.0
iB00_309_v n1_474796_804000 0 -9.99999999985252e-09
iB00_310_v n1_474686_842912 0 0.0
iB00_311_v n1_493920_804000 0 8.251999999999976e-05
iB00_312_v n1_493920_767520 0 0.00014500999999999932
iB00_313_v n1_532832_804000 0 0.00028121500000000035
iB00_314_v n1_474686_804000 0 0.0
iB00_315_v n1_474796_767520 0 1.499999999977878e-08
iB00_316_v n1_474796_728608 0 -2.5000000000054818e-08
iB00_317_v n1_474686_767520 0 0.0
iB00_318_v n1_532832_767520 0 0.00025594999999999985
iB00_319_v n1_493920_728608 0 8.568499999999988e-05
iB00_320_v n1_493920_692128 0 0.000131825
iB00_321_v n1_532832_728608 0 0.00018827500000000012
iB00_322_v n1_474686_728608 0 0.0
iB00_323_v n1_474796_692128 0 3.1763735522036263e-19
iB00_324_v n1_474796_653216 0 0.0
iB00_325_v n1_474686_692128 0 0.0
iB00_326_v n1_532832_692128 0 0.00031216000000000013
iB00_327_v n1_493920_653216 0 0.00016687999999999992
iB00_328_v n1_493920_614304 0 0.00010473500000000016
iB00_329_v n1_532832_653216 0 0.00022530999999999983
iB00_330_v n1_474686_653216 0 0.0
iB00_331_v n1_474796_614304 0 0.0
iB00_332_v n1_474796_577824 0 -2.1175823681357508e-19
iB00_333_v n1_474686_614304 0 0.0
iB00_334_v n1_532832_614304 0 0.00026610999999999996
iB00_335_v n1_493920_577824 0 0.00011508500000000008
iB00_336_v n1_493920_538912 0 0.0001150855
iB00_337_v n1_532832_577824 0 0.00031553999999999995
iB00_338_v n1_474686_577824 0 0.0
iB00_339_v n1_474796_538912 0 -4.999999999608623e-10
iB00_340_v n1_474796_502432 0 -2.49999999996313e-09
iB00_341_v n1_474686_538912 0 0.0
iB00_342_v n1_532832_538912 0 0.0003270230000000002
iB00_343_v n1_493920_502432 0 7.2504e-05
iB00_344_v n1_493920_480880 0 3.500011926190734e-09
iB00_345_v n1_532832_502432 0 0.0001620805
iB00_346_v n1_474686_502432 0 0.0
iB00_347_v n1_474796_480880 0 2.3852447794681098e-14
iB00_348_v n1_474796_480720 0 -2.385245e-14
iB00_349_v n1_474686_480880 0 0.0
iB00_350_v n1_532832_480880 0 -3.4999880737800714e-09
iB00_351_v n1_493920_480720 0 -1.19262e-14
iB00_352_v n1_570528_480880 0 -4.999880738138019e-10
iB00_353_v n1_532832_480720 0 -1.19262e-14
iB00_354_v n1_570528_502432 0 0.00021193349999999999
iB00_355_v n1_609440_502432 0 0.00015708814999999994
iB00_356_v n1_570528_538912 0 0.000285041
iB00_357_v n1_570528_577824 0 0.00031949949999999995
iB00_358_v n1_609440_538912 0 0.0003427728499999999
iB00_359_v n1_609440_577824 0 0.00015232300000000022
iB00_360_v n1_570528_614304 0 0.00042972500000000005
iB00_361_v n1_570528_653216 0 0.00029488499999999994
iB00_362_v n1_609440_614304 0 0.00029863200000000006
iB00_363_v n1_609440_653216 0 0.000335555
iB00_364_v n1_570528_692128 0 0.0002426149999999999
iB00_365_v n1_570528_728608 0 0.00032247999999999993
iB00_366_v n1_609440_692128 0 0.0003456600000000001
iB00_367_v n1_609440_728608 0 0.00031230499999999986
iB00_368_v n1_570528_767520 0 0.00029946
iB00_369_v n1_570528_804000 0 0.00034868999999999986
iB00_370_v n1_609440_767520 0 0.000309855
iB00_371_v n1_609440_804000 0 0.00025265000000000004
iB00_372_v n1_570528_842912 0 0.000344975
iB00_373_v n1_609440_842912 0 0.00029925000000000015
iB00_374_v n1_647136_842912 0 0.0004094449999999998
iB00_375_v n1_609440_881824 0 0.00034598500000000015
iB00_376_v n1_647136_881824 0 0.0002867599999999999
iB00_377_v n1_686048_881824 0 0.00024153499999999994
iB00_378_v n1_647136_918304 0 0.0002708249999999999
iB00_379_v n1_647136_957216 0 0.00023413499999999993
iB00_380_v n1_686048_918304 0 0.0003766300000000003
iB00_381_v n1_686048_957216 0 0.0003485750000000001
iB00_382_v n1_647136_993696 0 0.00030285000000000007
iB00_383_v n1_647136_1032608 0 0.0003205599999999999
iB00_384_v n1_686048_993696 0 0.00032991999999999993
iB00_385_v n1_686048_1032608 0 0.00041640300000000014
iB00_386_v n1_647136_1071520 0 0.00029450500000000003
iB00_387_v n1_647136_1108000 0 0.00037105400000000016
iB00_388_v n1_686048_1071520 0 0.00033529149999999967
iB00_389_v n1_686048_1108000 0 0.00037763100000000023
iB00_390_v n1_647136_1146912 0 0.00033354349999999974
iB00_391_v n1_647136_1183392 0 0.00035110000000000013
iB00_392_v n1_686048_1146912 0 0.0003620084999999996
iB00_393_v n1_686048_1183392 0 0.00036960450000000027
iB00_394_v n1_647136_1222304 0 0.0002377815000000002
iB00_395_v n1_647136_1261216 0 0.00027722469999999966
iB00_396_v n1_686048_1222304 0 0.0003742564999999999
iB00_397_v n1_686048_1261216 0 0.00018510549999999976
iB00_398_v n1_647136_1297696 0 0.00028075950000000017
iB00_399_v n1_647136_1336608 0 0.00028288399999999963
iB00_400_v n1_686048_1297696 0 0.00034603850000000007
iB00_401_v n1_686048_1336608 0 0.0004165399999999998
iB00_402_v n1_647136_1373088 0 0.0003244900000000001
iB00_403_v n1_647136_1412000 0 0.000355675
iB00_404_v n1_686048_1373088 0 0.0003670600000000002
iB00_405_v n1_686048_1412000 0 0.0004876199999999999
iB00_406_v n1_647136_1448480 0 0.00044247500000000006
iB00_407_v n1_686048_1448480 0 0.00031511000000000023
iB00_408_v n1_723744_1448480 0 0.0003482600000000003
iB00_409_v n1_761440_1448480 0 0.0003920849999999998
iB00_410_v n1_723744_1412000 0 0.0003180149999999997
iB00_411_v n1_761440_1412000 0 0.0003796850000000006
iB00_412_v n1_800352_1448480 0 0.0003952750000000002
iB00_413_v n1_838048_1448480 0 0.00045130499999999934
iB00_414_v n1_800352_1412000 0 0.0003173350000000007
iB00_415_v n1_838048_1412000 0 0.0003356699999999996
iB00_416_v n1_876960_1448480 0 0.0004733049999999997
iB00_417_v n1_914656_1448480 0 0.0003520099999999998
iB00_418_v n1_876960_1412000 0 0.0004582299999999997
iB00_419_v n1_914656_1412000 0 0.0003997249999999998
iB00_420_v n1_952352_1448480 0 0.00038950000000000025
iB00_421_v n1_991264_1448480 0 0.00029274999999999977
iB00_422_v n1_952352_1412000 0 0.00037071700000000017
iB00_423_v n1_991264_1412000 0 0.00034896399999999854
iB00_424_v n1_1028960_1448480 0 0.000416585000000001
iB00_425_v n1_1067872_1448480 0 0.0004076849999999989
iB00_426_v n1_1028960_1412000 0 0.0003338039999999991
iB00_427_v n1_1067872_1412000 0 0.00032329500000000046
iB00_428_v n1_1105568_1448480 0 0.0003922250000000003
iB00_429_v n1_1144480_1448480 0 0.0002988500000000005
iB00_430_v n1_1105568_1412000 0 0.0002723849999999993
iB00_431_v n1_1144480_1412000 0 0.00043187499999999997
iB00_432_v n1_1182176_1448480 0 0.0003569849999999995
iB00_433_v n1_1219872_1448480 0 0.0005836649999999997
iB00_434_v n1_1182176_1412000 0 0.00043649499999999964
iB00_435_v n1_1219872_1412000 0 0.00043295499999999973
iB00_436_v n1_1258784_1448480 0 0.0004459100000000001
iB00_437_v n1_1296480_1448480 0 0.0005393250000000003
iB00_438_v n1_1258784_1412000 0 0.000356165
iB00_439_v n1_1296480_1412000 0 0.0004352165000000002
iB00_440_v n1_1335392_1448480 0 0.00065424
iB00_441_v n1_1373088_1448480 0 0.0006223174999999999
iB00_442_v n1_1335392_1412000 0 0.00041371350000000013
iB00_443_v n1_1373088_1412000 0 0.00045315000000000004
iB00_444_v n1_1412000_1448480 0 0.00039480249999999977
iB00_445_v n1_1449696_1448480 0 0.0005601899999999999
iB00_446_v n1_1412000_1412000 0 0.00041617499999999975
iB00_447_v n1_1449696_1412000 0 0.00048757499999999997
iB00_448_v n1_1487392_1448480 0 0.0004105299999999999
iB00_449_v n1_1526304_1448480 0 0.00042119499999999997
iB00_450_v n1_1487392_1412000 0 0.0005975100000000002
iB00_451_v n1_1526304_1412000 0 0.0005579850000000002
iB00_452_v n1_1564000_1448480 0 0.000494365
iB00_453_v n1_1602912_1448480 0 0.0003688400000000002
iB00_454_v n1_1564000_1412000 0 0.0004782299999999999
iB00_455_v n1_1641180_1487392 0 -4.499999999975986e-08
iB00_456_v n1_1602912_1412000 0 0.00030810000000000006
iB00_457_v n1_1641180_1448480 0 5.0000000000109636e-08
iB00_458_v n1_1641290_1448480 0 0.0
iB00_459_v n1_1641180_1412000 0 -2.0000000000340316e-08
iB00_460_v n1_1641290_1487392 0 0.0
iB00_461_v n1_1641290_1526304 0 0.0
iB00_462_v n1_1641180_1373088 0 4.2351647362715017e-19
iB00_463_v n1_1641290_1412000 0 0.0
iB00_464_v n1_1602912_1373088 0 0.0004136350000000001
iB00_465_v n1_1602912_1336608 0 0.00039886499999999977
iB00_466_v n1_1564000_1373088 0 0.00037498500000000004
iB00_467_v n1_1526304_1373088 0 0.00051191
iB00_468_v n1_1564000_1336608 0 0.000578115
iB00_469_v n1_1526304_1336608 0 0.0004171499999999999
iB00_470_v n1_1487392_1373088 0 0.0005322300000000001
iB00_471_v n1_1449696_1373088 0 0.00044977000000000016
iB00_472_v n1_1487392_1336608 0 0.000372145
iB00_473_v n1_1449696_1336608 0 0.0005073349999999998
iB00_474_v n1_1412000_1373088 0 0.0005835865000000001
iB00_475_v n1_1373088_1373088 0 0.0006100728500000001
iB00_476_v n1_1412000_1336608 0 0.0005059754999999999
iB00_477_v n1_1373088_1336608 0 0.0005488855
iB00_478_v n1_1335392_1373088 0 0.0005710656499999998
iB00_479_v n1_1296480_1373088 0 0.0005416450000000002
iB00_480_v n1_1335392_1336608 0 0.0005287674999999999
iB00_481_v n1_1296480_1336608 0 0.00039432649999999997
iB00_482_v n1_1258784_1373088 0 0.0005354350000000003
iB00_483_v n1_1219872_1373088 0 0.0004671499999999996
iB00_484_v n1_1258784_1336608 0 0.0004041349999999997
iB00_485_v n1_1219872_1336608 0 0.00037662000000000004
iB00_486_v n1_1182176_1373088 0 0.00038942000000000056
iB00_487_v n1_1144480_1373088 0 0.00025057999999999965
iB00_488_v n1_1182176_1336608 0 0.0004030650000000005
iB00_489_v n1_1144480_1336608 0 0.0004248549999999993
iB00_490_v n1_1105568_1373088 0 0.000368575000000001
iB00_491_v n1_1067872_1373088 0 0.0003729549999999997
iB00_492_v n1_1105568_1336608 0 0.00033185499999999934
iB00_493_v n1_1067872_1336608 0 0.000388685
iB00_494_v n1_1028960_1373088 0 0.0003764194999999995
iB00_495_v n1_991264_1373088 0 0.00045667149999999997
iB00_496_v n1_1028960_1336608 0 0.00034588899999999983
iB00_497_v n1_991264_1336608 0 0.0003446449999999998
iB00_498_v n1_952352_1373088 0 0.0003708389999999999
iB00_499_v n1_914656_1373088 0 0.0005481700000000004
iB00_500_v n1_952352_1336608 0 0.00043243100000000064
iB00_501_v n1_914656_1336608 0 0.000275730000000001
iB00_502_v n1_876960_1373088 0 0.0004511300000000002
iB00_503_v n1_838048_1373088 0 0.0004382249999999989
iB00_504_v n1_876960_1336608 0 0.0004622500000000003
iB00_505_v n1_838048_1336608 0 0.00033681499999999926
iB00_506_v n1_800352_1373088 0 0.0003576949999999996
iB00_507_v n1_761440_1373088 0 0.0004260700000000003
iB00_508_v n1_800352_1336608 0 0.0003683950000000004
iB00_509_v n1_761440_1336608 0 0.00042858999999999996
iB00_510_v n1_723744_1373088 0 0.0004683599999999998
iB00_511_v n1_723744_1336608 0 0.0003451800000000004
iB00_512_v n1_723744_1297696 0 0.0003663550000000001
iB00_513_v n1_723744_1261216 0 0.00024646300000000015
iB00_514_v n1_761440_1297696 0 0.00027737500000000006
iB00_515_v n1_761440_1261216 0 0.0003813100000000003
iB00_516_v n1_723744_1222304 0 0.00028241800000000015
iB00_517_v n1_723744_1183392 0 0.00032975599999999984
iB00_518_v n1_761440_1222304 0 0.00038137649999999974
iB00_519_v n1_761440_1183392 0 0.00033203500000000044
iB00_520_v n1_723744_1146912 0 0.00023149450000000004
iB00_521_v n1_723744_1108000 0 0.00033040049999999996
iB00_522_v n1_761440_1146912 0 0.0003797174999999997
iB00_523_v n1_761440_1108000 0 0.00032744349999999986
iB00_524_v n1_723744_1071520 0 0.000322105
iB00_525_v n1_723744_1032608 0 0.00024073600000000002
iB00_526_v n1_761440_1071520 0 0.0003325051000000003
iB00_527_v n1_761440_1032608 0 0.0003581765
iB00_528_v n1_723744_993696 0 0.0003040034999999998
iB00_529_v n1_723744_957216 0 0.0003181080000000002
iB00_530_v n1_761440_993696 0 0.0003352739999999997
iB00_531_v n1_761440_957216 0 0.00033213650000000046
iB00_532_v n1_723744_918304 0 0.0003349295
iB00_533_v n1_723744_881824 0 0.0003670364999999999
iB00_534_v n1_761440_918304 0 0.0003365769999999999
iB00_535_v n1_686048_842912 0 0.00027329999999999987
iB00_536_v n1_761440_881824 0 0.0004145879999999999
iB00_537_v n1_723744_842912 0 0.00033349050000000015
iB00_538_v n1_723744_804000 0 0.0003304044999999999
iB00_539_v n1_761440_842912 0 0.0003812050000000001
iB00_540_v n1_686048_804000 0 0.00030915000000000006
iB00_541_v n1_686048_767520 0 0.0003370000000000002
iB00_542_v n1_647136_804000 0 0.0003039350000000001
iB00_543_v n1_647136_767520 0 0.00030476500000000014
iB00_544_v n1_647136_728608 0 0.00024005499999999995
iB00_545_v n1_686048_728608 0 0.0003364249999999998
iB00_546_v n1_647136_692128 0 0.0002787599999999999
iB00_547_v n1_647136_653216 0 0.00027550199999999995
iB00_548_v n1_686048_692128 0 0.00025056300000000003
iB00_549_v n1_686048_653216 0 0.00030104649999999997
iB00_550_v n1_647136_614304 0 0.0002053485000000001
iB00_551_v n1_647136_577824 0 0.000380272
iB00_552_v n1_686048_614304 0 0.000277683
iB00_553_v n1_686048_577824 0 0.00028041859999999993
iB00_554_v n1_647136_538912 0 0.0002819624999999999
iB00_555_v n1_647136_502432 0 0.0001604915
iB00_556_v n1_686048_538912 0 0.0003668689000000001
iB00_557_v n1_609440_480880 0 3.000011926176932e-09
iB00_558_v n1_686048_502432 0 0.00016934699999999998
iB00_559_v n1_647136_480880 0 -2.9999880737530346e-09
iB00_560_v n1_647136_480720 0 -1.19262e-14
iB00_561_v n1_686048_480880 0 1.0000119262250313e-09
iB00_562_v n1_609440_480720 0 -1.19262e-14
iB00_563_v n1_570528_480720 0 -1.19262e-14
iB00_564_v n1_723744_480880 0 1.1926226469779602e-14
iB00_565_v n1_686048_480720 0 -1.19262e-14
iB00_566_v n1_723744_502432 0 0.00014500599999999993
iB00_567_v n1_761440_502432 0 0.00011508799999999994
iB00_568_v n1_723744_538912 0 0.00031620600000000003
iB00_569_v n1_723744_577824 0 0.0002567117
iB00_570_v n1_761440_538912 0 0.0002776895
iB00_571_v n1_761440_577824 0 0.00034661109999999996
iB00_572_v n1_723744_614304 0 0.0003798588
iB00_573_v n1_723744_653216 0 0.0003006475
iB00_574_v n1_761440_614304 0 0.00026535370000000004
iB00_575_v n1_761440_653216 0 0.0002614165000000001
iB00_576_v n1_723744_692128 0 0.00039100950000000006
iB00_577_v n1_723744_728608 0 0.0003541895000000001
iB00_578_v n1_761440_692128 0 0.00029925949999999997
iB00_579_v n1_761440_728608 0 0.00035218649999999995
iB00_580_v n1_723744_767520 0 0.0002922874999999999
iB00_581_v n1_761440_767520 0 0.00033980850000000004
iB00_582_v n1_800352_767520 0 0.0003996169999999999
iB00_583_v n1_761440_804000 0 0.00031087849999999995
iB00_584_v n1_800352_804000 0 0.000281522695
iB00_585_v n1_838048_804000 0 0.00033375930500000007
iB00_586_v n1_800352_842912 0 0.00025171140000000003
iB00_587_v n1_800352_881824 0 0.00034153870000000003
iB00_588_v n1_838048_842912 0 0.0003460806
iB00_589_v n1_838048_881824 0 0.0002712038
iB00_590_v n1_800352_918304 0 0.00026735744999999985
iB00_591_v n1_800352_957216 0 0.00031018740000000004
iB00_592_v n1_838048_918304 0 0.0003567170500000001
iB00_593_v n1_838048_957216 0 0.00030072259999999973
iB00_594_v n1_800352_993696 0 0.00038044280000000004
iB00_595_v n1_800352_1032608 0 0.0003040420000000001
iB00_596_v n1_838048_993696 0 0.00031739270000000013
iB00_597_v n1_838048_1032608 0 0.000346203
iB00_598_v n1_800352_1071520 0 0.00038458290000000005
iB00_599_v n1_800352_1108000 0 0.00037361149999999967
iB00_600_v n1_838048_1071520 0 0.0002701740000000003
iB00_601_v n1_838048_1108000 0 0.00024073349999999974
iB00_602_v n1_800352_1146912 0 0.0003396494999999999
iB00_603_v n1_800352_1183392 0 0.00035695149999999995
iB00_604_v n1_838048_1146912 0 0.00021978499999999936
iB00_605_v n1_838048_1183392 0 0.0003533615000000004
iB00_606_v n1_800352_1222304 0 0.00031979000000000057
iB00_607_v n1_800352_1261216 0 0.00034227999999999955
iB00_608_v n1_838048_1222304 0 0.0003286149999999995
iB00_609_v n1_838048_1261216 0 0.000377715
iB00_610_v n1_800352_1297696 0 0.0003291600000000001
iB00_611_v n1_838048_1297696 0 0.0002698550000000006
iB00_612_v n1_876960_1297696 0 0.00019453999999999983
iB00_613_v n1_914656_1297696 0 0.0003634199999999997
iB00_614_v n1_876960_1261216 0 0.00034868000000000046
iB00_615_v n1_914656_1261216 0 0.0003340199999999998
iB00_616_v n1_952352_1297696 0 0.0003564864999999988
iB00_617_v n1_991264_1297696 0 0.0003578589999999998
iB00_618_v n1_952352_1261216 0 0.0003450320000000001
iB00_619_v n1_991264_1261216 0 0.00022394615000000042
iB00_620_v n1_1028960_1297696 0 0.000511958500000001
iB00_621_v n1_1067872_1297696 0 0.0003947660000000011
iB00_622_v n1_1028960_1261216 0 0.0006233008499999998
iB00_623_v n1_1067872_1261216 0 0.0002842629999999996
iB00_624_v n1_1105568_1297696 0 0.0003923949999999999
iB00_625_v n1_1144480_1297696 0 0.0004193200000000002
iB00_626_v n1_1105568_1261216 0 0.0004559090000000001
iB00_627_v n1_1144480_1261216 0 0.0003304869999999999
iB00_628_v n1_1182176_1297696 0 0.0002881350000000002
iB00_629_v n1_1219872_1297696 0 0.00031540600000000006
iB00_630_v n1_1182176_1261216 0 0.0005623119999999996
iB00_631_v n1_1219872_1261216 0 0.0003651305
iB00_632_v n1_1258784_1297696 0 0.0005707754999999998
iB00_633_v n1_1296480_1297696 0 0.0005013451000000001
iB00_634_v n1_1258784_1261216 0 0.00041370554999999986
iB00_635_v n1_1296480_1261216 0 0.0004164889499999999
iB00_636_v n1_1335392_1297696 0 0.0004928544000000002
iB00_637_v n1_1373088_1297696 0 0.000388662
iB00_638_v n1_1335392_1261216 0 0.0003827714999999999
iB00_639_v n1_1373088_1261216 0 0.00035466849999999994
iB00_640_v n1_1412000_1297696 0 0.00045151200000000005
iB00_641_v n1_1449696_1297696 0 0.0005658375
iB00_642_v n1_1412000_1261216 0 0.000356627
iB00_643_v n1_1449696_1261216 0 0.0005524185
iB00_644_v n1_1487392_1297696 0 0.0005050945
iB00_645_v n1_1526304_1297696 0 0.0005020975
iB00_646_v n1_1487392_1261216 0 0.0004556255
iB00_647_v n1_1526304_1261216 0 0.00054156981
iB00_648_v n1_1564000_1297696 0 0.00044918700000000003
iB00_649_v n1_1602912_1297696 0 0.0005571749999999999
iB00_650_v n1_1564000_1261216 0 0.0004819175499999999
iB00_651_v n1_1641180_1336608 0 -4.99999999992626e-09
iB00_652_v n1_1602912_1261216 0 0.0004415573500000001
iB00_653_v n1_1641180_1297696 0 0.0
iB00_654_v n1_1641290_1297696 0 0.0
iB00_655_v n1_1641180_1261216 0 2.999999999871053e-09
iB00_656_v n1_1641290_1336608 0 0.0
iB00_657_v n1_1641290_1373088 0 0.0
iB00_658_v n1_1641180_1222304 0 -2.9999999997651737e-09
iB00_659_v n1_1641290_1261216 0 0.0
iB00_660_v n1_1602912_1222304 0 0.0004157766499999997
iB00_661_v n1_1602912_1183392 0 0.0004786310000000004
iB00_662_v n1_1564000_1222304 0 0.00045484395000000013
iB00_663_v n1_1526304_1222304 0 0.00042331569
iB00_664_v n1_1564000_1183392 0 0.0003776964999999998
iB00_665_v n1_1526304_1183392 0 0.0006261119999999998
iB00_666_v n1_1487392_1222304 0 0.000498309
iB00_667_v n1_1449696_1222304 0 0.0005170705000000002
iB00_668_v n1_1487392_1183392 0 0.00047332599999999993
iB00_669_v n1_1449696_1183392 0 0.0005178334999999999
iB00_670_v n1_1412000_1222304 0 0.0004154588499999999
iB00_671_v n1_1373088_1222304 0 0.0003521955000000001
iB00_672_v n1_1412000_1183392 0 0.0004359956500000001
iB00_673_v n1_1373088_1183392 0 0.00038682154999999995
iB00_674_v n1_1335392_1222304 0 0.0003657630000000001
iB00_675_v n1_1296480_1222304 0 0.0005519020000000001
iB00_676_v n1_1335392_1183392 0 0.000440645
iB00_677_v n1_1296480_1183392 0 0.00036017699999999994
iB00_678_v n1_1258784_1222304 0 0.0002706409800000002
iB00_679_v n1_1219872_1222304 0 0.00035081551999999975
iB00_680_v n1_1258784_1183392 0 0.000445522
iB00_681_v n1_1219872_1183392 0 0.00033355250000000015
iB00_682_v n1_1182176_1222304 0 0.0003444255000000002
iB00_683_v n1_1144480_1222304 0 0.0002958029999999997
iB00_684_v n1_1182176_1183392 0 0.00030315574999999976
iB00_685_v n1_1144480_1183392 0 0.00029715404999999985
iB00_686_v n1_1105568_1222304 0 0.0004620704999999999
iB00_687_v n1_1067872_1222304 0 0.0003581257499999998
iB00_688_v n1_1105568_1183392 0 0.0003593877000000004
iB00_689_v n1_1067872_1183392 0 0.00044472250000000005
iB00_690_v n1_1028960_1222304 0 0.0004385317499999995
iB00_691_v n1_991264_1222304 0 0.00037075150000000033
iB00_692_v n1_1028960_1183392 0 0.0003301050000000005
iB00_693_v n1_991264_1183392 0 0.0003759064999999999
iB00_694_v n1_952352_1222304 0 0.00042744299999999963
iB00_695_v n1_914656_1222304 0 0.00029967749999999967
iB00_696_v n1_952352_1183392 0 0.00024949150000000013
iB00_697_v n1_914656_1183392 0 0.00035109200000000006
iB00_698_v n1_876960_1222304 0 0.0003720800000000001
iB00_699_v n1_876960_1183392 0 0.0003601045
iB00_700_v n1_876960_1146912 0 0.00035278649999999985
iB00_701_v n1_876960_1108000 0 0.00037410849999999985
iB00_702_v n1_914656_1146912 0 0.00033688599999999973
iB00_703_v n1_914656_1108000 0 0.00035135350000000076
iB00_704_v n1_876960_1071520 0 0.00029111400000000003
iB00_705_v n1_876960_1032608 0 0.00032847100000000016
iB00_706_v n1_914656_1071520 0 0.0003247349999999995
iB00_707_v n1_914656_1032608 0 0.00044447600000000045
iB00_708_v n1_876960_993696 0 0.0003215994999999998
iB00_709_v n1_876960_957216 0 0.0003387680000000002
iB00_710_v n1_914656_993696 0 0.0003490854999999999
iB00_711_v n1_914656_957216 0 0.000288107
iB00_712_v n1_876960_918304 0 0.0003577274999999999
iB00_713_v n1_876960_881824 0 0.00032991300000000004
iB00_714_v n1_914656_918304 0 0.00024410499999999983
iB00_715_v n1_914656_881824 0 0.00030567000000000013
iB00_716_v n1_876960_842912 0 0.0003764429999999999
iB00_717_v n1_876960_804000 0 0.00028748349999999995
iB00_718_v n1_914656_842912 0 0.00036546899999999994
iB00_719_v n1_838048_767520 0 0.000268341
iB00_720_v n1_914656_804000 0 0.00038927300000000004
iB00_721_v n1_876960_767520 0 0.00030719550000000013
iB00_722_v n1_876960_728608 0 0.000324488
iB00_723_v n1_914656_767520 0 0.0003222705
iB00_724_v n1_838048_728608 0 0.00033643399999999993
iB00_725_v n1_838048_692128 0 0.0003687355
iB00_726_v n1_800352_728608 0 0.0002773655
iB00_727_v n1_800352_692128 0 0.0004843055
iB00_728_v n1_800352_653216 0 0.00034743485
iB00_729_v n1_838048_653216 0 0.0003197812
iB00_730_v n1_800352_614304 0 0.0002889311
iB00_731_v n1_800352_577824 0 0.00024472425
iB00_732_v n1_838048_614304 0 0.00030777029999999996
iB00_733_v n1_838048_577824 0 0.000350187
iB00_734_v n1_800352_538912 0 0.0002471215
iB00_735_v n1_800352_502432 0 0.00018701900000000002
iB00_736_v n1_838048_538912 0 0.0003524
iB00_737_v n1_761440_480880 0 1.1926173530220399e-14
iB00_738_v n1_838048_502432 0 8.027149999999996e-05
iB00_739_v n1_800352_480880 0 -4.999880737899045e-10
iB00_740_v n1_800352_480720 0 -1.19262e-14
iB00_741_v n1_838048_480880 0 1.0000119263044406e-09
iB00_742_v n1_761440_480720 0 -1.19262e-14
iB00_743_v n1_723744_480720 0 -1.19262e-14
iB00_744_v n1_876960_480880 0 -2.4999880739748883e-09
iB00_745_v n1_838048_480720 0 -1.19262e-14
iB00_746_v n1_876960_502432 0 0.00013723700000000004
iB00_747_v n1_914656_502432 0 0.00014500699999999998
iB00_748_v n1_876960_538912 0 0.00034612550000000014
iB00_749_v n1_876960_577824 0 0.000247597
iB00_750_v n1_914656_538912 0 0.00028182399999999996
iB00_751_v n1_914656_577824 0 0.00029243150000000007
iB00_752_v n1_876960_614304 0 0.0002523445000000001
iB00_753_v n1_876960_653216 0 0.000320268
iB00_754_v n1_914656_614304 0 0.000321419
iB00_755_v n1_914656_653216 0 0.00036909774999999996
iB00_756_v n1_876960_692128 0 0.000350551
iB00_757_v n1_914656_692128 0 0.00032295775000000006
iB00_758_v n1_952352_692128 0 0.00035030299999999983
iB00_759_v n1_914656_728608 0 0.0002675675000000001
iB00_760_v n1_952352_728608 0 0.00036065549999999994
iB00_761_v n1_991264_728608 0 0.0002842033399999999
iB00_762_v n1_952352_767520 0 0.000294826
iB00_763_v n1_952352_804000 0 0.00034428050000000015
iB00_764_v n1_991264_767520 0 0.00034497300000000005
iB00_765_v n1_991264_804000 0 0.00035931099999999996
iB00_766_v n1_952352_842912 0 0.00032612050000000006
iB00_767_v n1_952352_881824 0 0.0003282850000000001
iB00_768_v n1_991264_842912 0 0.00021123049999999998
iB00_769_v n1_991264_881824 0 0.0004398349999999999
iB00_770_v n1_952352_918304 0 0.0003470264999999999
iB00_771_v n1_952352_957216 0 0.00030702649999999996
iB00_772_v n1_991264_918304 0 0.00034669000000000003
iB00_773_v n1_991264_957216 0 0.000308524
iB00_774_v n1_952352_993696 0 0.0003050380000000003
iB00_775_v n1_952352_1032608 0 0.0003545209999999999
iB00_776_v n1_991264_993696 0 0.0002536774999999997
iB00_777_v n1_991264_1032608 0 0.0002475925
iB00_778_v n1_952352_1071520 0 0.00031770749999999976
iB00_779_v n1_952352_1108000 0 0.00034546250000000027
iB00_780_v n1_991264_1071520 0 0.00037761750000000035
iB00_781_v n1_991264_1108000 0 0.0003545129999999999
iB00_782_v n1_952352_1146912 0 0.000349243
iB00_783_v n1_991264_1146912 0 0.0003267255000000003
iB00_784_v n1_1028960_1146912 0 0.0003649760000000001
iB00_785_v n1_1067872_1146912 0 0.000250881
iB00_786_v n1_1028960_1108000 0 0.0002383354999999997
iB00_787_v n1_1067872_1108000 0 0.00031697050000000025
iB00_788_v n1_1105568_1146912 0 0.00027807049999999963
iB00_789_v n1_1144480_1146912 0 0.00036259400000000026
iB00_790_v n1_1105568_1108000 0 0.0002959290000000001
iB00_791_v n1_1144480_1108000 0 0.00032366999999999997
iB00_792_v n1_1182176_1146912 0 0.0003740935000000001
iB00_793_v n1_1219872_1146912 0 0.00027365549999999993
iB00_794_v n1_1182176_1108000 0 0.00039154200000000026
iB00_795_v n1_1219872_1108000 0 0.00044283650000000017
iB00_796_v n1_1258784_1146912 0 0.000412585
iB00_797_v n1_1296480_1146912 0 0.00037503349999999994
iB00_798_v n1_1258784_1108000 0 0.0005132119999999999
iB00_799_v n1_1296480_1108000 0 0.0004729615
iB00_800_v n1_1335392_1146912 0 0.00038820494999999996
iB00_801_v n1_1373088_1146912 0 0.0005754679500000001
iB00_802_v n1_1335392_1108000 0 0.00046464254999999994
iB00_803_v n1_1373088_1108000 0 0.00039314500000000007
iB00_804_v n1_1412000_1146912 0 0.0003977435
iB00_805_v n1_1449696_1146912 0 0.00035912
iB00_806_v n1_1412000_1108000 0 0.00041325499999999996
iB00_807_v n1_1449696_1108000 0 0.00030271499999999984
iB00_808_v n1_1487392_1146912 0 0.0006804799999999999
iB00_809_v n1_1526304_1146912 0 0.00037892500000000017
iB00_810_v n1_1487392_1108000 0 0.00037171499999999995
iB00_811_v n1_1526304_1108000 0 0.00038233500000000003
iB00_812_v n1_1564000_1146912 0 0.0003714600000000001
iB00_813_v n1_1602912_1146912 0 0.00039552500000000014
iB00_814_v n1_1564000_1108000 0 0.00041595499999999975
iB00_815_v n1_1641180_1183392 0 1.0587911840678754e-19
iB00_816_v n1_1602912_1108000 0 0.0003011949999999998
iB00_817_v n1_1641180_1146912 0 0.0
iB00_818_v n1_1641290_1146912 0 0.0
iB00_819_v n1_1641180_1108000 0 0.0
iB00_820_v n1_1641290_1183392 0 0.0
iB00_821_v n1_1641290_1222304 0 0.0
iB00_822_v n1_1641180_1071520 0 2.4999999999207785e-08
iB00_823_v n1_1641290_1108000 0 0.0
iB00_824_v n1_1602912_1071520 0 0.00016993000000000027
iB00_825_v n1_1602912_1032608 0 0.0003441649999999997
iB00_826_v n1_1564000_1071520 0 0.00029827
iB00_827_v n1_1526304_1071520 0 0.0002903199999999999
iB00_828_v n1_1564000_1032608 0 0.0003230400000000002
iB00_829_v n1_1526304_1032608 0 0.00032641500000000015
iB00_830_v n1_1487392_1071520 0 0.00033378000000000037
iB00_831_v n1_1449696_1071520 0 0.0004104299999999999
iB00_832_v n1_1487392_1032608 0 0.00032602000000000005
iB00_833_v n1_1449696_1032608 0 0.00033076000000000047
iB00_834_v n1_1412000_1071520 0 0.0003641400000000002
iB00_835_v n1_1373088_1071520 0 0.0002961050000000002
iB00_836_v n1_1412000_1032608 0 0.000360945
iB00_837_v n1_1373088_1032608 0 0.0003378949999999996
iB00_838_v n1_1335392_1071520 0 0.00032457249999999987
iB00_839_v n1_1296480_1071520 0 0.0003768800000000001
iB00_840_v n1_1335392_1032608 0 0.00035250500000000014
iB00_841_v n1_1296480_1032608 0 0.0004585755000000001
iB00_842_v n1_1258784_1071520 0 0.00038678450000000005
iB00_843_v n1_1219872_1071520 0 0.000263945
iB00_844_v n1_1258784_1032608 0 0.00038161035000000007
iB00_845_v n1_1219872_1032608 0 0.00033263499999999996
iB00_846_v n1_1182176_1071520 0 0.0004083049999999999
iB00_847_v n1_1144480_1071520 0 0.0003326165000000001
iB00_848_v n1_1182176_1032608 0 0.00032723499999999994
iB00_849_v n1_1144480_1032608 0 0.0004121449999999999
iB00_850_v n1_1105568_1071520 0 0.0003101660000000001
iB00_851_v n1_1067872_1071520 0 0.0003840039999999998
iB00_852_v n1_1105568_1032608 0 0.00030299499999999997
iB00_853_v n1_1067872_1032608 0 0.0003199925000000001
iB00_854_v n1_1028960_1071520 0 0.0002770010000000001
iB00_855_v n1_1028960_1032608 0 0.0002815914999999998
iB00_856_v n1_1028960_993696 0 0.0004621865
iB00_857_v n1_1028960_957216 0 0.00034724999999999996
iB00_858_v n1_1067872_993696 0 0.0003702099999999997
iB00_859_v n1_1067872_957216 0 0.00033647
iB00_860_v n1_1028960_918304 0 0.0003243949999999999
iB00_861_v n1_1028960_881824 0 0.0003890415000000001
iB00_862_v n1_1067872_918304 0 0.00033445500000000027
iB00_863_v n1_1067872_881824 0 0.00031859899999999987
iB00_864_v n1_1028960_842912 0 0.000286568
iB00_865_v n1_1028960_804000 0 0.0003430965
iB00_866_v n1_1067872_842912 0 0.0003496460000000001
iB00_867_v n1_1067872_804000 0 0.0003238422399999999
iB00_868_v n1_1028960_767520 0 0.00031589435000000006
iB00_869_v n1_1028960_728608 0 0.00034535115000000003
iB00_870_v n1_1067872_767520 0 0.0003725562599999999
iB00_871_v n1_991264_692128 0 0.0003746661600000002
iB00_872_v n1_1067872_728608 0 0.0003110324999999998
iB00_873_v n1_1028960_692128 0 0.00032864649999999983
iB00_874_v n1_1028960_653216 0 0.0004438660000000002
iB00_875_v n1_1067872_692128 0 0.00038731400000000004
iB00_876_v n1_991264_653216 0 0.00035677499999999977
iB00_877_v n1_991264_614304 0 0.00029993099999999997
iB00_878_v n1_952352_653216 0 0.00029353150000000004
iB00_879_v n1_952352_614304 0 0.00027935199999999986
iB00_880_v n1_952352_577824 0 0.00017137349999999982
iB00_881_v n1_991264_577824 0 0.0003361155000000002
iB00_882_v n1_952352_538912 0 0.0004002080000000002
iB00_883_v n1_952352_502432 0 9.839799999999992e-05
iB00_884_v n1_991264_538912 0 0.00034758449999999986
iB00_885_v n1_914656_480880 0 1.0000119262276036e-09
iB00_886_v n1_991264_502432 0 0.00011911099999999994
iB00_887_v n1_952352_480880 0 2.0000119260673465e-09
iB00_888_v n1_952352_480720 0 -1.19262e-14
iB00_889_v n1_991264_480880 0 -9.99988073486069e-10
iB00_890_v n1_914656_480720 0 -1.19262e-14
iB00_891_v n1_876960_480720 0 -1.19262e-14
iB00_892_v n1_1028960_480880 0 5.000119258961645e-10
iB00_893_v n1_991264_480720 0 -1.19262e-14
iB00_894_v n1_1028960_502432 0 0.00014500450000000002
iB00_895_v n1_1067872_502432 0 0.00019531999999999997
iB00_896_v n1_1028960_538912 0 0.0002507000000000002
iB00_897_v n1_1028960_577824 0 0.0003556804999999999
iB00_898_v n1_1067872_538912 0 0.0002598949999999997
iB00_899_v n1_1067872_577824 0 0.00030656999999999977
iB00_900_v n1_1028960_614304 0 0.0002108355
iB00_901_v n1_1067872_614304 0 0.00023199000000000011
iB00_902_v n1_1105568_614304 0 0.00025117000000000005
iB00_903_v n1_1067872_653216 0 0.0004017699999999999
iB00_904_v n1_1105568_653216 0 0.00043487999999999985
iB00_905_v n1_1144480_653216 0 0.00039940499999999987
iB00_906_v n1_1105568_692128 0 0.00027232400000000017
iB00_907_v n1_1105568_728608 0 0.000386487
iB00_908_v n1_1144480_692128 0 0.00026144
iB00_909_v n1_1144480_728608 0 0.00041683000000000014
iB00_910_v n1_1105568_767520 0 0.00035464949999999997
iB00_911_v n1_1105568_804000 0 0.000391057
iB00_912_v n1_1144480_767520 0 0.00029046600000000035
iB00_913_v n1_1144480_804000 0 0.00039878150000000013
iB00_914_v n1_1105568_842912 0 0.0005121899999999998
iB00_915_v n1_1105568_881824 0 0.00040995150000000015
iB00_916_v n1_1144480_842912 0 0.00037733830000000006
iB00_917_v n1_1144480_881824 0 0.0003411597
iB00_918_v n1_1105568_918304 0 0.00044093099999999977
iB00_919_v n1_1105568_957216 0 0.0003474400000000002
iB00_920_v n1_1144480_918304 0 0.0003858930000000004
iB00_921_v n1_1144480_957216 0 0.0003928414999999999
iB00_922_v n1_1105568_993696 0 0.0003262499999999998
iB00_923_v n1_1144480_993696 0 0.0003345800000000001
iB00_924_v n1_1182176_993696 0 0.00033880199999999997
iB00_925_v n1_1219872_993696 0 0.0003414705000000001
iB00_926_v n1_1182176_957216 0 0.00039905250000000017
iB00_927_v n1_1219872_957216 0 0.0003613725000000001
iB00_928_v n1_1258784_993696 0 0.00043815014999999994
iB00_929_v n1_1296480_993696 0 0.0003815294999999999
iB00_930_v n1_1258784_957216 0 0.0003302980000000002
iB00_931_v n1_1296480_957216 0 0.00039183999999999974
iB00_932_v n1_1335392_993696 0 0.0003306000000000002
iB00_933_v n1_1373088_993696 0 0.00043107499999999995
iB00_934_v n1_1335392_957216 0 0.0003059349999999998
iB00_935_v n1_1373088_957216 0 0.0003593250000000002
iB00_936_v n1_1412000_993696 0 0.0003613099999999999
iB00_937_v n1_1449696_993696 0 0.00020797499999999949
iB00_938_v n1_1412000_957216 0 0.00036886999999999955
iB00_939_v n1_1449696_957216 0 0.000349285
iB00_940_v n1_1487392_993696 0 0.0003861300000000004
iB00_941_v n1_1526304_993696 0 0.00034245500000000014
iB00_942_v n1_1487392_957216 0 0.00027135499999999944
iB00_943_v n1_1526304_957216 0 0.00043761500000000003
iB00_944_v n1_1564000_993696 0 0.0002727899999999999
iB00_945_v n1_1602912_993696 0 0.00030776500000000015
iB00_946_v n1_1564000_957216 0 0.00031714499999999985
iB00_947_v n1_1641180_1032608 0 8.470329472543003e-19
iB00_948_v n1_1602912_957216 0 0.00020517999999999963
iB00_949_v n1_1641180_993696 0 -1.500000000104933e-08
iB00_950_v n1_1641290_993696 0 0.0
iB00_951_v n1_1641180_957216 0 -3.0000000000404595e-08
iB00_952_v n1_1641290_1032608 0 0.0
iB00_953_v n1_1641290_1071520 0 0.0
iB00_954_v n1_1641180_918304 0 3.0000000000404595e-08
iB00_955_v n1_1641290_957216 0 0.0
iB00_956_v n1_1602912_918304 0 0.0002601900000000004
iB00_957_v n1_1602912_881824 0 0.0003174200000000003
iB00_958_v n1_1564000_918304 0 0.0004496849999999999
iB00_959_v n1_1526304_918304 0 0.0002919849999999997
iB00_960_v n1_1564000_881824 0 0.00025811
iB00_961_v n1_1526304_881824 0 0.0003082849999999999
iB00_962_v n1_1487392_918304 0 0.0004230000000000004
iB00_963_v n1_1449696_918304 0 0.0005373099999999998
iB00_964_v n1_1487392_881824 0 0.0003102650000000003
iB00_965_v n1_1449696_881824 0 0.0002670399999999996
iB00_966_v n1_1412000_918304 0 0.00025948500000000043
iB00_967_v n1_1373088_918304 0 0.00031814000000000023
iB00_968_v n1_1412000_881824 0 0.0003566149999999999
iB00_969_v n1_1373088_881824 0 0.0002566250000000003
iB00_970_v n1_1335392_918304 0 0.000407985
iB00_971_v n1_1296480_918304 0 0.0004074350000000002
iB00_972_v n1_1335392_881824 0 0.0004904700000000002
iB00_973_v n1_1296480_881824 0 0.00038699999999999943
iB00_974_v n1_1258784_918304 0 0.00036532000000000003
iB00_975_v n1_1219872_918304 0 0.0004379070000000001
iB00_976_v n1_1258784_881824 0 0.0004964800000000001
iB00_977_v n1_1219872_881824 0 0.00045772
iB00_978_v n1_1182176_918304 0 0.00033553999999999995
iB00_979_v n1_1182176_881824 0 0.00033854399999999987
iB00_980_v n1_1182176_842912 0 0.00035578150000000006
iB00_981_v n1_1182176_804000 0 0.00034721
iB00_982_v n1_1219872_842912 0 0.00048553499999999994
iB00_983_v n1_1219872_804000 0 0.0004721800000000002
iB00_984_v n1_1182176_767520 0 0.00040109500000000013
iB00_985_v n1_1182176_728608 0 0.0001697799999999999
iB00_986_v n1_1219872_767520 0 0.0003182849999999998
iB00_987_v n1_1219872_728608 0 0.00027353499999999993
iB00_988_v n1_1182176_692128 0 0.0002776800000000002
iB00_989_v n1_1182176_653216 0 0.00028197000000000004
iB00_990_v n1_1219872_692128 0 0.0003816349999999996
iB00_991_v n1_1144480_614304 0 0.0002522049999999998
iB00_992_v n1_1219872_653216 0 0.00031012499999999985
iB00_993_v n1_1182176_614304 0 0.00031582500000000005
iB00_994_v n1_1182176_577824 0 0.0003201999999999999
iB00_995_v n1_1219872_614304 0 0.000456945
iB00_996_v n1_1144480_577824 0 0.0004398699999999998
iB00_997_v n1_1144480_538912 0 0.00032433
iB00_998_v n1_1105568_577824 0 0.00023155500000000007
iB00_999_v n1_1105568_538912 0 0.00036523500000000005
iB00_1000_v n1_1105568_502432 0 0.0001948499999999996
iB00_1001_v n1_1067872_480880 0 -4.999988074149777e-09
iB00_1002_v n1_1144480_502432 0 8.344500000000009e-05
iB00_1003_v n1_1105568_480880 0 5.0000119269971905e-09
iB00_1004_v n1_1105568_480720 0 -1.19262e-14
iB00_1005_v n1_1144480_480880 0 -4.9999880742317585e-09
iB00_1006_v n1_1067872_480720 0 -1.19262e-14
iB00_1007_v n1_1028960_480720 0 -1.19262e-14
iB00_1008_v n1_1182176_480880 0 1.5000011926402296e-08
iB00_1009_v n1_1144480_480720 0 -1.19262e-14
iB00_1010_v n1_1182176_502432 0 0.00014500999999999994
iB00_1011_v n1_1219872_502432 0 0.00013484500000000035
iB00_1012_v n1_1182176_538912 0 0.000277405
iB00_1013_v n1_1219872_538912 0 0.0003784299999999998
iB00_1014_v n1_1258784_538912 0 0.0003179500000000005
iB00_1015_v n1_1219872_577824 0 0.00025977000000000004
iB00_1016_v n1_1258784_577824 0 0.00037752500000000025
iB00_1017_v n1_1296480_577824 0 0.00032769999999999983
iB00_1018_v n1_1258784_614304 0 0.0004051850000000002
iB00_1019_v n1_1258784_653216 0 0.0004041800000000008
iB00_1020_v n1_1296480_614304 0 0.00031038000000000094
iB00_1021_v n1_1296480_653216 0 0.0002639199999999994
iB00_1022_v n1_1258784_692128 0 0.0003085150000000003
iB00_1023_v n1_1258784_728608 0 0.0003911350000000003
iB00_1024_v n1_1296480_692128 0 0.00041474499999999935
iB00_1025_v n1_1296480_728608 0 0.00033791
iB00_1026_v n1_1258784_767520 0 0.00041709000000000033
iB00_1027_v n1_1258784_804000 0 0.0004074649999999996
iB00_1028_v n1_1296480_767520 0 0.0003114999999999997
iB00_1029_v n1_1296480_804000 0 0.0004106200000000005
iB00_1030_v n1_1258784_842912 0 0.000391615
iB00_1031_v n1_1296480_842912 0 0.0004474099999999998
iB00_1032_v n1_1335392_842912 0 0.0005757549999999998
iB00_1033_v n1_1373088_842912 0 0.000434515
iB00_1034_v n1_1335392_804000 0 0.0003596099999999998
iB00_1035_v n1_1373088_804000 0 0.000491465
iB00_1036_v n1_1412000_842912 0 0.0005903799999999997
iB00_1037_v n1_1449696_842912 0 0.00029992999999999985
iB00_1038_v n1_1412000_804000 0 0.0006026849999999995
iB00_1039_v n1_1449696_804000 0 0.0003383300000000002
iB00_1040_v n1_1487392_842912 0 0.00037577999999999847
iB00_1041_v n1_1526304_842912 0 0.00043929000000000076
iB00_1042_v n1_1487392_804000 0 0.00024301500000000067
iB00_1043_v n1_1526304_804000 0 0.0003031300000000001
iB00_1044_v n1_1564000_842912 0 0.00025644999999999986
iB00_1045_v n1_1602912_842912 0 0.0003415850000000005
iB00_1046_v n1_1564000_804000 0 0.0004124150000000007
iB00_1047_v n1_1641180_881824 0 -2.5000000000054818e-08
iB00_1048_v n1_1602912_804000 0 0.00036812500000000083
iB00_1049_v n1_1641180_842912 0 1.999999999970504e-08
iB00_1050_v n1_1641290_842912 0 0.0
iB00_1051_v n1_1641180_804000 0 -4.999999999502744e-09
iB00_1052_v n1_1641290_881824 0 0.0
iB00_1053_v n1_1641290_918304 0 0.0
iB00_1054_v n1_1641180_767520 0 2.0000000001399107e-08
iB00_1055_v n1_1641290_804000 0 0.0
iB00_1056_v n1_1602912_767520 0 0.0003508849999999997
iB00_1057_v n1_1602912_728608 0 0.000272114999999998
iB00_1058_v n1_1564000_767520 0 0.0003246149999999996
iB00_1059_v n1_1526304_767520 0 0.0003828200000000001
iB00_1060_v n1_1564000_728608 0 0.00035925999999999856
iB00_1061_v n1_1526304_728608 0 0.00031392500000000054
iB00_1062_v n1_1487392_767520 0 0.0002330649999999996
iB00_1063_v n1_1449696_767520 0 0.00039988499999999913
iB00_1064_v n1_1487392_728608 0 0.00031032499999999986
iB00_1065_v n1_1449696_728608 0 0.0003157999999999996
iB00_1066_v n1_1412000_767520 0 0.00031434500000000027
iB00_1067_v n1_1373088_767520 0 0.0005751450000000004
iB00_1068_v n1_1412000_728608 0 0.00029991499999999967
iB00_1069_v n1_1373088_728608 0 0.00038671000000000034
iB00_1070_v n1_1335392_767520 0 0.0003807950000000003
iB00_1071_v n1_1335392_728608 0 0.0004799849999999999
iB00_1072_v n1_1335392_692128 0 0.000299145
iB00_1073_v n1_1335392_653216 0 0.0004321049999999996
iB00_1074_v n1_1373088_692128 0 0.0003541349999999992
iB00_1075_v n1_1373088_653216 0 0.00042001499999999917
iB00_1076_v n1_1335392_614304 0 0.0003298300000000002
iB00_1077_v n1_1335392_577824 0 0.00021834499999999943
iB00_1078_v n1_1373088_614304 0 0.0003775850000000002
iB00_1079_v n1_1296480_538912 0 0.00027874499999999995
iB00_1080_v n1_1373088_577824 0 0.0004045099999999991
iB00_1081_v n1_1335392_538912 0 0.0004144300000000002
iB00_1082_v n1_1335392_502432 0 9.250000000000123e-05
iB00_1083_v n1_1373088_538912 0 0.00027988999999999976
iB00_1084_v n1_1296480_502432 0 0.0001670550000000003
iB00_1085_v n1_1296480_480880 0 -1.4999988073155266e-08
iB00_1086_v n1_1258784_502432 0 0.0002073549999999995
iB00_1087_v n1_1258784_480880 0 1.0000011926076418e-08
iB00_1088_v n1_1258784_480720 0 -1.19262e-14
iB00_1089_v n1_1219872_480880 0 -1.9999988074539935e-08
iB00_1090_v n1_1219872_480720 0 -1.19262e-14
iB00_1091_v n1_1182176_480720 0 -1.19262e-14
iB00_1092_v n1_1335392_480880 0 2.500001192670223e-08
iB00_1093_v n1_1296480_480720 0 -1.19262e-14
iB00_1094_v n1_1373088_480880 0 -4.9999880758438425e-09
iB00_1095_v n1_1335392_480720 0 -1.19262e-14
iB00_1096_v n1_1373088_502432 0 0.00015696999999999952
iB00_1097_v n1_1412000_502432 0 0.00015693000000000055
iB00_1098_v n1_1412000_538912 0 0.0004788950000000003
iB00_1099_v n1_1449696_538912 0 0.0004267799999999993
iB00_1100_v n1_1412000_577824 0 0.00032868500000000054
iB00_1101_v n1_1412000_614304 0 0.00036037999999999945
iB00_1102_v n1_1449696_577824 0 0.0003201750000000007
iB00_1103_v n1_1449696_614304 0 0.0001476850000000001
iB00_1104_v n1_1412000_653216 0 0.00026731500000000104
iB00_1105_v n1_1412000_692128 0 0.00046408000000000067
iB00_1106_v n1_1449696_653216 0 0.0004053800000000007
iB00_1107_v n1_1449696_692128 0 0.00029236999999999953
iB00_1108_v n1_1487392_692128 0 0.0005177900000000005
iB00_1109_v n1_1526304_692128 0 0.00032620999999999855
iB00_1110_v n1_1487392_653216 0 0.0003486600000000003
iB00_1111_v n1_1526304_653216 0 0.0004125450000000005
iB00_1112_v n1_1564000_692128 0 0.0003115950000000002
iB00_1113_v n1_1602912_692128 0 0.0003283400000000006
iB00_1114_v n1_1564000_653216 0 0.00033705499999999995
iB00_1115_v n1_1641180_728608 0 -2.5000000001748884e-08
iB00_1116_v n1_1602912_653216 0 0.0003443999999999996
iB00_1117_v n1_1641180_692128 0 -1.9999999998010975e-08
iB00_1118_v n1_1641290_692128 0 0.0
iB00_1119_v n1_1641180_653216 0 5.000000000053315e-08
iB00_1120_v n1_1641290_728608 0 0.0
iB00_1121_v n1_1641290_767520 0 0.0
iB00_1122_v n1_1641180_614304 0 -1.0000000000699553e-08
iB00_1123_v n1_1641290_653216 0 0.0
iB00_1124_v n1_1602912_614304 0 0.0003669099999999997
iB00_1125_v n1_1602912_577824 0 0.00032741999999999765
iB00_1126_v n1_1564000_614304 0 0.0003551500000000012
iB00_1127_v n1_1526304_614304 0 0.0004241499999999983
iB00_1128_v n1_1564000_577824 0 0.0003343499999999996
iB00_1129_v n1_1526304_577824 0 0.0002545000000000015
iB00_1130_v n1_1487392_614304 0 0.00042364999999999975
iB00_1131_v n1_1487392_577824 0 0.0003106499999999993
iB00_1132_v n1_1487392_538912 0 0.000454599999999999
iB00_1133_v n1_1487392_502432 0 0.0002201000000000015
iB00_1134_v n1_1526304_538912 0 0.00031700000000000223
iB00_1135_v n1_1449696_502432 0 7.848000000000048e-05
iB00_1136_v n1_1449696_480880 0 2.5000005961460753e-08
iB00_1137_v n1_1412000_480880 0 -1.4999988073131367e-08
iB00_1138_v n1_1412000_480720 0 -1.19262e-14
iB00_1139_v n1_1373088_480720 0 -1.19262e-14
iB00_1140_v n1_1487392_480880 0 5.96522953103841e-15
iB00_1141_v n1_1449696_480720 0 -5.9631e-15
iB00_1142_v n1_1526304_480880 0 5.9631e-15
iB00_1143_v n1_1487392_480720 0 -5.9631e-15
iB00_1144_v n1_1526304_502432 0 0.00025709999999999964
iB00_1145_v n1_1564000_502432 0 0.00017505000000000098
iB00_1146_v n1_1564000_538912 0 0.0003238999999999987
iB00_1147_v n1_1602912_538912 0 0.0002551549999999991
iB00_1148_v n1_1641180_577824 0 -2.0000000001399107e-08
iB00_1149_v n1_1602912_502432 0 0.00013825499999999856
iB00_1150_v n1_1641180_538912 0 -5.000000000349777e-09
iB00_1151_v n1_1641290_538912 0 0.0
iB00_1152_v n1_1641180_502432 0 -5.000000002043843e-09
iB00_1153_v n1_1641290_577824 0 0.0
iB00_1154_v n1_1641290_614304 0 0.0
iB00_1155_v n1_1641180_480880 0 1.19262e-14
iB00_1156_v n1_1641290_502432 0 0.0
iB00_1157_v n1_1602912_480880 0 5.95633568509224e-15
iB00_1158_v n1_1602912_480720 0 -5.9631e-15
iB00_1159_v n1_1620161_480880 0 5.0000000017050295e-08
iB00_1160_v n1_1564000_480880 0 5.963111948670274e-15
iB00_1161_v n1_1564000_480720 0 -5.9631e-15
iB00_1162_v n1_1526304_480720 0 -5.9631e-15
iB00_1163_v n1_1620161_300000 0 -0.042999000000000016
iB00_1164_v n1_1620161_481040 0 0.0
iB00_1165_v n1_1620161_295000 0 -0.064661
iB00_1166_v n1_1641290_480880 0 0.0
iB00_1167_v n1_1641180_480720 0 -1.19262e-14
.op
.print tran v(n1_295000_940095) v(n1_300000_940095) v(n1_474796_940095) v(n1_474906_940095) v(n1_474796_918304) v(n1_474796_957216) v(n1_474796_993696) v(n1_493920_957216) v(n1_474686_957216) v(n1_532832_957216) v(n1_493920_918304) v(n1_493920_993696) v(n1_493920_1032608) v(n1_532832_993696) v(n1_474686_993696) v(n1_474796_1032608) v(n1_474796_1071520) v(n1_474686_1032608) v(n1_532832_1032608) v(n1_493920_1071520) v(n1_493920_1108000) v(n1_532832_1071520) v(n1_474686_1071520) v(n1_474796_1108000) v(n1_474796_1146912) v(n1_474686_1108000) v(n1_532832_1108000) v(n1_493920_1146912) v(n1_493920_1183392) v(n1_532832_1146912) v(n1_474686_1146912) v(n1_474796_1183392) v(n1_474796_1222304) v(n1_474686_1183392) v(n1_532832_1183392) v(n1_493920_1222304) v(n1_493920_1261216) v(n1_532832_1222304) v(n1_474686_1222304) v(n1_474796_1261216) v(n1_474796_1297696) v(n1_474686_1261216) v(n1_532832_1261216) v(n1_493920_1297696) v(n1_493920_1336608) v(n1_532832_1297696) v(n1_474686_1297696) v(n1_474796_1336608) v(n1_474796_1373088) v(n1_474686_1336608) v(n1_532832_1336608) v(n1_493920_1373088) v(n1_493920_1412000) v(n1_532832_1373088) v(n1_474686_1373088) v(n1_474796_1412000) v(n1_474796_1448480) v(n1_474686_1412000) v(n1_532832_1412000) v(n1_493920_1448480) v(n1_493920_1487392) v(n1_532832_1448480) v(n1_474686_1448480) v(n1_474796_1487392) v(n1_474796_1526304) v(n1_474686_1487392) v(n1_532832_1487392) v(n1_493920_1526304) v(n1_493920_1562784) v(n1_532832_1526304) v(n1_474686_1526304) v(n1_474796_1562784) v(n1_474796_1601696) v(n1_474686_1562784) v(n1_532832_1562784) v(n1_493920_1601696) v(n1_493920_1641130) v(n1_532832_1601696) v(n1_474686_1601696) v(n1_474796_1641130) v(n1_474796_1641290) v(n1_474686_1641130) v(n1_532832_1641130) v(n1_493920_1641290) v(n1_570528_1641130) v(n1_532832_1641290) v(n1_570528_1601696) v(n1_609440_1601696) v(n1_570528_1562784) v(n1_570528_1641290) v(n1_609440_1641130) v(n1_647136_1641130) v(n1_609440_1641290) v(n1_609440_1562784) v(n1_647136_1601696) v(n1_686048_1601696) v(n1_647136_1562784) v(n1_647136_1641290) v(n1_686048_1641130) v(n1_723744_1641130) v(n1_686048_1641290) v(n1_686048_1562784) v(n1_723744_1601696) v(n1_761440_1601696) v(n1_723744_1562784) v(n1_723744_1641290) v(n1_761440_1641130) v(n1_800352_1641130) v(n1_761440_1641290) v(n1_761440_1562784) v(n1_800352_1601696) v(n1_838048_1601696) v(n1_800352_1562784) v(n1_800352_1641290) v(n1_838048_1641130) v(n1_876960_1641130) v(n1_838048_1641290) v(n1_838048_1562784) v(n1_876960_1601696) v(n1_914656_1601696) v(n1_876960_1562784) v(n1_876960_1641290) v(n1_914656_1641130) v(n1_952352_1641130) v(n1_914656_1641290) v(n1_914656_1562784) v(n1_952352_1601696) v(n1_991264_1601696) v(n1_952352_1562784) v(n1_952352_1641290) v(n1_979937_1641130) v(n1_991264_1641130) v(n1_979937_1640970) v(n1_979937_1820000) v(n1_979937_1825000) v(n1_1028960_1641130) v(n1_991264_1641290) v(n1_991264_1562784) v(n1_1028960_1601696) v(n1_1067872_1601696) v(n1_1028960_1562784) v(n1_1028960_1641290) v(n1_1067872_1641130) v(n1_1105568_1641130) v(n1_1067872_1641290) v(n1_1067872_1562784) v(n1_1105568_1601696) v(n1_1144480_1601696) v(n1_1105568_1562784) v(n1_1105568_1641290) v(n1_1144480_1641130) v(n1_1182176_1641130) v(n1_1144480_1641290) v(n1_1144480_1562784) v(n1_1182176_1601696) v(n1_1219872_1601696) v(n1_1182176_1562784) v(n1_1182176_1641290) v(n1_1219872_1641130) v(n1_1258784_1641130) v(n1_1219872_1641290) v(n1_1219872_1562784) v(n1_1258784_1601696) v(n1_1296480_1601696) v(n1_1258784_1562784) v(n1_1258784_1641290) v(n1_1296480_1641130) v(n1_1335392_1641130) v(n1_1296480_1641290) v(n1_1296480_1562784) v(n1_1335392_1601696) v(n1_1373088_1601696) v(n1_1335392_1562784) v(n1_1335392_1641290) v(n1_1373088_1641130) v(n1_1412000_1641130) v(n1_1373088_1641290) v(n1_1373088_1562784) v(n1_1412000_1601696) v(n1_1449696_1601696) v(n1_1412000_1562784) v(n1_1412000_1641290) v(n1_1449696_1641130) v(n1_1487392_1641130) v(n1_1449696_1641290) v(n1_1449696_1562784) v(n1_1487392_1601696) v(n1_1526304_1601696) v(n1_1487392_1562784) v(n1_1487392_1641290) v(n1_1526304_1641130) v(n1_1564000_1641130) v(n1_1526304_1641290) v(n1_1526304_1562784) v(n1_1564000_1601696) v(n1_1602912_1601696) v(n1_1564000_1562784) v(n1_1564000_1641290) v(n1_1602912_1641130) v(n1_1641180_1641130) v(n1_1602912_1641290) v(n1_1602912_1562784) v(n1_1641180_1601696) v(n1_1641290_1601696) v(n1_1641180_1562784) v(n1_1641180_1619905) v(n1_1820088_1619905) v(n1_1641070_1619905) v(n1_1825088_1619905) v(n1_1641180_1641290) v(n1_1641290_1641130) v(n1_1641180_1526304) v(n1_1641290_1562784) v(n1_1602912_1526304) v(n1_1602912_1487392) v(n1_1564000_1526304) v(n1_1526304_1526304) v(n1_1564000_1487392) v(n1_1526304_1487392) v(n1_1487392_1526304) v(n1_1449696_1526304) v(n1_1487392_1487392) v(n1_1449696_1487392) v(n1_1412000_1526304) v(n1_1373088_1526304) v(n1_1412000_1487392) v(n1_1373088_1487392) v(n1_1335392_1526304) v(n1_1296480_1526304) v(n1_1335392_1487392) v(n1_1296480_1487392) v(n1_1258784_1526304) v(n1_1219872_1526304) v(n1_1258784_1487392) v(n1_1219872_1487392) v(n1_1182176_1526304) v(n1_1144480_1526304) v(n1_1182176_1487392) v(n1_1144480_1487392) v(n1_1105568_1526304) v(n1_1067872_1526304) v(n1_1105568_1487392) v(n1_1067872_1487392) v(n1_1028960_1526304) v(n1_991264_1526304) v(n1_1028960_1487392) v(n1_991264_1487392) v(n1_952352_1526304) v(n1_914656_1526304) v(n1_952352_1487392) v(n1_914656_1487392) v(n1_876960_1526304) v(n1_838048_1526304) v(n1_876960_1487392) v(n1_838048_1487392) v(n1_800352_1526304) v(n1_761440_1526304) v(n1_800352_1487392) v(n1_761440_1487392) v(n1_723744_1526304) v(n1_686048_1526304) v(n1_723744_1487392) v(n1_686048_1487392) v(n1_647136_1526304) v(n1_609440_1526304) v(n1_647136_1487392) v(n1_609440_1487392) v(n1_570528_1526304) v(n1_570528_1487392) v(n1_570528_1448480) v(n1_570528_1412000) v(n1_609440_1448480) v(n1_609440_1412000) v(n1_570528_1373088) v(n1_570528_1336608) v(n1_609440_1373088) v(n1_609440_1336608) v(n1_570528_1297696) v(n1_570528_1261216) v(n1_609440_1297696) v(n1_609440_1261216) v(n1_570528_1222304) v(n1_570528_1183392) v(n1_609440_1222304) v(n1_609440_1183392) v(n1_570528_1146912) v(n1_570528_1108000) v(n1_609440_1146912) v(n1_609440_1108000) v(n1_570528_1071520) v(n1_570528_1032608) v(n1_609440_1071520) v(n1_609440_1032608) v(n1_570528_993696) v(n1_570528_957216) v(n1_609440_993696) v(n1_532832_918304) v(n1_609440_957216) v(n1_570528_918304) v(n1_570528_881824) v(n1_609440_918304) v(n1_532832_881824) v(n1_532832_842912) v(n1_493920_881824) v(n1_474796_881824) v(n1_493920_842912) v(n1_474686_918304) v(n1_474796_842912) v(n1_474686_881824) v(n1_474796_804000) v(n1_474686_842912) v(n1_493920_804000) v(n1_493920_767520) v(n1_532832_804000) v(n1_474686_804000) v(n1_474796_767520) v(n1_474796_728608) v(n1_474686_767520) v(n1_532832_767520) v(n1_493920_728608) v(n1_493920_692128) v(n1_532832_728608) v(n1_474686_728608) v(n1_474796_692128) v(n1_474796_653216) v(n1_474686_692128) v(n1_532832_692128) v(n1_493920_653216) v(n1_493920_614304) v(n1_532832_653216) v(n1_474686_653216) v(n1_474796_614304) v(n1_474796_577824) v(n1_474686_614304) v(n1_532832_614304) v(n1_493920_577824) v(n1_493920_538912) v(n1_532832_577824) v(n1_474686_577824) v(n1_474796_538912) v(n1_474796_502432) v(n1_474686_538912) v(n1_532832_538912) v(n1_493920_502432) v(n1_493920_480880) v(n1_532832_502432) v(n1_474686_502432) v(n1_474796_480880) v(n1_474796_480720) v(n1_474686_480880) v(n1_532832_480880) v(n1_493920_480720) v(n1_570528_480880) v(n1_532832_480720) v(n1_570528_502432) v(n1_609440_502432) v(n1_570528_538912) v(n1_570528_577824) v(n1_609440_538912) v(n1_609440_577824) v(n1_570528_614304) v(n1_570528_653216) v(n1_609440_614304) v(n1_609440_653216) v(n1_570528_692128) v(n1_570528_728608) v(n1_609440_692128) v(n1_609440_728608) v(n1_570528_767520) v(n1_570528_804000) v(n1_609440_767520) v(n1_609440_804000) v(n1_570528_842912) v(n1_609440_842912) v(n1_647136_842912) v(n1_609440_881824) v(n1_647136_881824) v(n1_686048_881824) v(n1_647136_918304) v(n1_647136_957216) v(n1_686048_918304) v(n1_686048_957216) v(n1_647136_993696) v(n1_647136_1032608) v(n1_686048_993696) v(n1_686048_1032608) v(n1_647136_1071520) v(n1_647136_1108000) v(n1_686048_1071520) v(n1_686048_1108000) v(n1_647136_1146912) v(n1_647136_1183392) v(n1_686048_1146912) v(n1_686048_1183392) v(n1_647136_1222304) v(n1_647136_1261216) v(n1_686048_1222304) v(n1_686048_1261216) v(n1_647136_1297696) v(n1_647136_1336608) v(n1_686048_1297696) v(n1_686048_1336608) v(n1_647136_1373088) v(n1_647136_1412000) v(n1_686048_1373088) v(n1_686048_1412000) v(n1_647136_1448480) v(n1_686048_1448480) v(n1_723744_1448480) v(n1_761440_1448480) v(n1_723744_1412000) v(n1_761440_1412000) v(n1_800352_1448480) v(n1_838048_1448480) v(n1_800352_1412000) v(n1_838048_1412000) v(n1_876960_1448480) v(n1_914656_1448480) v(n1_876960_1412000) v(n1_914656_1412000) v(n1_952352_1448480) v(n1_991264_1448480) v(n1_952352_1412000) v(n1_991264_1412000) v(n1_1028960_1448480) v(n1_1067872_1448480) v(n1_1028960_1412000) v(n1_1067872_1412000) v(n1_1105568_1448480) v(n1_1144480_1448480) v(n1_1105568_1412000) v(n1_1144480_1412000) v(n1_1182176_1448480) v(n1_1219872_1448480) v(n1_1182176_1412000) v(n1_1219872_1412000) v(n1_1258784_1448480) v(n1_1296480_1448480) v(n1_1258784_1412000) v(n1_1296480_1412000) v(n1_1335392_1448480) v(n1_1373088_1448480) v(n1_1335392_1412000) v(n1_1373088_1412000) v(n1_1412000_1448480) v(n1_1449696_1448480) v(n1_1412000_1412000) v(n1_1449696_1412000) v(n1_1487392_1448480) v(n1_1526304_1448480) v(n1_1487392_1412000) v(n1_1526304_1412000) v(n1_1564000_1448480) v(n1_1602912_1448480) v(n1_1564000_1412000) v(n1_1641180_1487392) v(n1_1602912_1412000) v(n1_1641180_1448480) v(n1_1641290_1448480) v(n1_1641180_1412000) v(n1_1641290_1487392) v(n1_1641290_1526304) v(n1_1641180_1373088) v(n1_1641290_1412000) v(n1_1602912_1373088) v(n1_1602912_1336608) v(n1_1564000_1373088) v(n1_1526304_1373088) v(n1_1564000_1336608) v(n1_1526304_1336608) v(n1_1487392_1373088) v(n1_1449696_1373088) v(n1_1487392_1336608) v(n1_1449696_1336608) v(n1_1412000_1373088) v(n1_1373088_1373088) v(n1_1412000_1336608) v(n1_1373088_1336608) v(n1_1335392_1373088) v(n1_1296480_1373088) v(n1_1335392_1336608) v(n1_1296480_1336608) v(n1_1258784_1373088) v(n1_1219872_1373088) v(n1_1258784_1336608) v(n1_1219872_1336608) v(n1_1182176_1373088) v(n1_1144480_1373088) v(n1_1182176_1336608) v(n1_1144480_1336608) v(n1_1105568_1373088) v(n1_1067872_1373088) v(n1_1105568_1336608) v(n1_1067872_1336608) v(n1_1028960_1373088) v(n1_991264_1373088) v(n1_1028960_1336608) v(n1_991264_1336608) v(n1_952352_1373088) v(n1_914656_1373088) v(n1_952352_1336608) v(n1_914656_1336608) v(n1_876960_1373088) v(n1_838048_1373088) v(n1_876960_1336608) v(n1_838048_1336608) v(n1_800352_1373088) v(n1_761440_1373088) v(n1_800352_1336608) v(n1_761440_1336608) v(n1_723744_1373088) v(n1_723744_1336608) v(n1_723744_1297696) v(n1_723744_1261216) v(n1_761440_1297696) v(n1_761440_1261216) v(n1_723744_1222304) v(n1_723744_1183392) v(n1_761440_1222304) v(n1_761440_1183392) v(n1_723744_1146912) v(n1_723744_1108000) v(n1_761440_1146912) v(n1_761440_1108000) v(n1_723744_1071520) v(n1_723744_1032608) v(n1_761440_1071520) v(n1_761440_1032608) v(n1_723744_993696) v(n1_723744_957216) v(n1_761440_993696) v(n1_761440_957216) v(n1_723744_918304) v(n1_723744_881824) v(n1_761440_918304) v(n1_686048_842912) v(n1_761440_881824) v(n1_723744_842912) v(n1_723744_804000) v(n1_761440_842912) v(n1_686048_804000) v(n1_686048_767520) v(n1_647136_804000) v(n1_647136_767520) v(n1_647136_728608) v(n1_686048_728608) v(n1_647136_692128) v(n1_647136_653216) v(n1_686048_692128) v(n1_686048_653216) v(n1_647136_614304) v(n1_647136_577824) v(n1_686048_614304) v(n1_686048_577824) v(n1_647136_538912) v(n1_647136_502432) v(n1_686048_538912) v(n1_609440_480880) v(n1_686048_502432) v(n1_647136_480880) v(n1_647136_480720) v(n1_686048_480880) v(n1_609440_480720) v(n1_570528_480720) v(n1_723744_480880) v(n1_686048_480720) v(n1_723744_502432) v(n1_761440_502432) v(n1_723744_538912) v(n1_723744_577824) v(n1_761440_538912) v(n1_761440_577824) v(n1_723744_614304) v(n1_723744_653216) v(n1_761440_614304) v(n1_761440_653216) v(n1_723744_692128) v(n1_723744_728608) v(n1_761440_692128) v(n1_761440_728608) v(n1_723744_767520) v(n1_761440_767520) v(n1_800352_767520) v(n1_761440_804000) v(n1_800352_804000) v(n1_838048_804000) v(n1_800352_842912) v(n1_800352_881824) v(n1_838048_842912) v(n1_838048_881824) v(n1_800352_918304) v(n1_800352_957216) v(n1_838048_918304) v(n1_838048_957216) v(n1_800352_993696) v(n1_800352_1032608) v(n1_838048_993696) v(n1_838048_1032608) v(n1_800352_1071520) v(n1_800352_1108000) v(n1_838048_1071520) v(n1_838048_1108000) v(n1_800352_1146912) v(n1_800352_1183392) v(n1_838048_1146912) v(n1_838048_1183392) v(n1_800352_1222304) v(n1_800352_1261216) v(n1_838048_1222304) v(n1_838048_1261216) v(n1_800352_1297696) v(n1_838048_1297696) v(n1_876960_1297696) v(n1_914656_1297696) v(n1_876960_1261216) v(n1_914656_1261216) v(n1_952352_1297696) v(n1_991264_1297696) v(n1_952352_1261216) v(n1_991264_1261216) v(n1_1028960_1297696) v(n1_1067872_1297696) v(n1_1028960_1261216) v(n1_1067872_1261216) v(n1_1105568_1297696) v(n1_1144480_1297696) v(n1_1105568_1261216) v(n1_1144480_1261216) v(n1_1182176_1297696) v(n1_1219872_1297696) v(n1_1182176_1261216) v(n1_1219872_1261216) v(n1_1258784_1297696) v(n1_1296480_1297696) v(n1_1258784_1261216) v(n1_1296480_1261216) v(n1_1335392_1297696) v(n1_1373088_1297696) v(n1_1335392_1261216) v(n1_1373088_1261216) v(n1_1412000_1297696) v(n1_1449696_1297696) v(n1_1412000_1261216) v(n1_1449696_1261216) v(n1_1487392_1297696) v(n1_1526304_1297696) v(n1_1487392_1261216) v(n1_1526304_1261216) v(n1_1564000_1297696) v(n1_1602912_1297696) v(n1_1564000_1261216) v(n1_1641180_1336608) v(n1_1602912_1261216) v(n1_1641180_1297696) v(n1_1641290_1297696) v(n1_1641180_1261216) v(n1_1641290_1336608) v(n1_1641290_1373088) v(n1_1641180_1222304) v(n1_1641290_1261216) v(n1_1602912_1222304) v(n1_1602912_1183392) v(n1_1564000_1222304) v(n1_1526304_1222304) v(n1_1564000_1183392) v(n1_1526304_1183392) v(n1_1487392_1222304) v(n1_1449696_1222304) v(n1_1487392_1183392) v(n1_1449696_1183392) v(n1_1412000_1222304) v(n1_1373088_1222304) v(n1_1412000_1183392) v(n1_1373088_1183392) v(n1_1335392_1222304) v(n1_1296480_1222304) v(n1_1335392_1183392) v(n1_1296480_1183392) v(n1_1258784_1222304) v(n1_1219872_1222304) v(n1_1258784_1183392) v(n1_1219872_1183392) v(n1_1182176_1222304) v(n1_1144480_1222304) v(n1_1182176_1183392) v(n1_1144480_1183392) v(n1_1105568_1222304) v(n1_1067872_1222304) v(n1_1105568_1183392) v(n1_1067872_1183392) v(n1_1028960_1222304) v(n1_991264_1222304) v(n1_1028960_1183392) v(n1_991264_1183392) v(n1_952352_1222304) v(n1_914656_1222304) v(n1_952352_1183392) v(n1_914656_1183392) v(n1_876960_1222304) v(n1_876960_1183392) v(n1_876960_1146912) v(n1_876960_1108000) v(n1_914656_1146912) v(n1_914656_1108000) v(n1_876960_1071520) v(n1_876960_1032608) v(n1_914656_1071520) v(n1_914656_1032608) v(n1_876960_993696) v(n1_876960_957216) v(n1_914656_993696) v(n1_914656_957216) v(n1_876960_918304) v(n1_876960_881824) v(n1_914656_918304) v(n1_914656_881824) v(n1_876960_842912) v(n1_876960_804000) v(n1_914656_842912) v(n1_838048_767520) v(n1_914656_804000) v(n1_876960_767520) v(n1_876960_728608) v(n1_914656_767520) v(n1_838048_728608) v(n1_838048_692128) v(n1_800352_728608) v(n1_800352_692128) v(n1_800352_653216) v(n1_838048_653216) v(n1_800352_614304) v(n1_800352_577824) v(n1_838048_614304) v(n1_838048_577824) v(n1_800352_538912) v(n1_800352_502432) v(n1_838048_538912) v(n1_761440_480880) v(n1_838048_502432) v(n1_800352_480880) v(n1_800352_480720) v(n1_838048_480880) v(n1_761440_480720) v(n1_723744_480720) v(n1_876960_480880) v(n1_838048_480720) v(n1_876960_502432) v(n1_914656_502432) v(n1_876960_538912) v(n1_876960_577824) v(n1_914656_538912) v(n1_914656_577824) v(n1_876960_614304) v(n1_876960_653216) v(n1_914656_614304) v(n1_914656_653216) v(n1_876960_692128) v(n1_914656_692128) v(n1_952352_692128) v(n1_914656_728608) v(n1_952352_728608) v(n1_991264_728608) v(n1_952352_767520) v(n1_952352_804000) v(n1_991264_767520) v(n1_991264_804000) v(n1_952352_842912) v(n1_952352_881824) v(n1_991264_842912) v(n1_991264_881824) v(n1_952352_918304) v(n1_952352_957216) v(n1_991264_918304) v(n1_991264_957216) v(n1_952352_993696) v(n1_952352_1032608) v(n1_991264_993696) v(n1_991264_1032608) v(n1_952352_1071520) v(n1_952352_1108000) v(n1_991264_1071520) v(n1_991264_1108000) v(n1_952352_1146912) v(n1_991264_1146912) v(n1_1028960_1146912) v(n1_1067872_1146912) v(n1_1028960_1108000) v(n1_1067872_1108000) v(n1_1105568_1146912) v(n1_1144480_1146912) v(n1_1105568_1108000) v(n1_1144480_1108000) v(n1_1182176_1146912) v(n1_1219872_1146912) v(n1_1182176_1108000) v(n1_1219872_1108000) v(n1_1258784_1146912) v(n1_1296480_1146912) v(n1_1258784_1108000) v(n1_1296480_1108000) v(n1_1335392_1146912) v(n1_1373088_1146912) v(n1_1335392_1108000) v(n1_1373088_1108000) v(n1_1412000_1146912) v(n1_1449696_1146912) v(n1_1412000_1108000) v(n1_1449696_1108000) v(n1_1487392_1146912) v(n1_1526304_1146912) v(n1_1487392_1108000) v(n1_1526304_1108000) v(n1_1564000_1146912) v(n1_1602912_1146912) v(n1_1564000_1108000) v(n1_1641180_1183392) v(n1_1602912_1108000) v(n1_1641180_1146912) v(n1_1641290_1146912) v(n1_1641180_1108000) v(n1_1641290_1183392) v(n1_1641290_1222304) v(n1_1641180_1071520) v(n1_1641290_1108000) v(n1_1602912_1071520) v(n1_1602912_1032608) v(n1_1564000_1071520) v(n1_1526304_1071520) v(n1_1564000_1032608) v(n1_1526304_1032608) v(n1_1487392_1071520) v(n1_1449696_1071520) v(n1_1487392_1032608) v(n1_1449696_1032608) v(n1_1412000_1071520) v(n1_1373088_1071520) v(n1_1412000_1032608) v(n1_1373088_1032608) v(n1_1335392_1071520) v(n1_1296480_1071520) v(n1_1335392_1032608) v(n1_1296480_1032608) v(n1_1258784_1071520) v(n1_1219872_1071520) v(n1_1258784_1032608) v(n1_1219872_1032608) v(n1_1182176_1071520) v(n1_1144480_1071520) v(n1_1182176_1032608) v(n1_1144480_1032608) v(n1_1105568_1071520) v(n1_1067872_1071520) v(n1_1105568_1032608) v(n1_1067872_1032608) v(n1_1028960_1071520) v(n1_1028960_1032608) v(n1_1028960_993696) v(n1_1028960_957216) v(n1_1067872_993696) v(n1_1067872_957216) v(n1_1028960_918304) v(n1_1028960_881824) v(n1_1067872_918304) v(n1_1067872_881824) v(n1_1028960_842912) v(n1_1028960_804000) v(n1_1067872_842912) v(n1_1067872_804000) v(n1_1028960_767520) v(n1_1028960_728608) v(n1_1067872_767520) v(n1_991264_692128) v(n1_1067872_728608) v(n1_1028960_692128) v(n1_1028960_653216) v(n1_1067872_692128) v(n1_991264_653216) v(n1_991264_614304) v(n1_952352_653216) v(n1_952352_614304) v(n1_952352_577824) v(n1_991264_577824) v(n1_952352_538912) v(n1_952352_502432) v(n1_991264_538912) v(n1_914656_480880) v(n1_991264_502432) v(n1_952352_480880) v(n1_952352_480720) v(n1_991264_480880) v(n1_914656_480720) v(n1_876960_480720) v(n1_1028960_480880) v(n1_991264_480720) v(n1_1028960_502432) v(n1_1067872_502432) v(n1_1028960_538912) v(n1_1028960_577824) v(n1_1067872_538912) v(n1_1067872_577824) v(n1_1028960_614304) v(n1_1067872_614304) v(n1_1105568_614304) v(n1_1067872_653216) v(n1_1105568_653216) v(n1_1144480_653216) v(n1_1105568_692128) v(n1_1105568_728608) v(n1_1144480_692128) v(n1_1144480_728608) v(n1_1105568_767520) v(n1_1105568_804000) v(n1_1144480_767520) v(n1_1144480_804000) v(n1_1105568_842912) v(n1_1105568_881824) v(n1_1144480_842912) v(n1_1144480_881824) v(n1_1105568_918304) v(n1_1105568_957216) v(n1_1144480_918304) v(n1_1144480_957216) v(n1_1105568_993696) v(n1_1144480_993696) v(n1_1182176_993696) v(n1_1219872_993696) v(n1_1182176_957216) v(n1_1219872_957216) v(n1_1258784_993696) v(n1_1296480_993696) v(n1_1258784_957216) v(n1_1296480_957216) v(n1_1335392_993696) v(n1_1373088_993696) v(n1_1335392_957216) v(n1_1373088_957216) v(n1_1412000_993696) v(n1_1449696_993696) v(n1_1412000_957216) v(n1_1449696_957216) v(n1_1487392_993696) v(n1_1526304_993696) v(n1_1487392_957216) v(n1_1526304_957216) v(n1_1564000_993696) v(n1_1602912_993696) v(n1_1564000_957216) v(n1_1641180_1032608) v(n1_1602912_957216) v(n1_1641180_993696) v(n1_1641290_993696) v(n1_1641180_957216) v(n1_1641290_1032608) v(n1_1641290_1071520) v(n1_1641180_918304) v(n1_1641290_957216) v(n1_1602912_918304) v(n1_1602912_881824) v(n1_1564000_918304) v(n1_1526304_918304) v(n1_1564000_881824) v(n1_1526304_881824) v(n1_1487392_918304) v(n1_1449696_918304) v(n1_1487392_881824) v(n1_1449696_881824) v(n1_1412000_918304) v(n1_1373088_918304) v(n1_1412000_881824) v(n1_1373088_881824) v(n1_1335392_918304) v(n1_1296480_918304) v(n1_1335392_881824) v(n1_1296480_881824) v(n1_1258784_918304) v(n1_1219872_918304) v(n1_1258784_881824) v(n1_1219872_881824) v(n1_1182176_918304) v(n1_1182176_881824) v(n1_1182176_842912) v(n1_1182176_804000) v(n1_1219872_842912) v(n1_1219872_804000) v(n1_1182176_767520) v(n1_1182176_728608) v(n1_1219872_767520) v(n1_1219872_728608) v(n1_1182176_692128) v(n1_1182176_653216) v(n1_1219872_692128) v(n1_1144480_614304) v(n1_1219872_653216) v(n1_1182176_614304) v(n1_1182176_577824) v(n1_1219872_614304) v(n1_1144480_577824) v(n1_1144480_538912) v(n1_1105568_577824) v(n1_1105568_538912) v(n1_1105568_502432) v(n1_1067872_480880) v(n1_1144480_502432) v(n1_1105568_480880) v(n1_1105568_480720) v(n1_1144480_480880) v(n1_1067872_480720) v(n1_1028960_480720) v(n1_1182176_480880) v(n1_1144480_480720) v(n1_1182176_502432) v(n1_1219872_502432) v(n1_1182176_538912) v(n1_1219872_538912) v(n1_1258784_538912) v(n1_1219872_577824) v(n1_1258784_577824) v(n1_1296480_577824) v(n1_1258784_614304) v(n1_1258784_653216) v(n1_1296480_614304) v(n1_1296480_653216) v(n1_1258784_692128) v(n1_1258784_728608) v(n1_1296480_692128) v(n1_1296480_728608) v(n1_1258784_767520) v(n1_1258784_804000) v(n1_1296480_767520) v(n1_1296480_804000) v(n1_1258784_842912) v(n1_1296480_842912) v(n1_1335392_842912) v(n1_1373088_842912) v(n1_1335392_804000) v(n1_1373088_804000) v(n1_1412000_842912) v(n1_1449696_842912) v(n1_1412000_804000) v(n1_1449696_804000) v(n1_1487392_842912) v(n1_1526304_842912) v(n1_1487392_804000) v(n1_1526304_804000) v(n1_1564000_842912) v(n1_1602912_842912) v(n1_1564000_804000) v(n1_1641180_881824) v(n1_1602912_804000) v(n1_1641180_842912) v(n1_1641290_842912) v(n1_1641180_804000) v(n1_1641290_881824) v(n1_1641290_918304) v(n1_1641180_767520) v(n1_1641290_804000) v(n1_1602912_767520) v(n1_1602912_728608) v(n1_1564000_767520) v(n1_1526304_767520) v(n1_1564000_728608) v(n1_1526304_728608) v(n1_1487392_767520) v(n1_1449696_767520) v(n1_1487392_728608) v(n1_1449696_728608) v(n1_1412000_767520) v(n1_1373088_767520) v(n1_1412000_728608) v(n1_1373088_728608) v(n1_1335392_767520) v(n1_1335392_728608) v(n1_1335392_692128) v(n1_1335392_653216) v(n1_1373088_692128) v(n1_1373088_653216) v(n1_1335392_614304) v(n1_1335392_577824) v(n1_1373088_614304) v(n1_1296480_538912) v(n1_1373088_577824) v(n1_1335392_538912) v(n1_1335392_502432) v(n1_1373088_538912) v(n1_1296480_502432) v(n1_1296480_480880) v(n1_1258784_502432) v(n1_1258784_480880) v(n1_1258784_480720) v(n1_1219872_480880) v(n1_1219872_480720) v(n1_1182176_480720) v(n1_1335392_480880) v(n1_1296480_480720) v(n1_1373088_480880) v(n1_1335392_480720) v(n1_1373088_502432) v(n1_1412000_502432) v(n1_1412000_538912) v(n1_1449696_538912) v(n1_1412000_577824) v(n1_1412000_614304) v(n1_1449696_577824) v(n1_1449696_614304) v(n1_1412000_653216) v(n1_1412000_692128) v(n1_1449696_653216) v(n1_1449696_692128) v(n1_1487392_692128) v(n1_1526304_692128) v(n1_1487392_653216) v(n1_1526304_653216) v(n1_1564000_692128) v(n1_1602912_692128) v(n1_1564000_653216) v(n1_1641180_728608) v(n1_1602912_653216) v(n1_1641180_692128) v(n1_1641290_692128) v(n1_1641180_653216) v(n1_1641290_728608) v(n1_1641290_767520) v(n1_1641180_614304) v(n1_1641290_653216) v(n1_1602912_614304) v(n1_1602912_577824) v(n1_1564000_614304) v(n1_1526304_614304) v(n1_1564000_577824) v(n1_1526304_577824) v(n1_1487392_614304) v(n1_1487392_577824) v(n1_1487392_538912) v(n1_1487392_502432) v(n1_1526304_538912) v(n1_1449696_502432) v(n1_1449696_480880) v(n1_1412000_480880) v(n1_1412000_480720) v(n1_1373088_480720) v(n1_1487392_480880) v(n1_1449696_480720) v(n1_1526304_480880) v(n1_1487392_480720) v(n1_1526304_502432) v(n1_1564000_502432) v(n1_1564000_538912) v(n1_1602912_538912) v(n1_1641180_577824) v(n1_1602912_502432) v(n1_1641180_538912) v(n1_1641290_538912) v(n1_1641180_502432) v(n1_1641290_577824) v(n1_1641290_614304) v(n1_1641180_480880) v(n1_1641290_502432) v(n1_1602912_480880) v(n1_1602912_480720) v(n1_1620161_480880) v(n1_1564000_480880) v(n1_1564000_480720) v(n1_1526304_480720) v(n1_1620161_300000) v(n1_1620161_481040) v(n1_1620161_295000) v(n1_1641290_480880) v(n1_1641180_480720)
.end
