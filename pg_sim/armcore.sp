v0 n1_979937_1820000 0 1.8
v1 n1_1620161_300000 0 1.8
R27-100-100 n1_295000_940095 n1_300000_940095 0.736842
R27-100-101 n1_300000_940095 n1_474796_940095 25.7594
R27-100-102 n1_474796_940095 n1_474906_940095 0.0162105
R27-101-100 n1_474686_957216 n1_474796_957216 0.01925
R27-101-101 n1_474796_957216 n1_493920_957216 92.2967
R27-101-102 n1_493920_957216 n1_532832_957216 23.6685
R27-101-103 n1_532832_957216 n1_570528_957216 6.5968
R27-101-104 n1_570528_957216 n1_609440_957216 6.8096000000000005
R27-101-105 n1_609440_957216 n1_647136_957216 6.5968
R27-101-106 n1_647136_957216 n1_686048_957216 6.8096000000000005
R27-101-107 n1_686048_957216 n1_723744_957216 6.5968
R27-101-108 n1_723744_957216 n1_761440_957216 6.5968
R27-101-109 n1_761440_957216 n1_800352_957216 6.8096000000000005
R27-101-110 n1_800352_957216 n1_838048_957216 6.5968
R27-101-111 n1_838048_957216 n1_876960_957216 6.8096000000000005
R27-101-112 n1_876960_957216 n1_914656_957216 6.5968
R27-101-113 n1_914656_957216 n1_952352_957216 6.5968
R27-101-114 n1_952352_957216 n1_991264_957216 6.8096000000000005
R27-101-115 n1_991264_957216 n1_1028960_957216 6.5968
R27-101-116 n1_1028960_957216 n1_1067872_957216 6.8096000000000005
R27-101-117 n1_1067872_957216 n1_1105568_957216 6.5968
R27-101-118 n1_1105568_957216 n1_1144480_957216 6.8096000000000005
R27-101-119 n1_1144480_957216 n1_1182176_957216 6.5968
R27-101-120 n1_1182176_957216 n1_1219872_957216 6.5968
R27-101-121 n1_1219872_957216 n1_1258784_957216 6.8096000000000005
R27-101-122 n1_1258784_957216 n1_1296480_957216 6.5968
R27-101-123 n1_1296480_957216 n1_1335392_957216 6.8096000000000005
R27-101-124 n1_1335392_957216 n1_1373088_957216 6.5968
R27-101-125 n1_1373088_957216 n1_1412000_957216 6.8096000000000005
R27-101-126 n1_1412000_957216 n1_1449696_957216 6.5968
R27-101-127 n1_1449696_957216 n1_1487392_957216 6.5968
R27-101-128 n1_1487392_957216 n1_1526304_957216 6.8096000000000005
R27-101-129 n1_1526304_957216 n1_1564000_957216 6.5968
R27-101-130 n1_1564000_957216 n1_1602912_957216 6.8096000000000005
R27-101-131 n1_1602912_957216 n1_1641180_957216 98.2715
R27-101-132 n1_1641180_957216 n1_1641290_957216 0.01925
R27-102-100 n1_474686_993696 n1_474796_993696 0.01925
R27-102-101 n1_474796_993696 n1_493920_993696 63.601
R27-102-102 n1_493920_993696 n1_532832_993696 124.4757
R27-102-103 n1_532832_993696 n1_570528_993696 87.2067
R27-102-104 n1_570528_993696 n1_609440_993696 17.0018
R27-102-105 n1_609440_993696 n1_647136_993696 6.5968
R27-102-106 n1_647136_993696 n1_686048_993696 6.8096000000000005
R27-102-107 n1_686048_993696 n1_723744_993696 6.5968
R27-102-108 n1_723744_993696 n1_761440_993696 6.5968
R27-102-109 n1_761440_993696 n1_800352_993696 6.8096000000000005
R27-102-110 n1_800352_993696 n1_838048_993696 6.5968
R27-102-111 n1_838048_993696 n1_876960_993696 6.8096000000000005
R27-102-112 n1_876960_993696 n1_914656_993696 6.5968
R27-102-113 n1_914656_993696 n1_952352_993696 6.5968
R27-102-114 n1_952352_993696 n1_991264_993696 6.8096000000000005
R27-102-115 n1_991264_993696 n1_1028960_993696 6.5968
R27-102-116 n1_1028960_993696 n1_1067872_993696 6.8096000000000005
R27-102-117 n1_1067872_993696 n1_1105568_993696 6.5968
R27-102-118 n1_1105568_993696 n1_1144480_993696 6.8096000000000005
R27-102-119 n1_1144480_993696 n1_1182176_993696 6.5968
R27-102-120 n1_1182176_993696 n1_1219872_993696 6.5968
R27-102-121 n1_1219872_993696 n1_1258784_993696 6.8096000000000005
R27-102-122 n1_1258784_993696 n1_1296480_993696 6.5968
R27-102-123 n1_1296480_993696 n1_1335392_993696 6.8096000000000005
R27-102-124 n1_1335392_993696 n1_1373088_993696 6.5968
R27-102-125 n1_1373088_993696 n1_1412000_993696 6.8096000000000005
R27-102-126 n1_1412000_993696 n1_1449696_993696 6.5968
R27-102-127 n1_1449696_993696 n1_1487392_993696 6.5968
R27-102-128 n1_1487392_993696 n1_1526304_993696 6.8096000000000005
R27-102-129 n1_1526304_993696 n1_1564000_993696 6.5968
R27-102-130 n1_1564000_993696 n1_1602912_993696 6.8096000000000005
R27-102-131 n1_1602912_993696 n1_1641180_993696 116.7605
R27-102-132 n1_1641180_993696 n1_1641290_993696 0.01925
R27-103-100 n1_474686_1032608 n1_474796_1032608 0.01925
R27-103-101 n1_474796_1032608 n1_493920_1032608 23.2042
R27-103-102 n1_493920_1032608 n1_532832_1032608 6.8096000000000005
R27-103-103 n1_532832_1032608 n1_570528_1032608 6.5968
R27-103-104 n1_570528_1032608 n1_609440_1032608 6.8096000000000005
R27-103-105 n1_609440_1032608 n1_647136_1032608 6.5968
R27-103-106 n1_647136_1032608 n1_686048_1032608 6.8096000000000005
R27-103-107 n1_686048_1032608 n1_723744_1032608 6.5968
R27-103-108 n1_723744_1032608 n1_761440_1032608 6.5968
R27-103-109 n1_761440_1032608 n1_800352_1032608 6.8096000000000005
R27-103-110 n1_800352_1032608 n1_838048_1032608 6.5968
R27-103-111 n1_838048_1032608 n1_876960_1032608 6.8096000000000005
R27-103-112 n1_876960_1032608 n1_914656_1032608 6.5968
R27-103-113 n1_914656_1032608 n1_952352_1032608 6.5968
R27-103-114 n1_952352_1032608 n1_991264_1032608 6.8096000000000005
R27-103-115 n1_991264_1032608 n1_1028960_1032608 6.5968
R27-103-116 n1_1028960_1032608 n1_1067872_1032608 6.8096000000000005
R27-103-117 n1_1067872_1032608 n1_1105568_1032608 6.5968
R27-103-118 n1_1105568_1032608 n1_1144480_1032608 6.8096000000000005
R27-103-119 n1_1144480_1032608 n1_1182176_1032608 6.5968
R27-103-120 n1_1182176_1032608 n1_1219872_1032608 6.5968
R27-103-121 n1_1219872_1032608 n1_1258784_1032608 6.8096000000000005
R27-103-122 n1_1258784_1032608 n1_1296480_1032608 6.5968
R27-103-123 n1_1296480_1032608 n1_1335392_1032608 6.8096000000000005
R27-103-124 n1_1335392_1032608 n1_1373088_1032608 6.5968
R27-103-125 n1_1373088_1032608 n1_1412000_1032608 6.8096000000000005
R27-103-126 n1_1412000_1032608 n1_1449696_1032608 6.5968
R27-103-127 n1_1449696_1032608 n1_1487392_1032608 6.5968
R27-103-128 n1_1487392_1032608 n1_1526304_1032608 6.8096000000000005
R27-103-129 n1_1526304_1032608 n1_1564000_1032608 6.5968
R27-103-130 n1_1564000_1032608 n1_1602912_1032608 6.8096000000000005
R27-103-131 n1_1602912_1032608 n1_1641180_1032608 23.7606
R27-103-132 n1_1641180_1032608 n1_1641290_1032608 0.01925
R27-104-100 n1_474686_1071520 n1_474796_1071520 0.01925
R27-104-101 n1_474796_1071520 n1_493920_1071520 27.4846
R27-104-102 n1_493920_1071520 n1_532832_1071520 6.8096000000000005
R27-104-103 n1_532832_1071520 n1_570528_1071520 6.5968
R27-104-104 n1_570528_1071520 n1_609440_1071520 6.8096000000000005
R27-104-105 n1_609440_1071520 n1_647136_1071520 6.5968
R27-104-106 n1_647136_1071520 n1_686048_1071520 6.8096000000000005
R27-104-107 n1_686048_1071520 n1_723744_1071520 6.5968
R27-104-108 n1_723744_1071520 n1_761440_1071520 6.5968
R27-104-109 n1_761440_1071520 n1_800352_1071520 6.8096000000000005
R27-104-110 n1_800352_1071520 n1_838048_1071520 6.5968
R27-104-111 n1_838048_1071520 n1_876960_1071520 6.8096000000000005
R27-104-112 n1_876960_1071520 n1_914656_1071520 6.5968
R27-104-113 n1_914656_1071520 n1_952352_1071520 6.5968
R27-104-114 n1_952352_1071520 n1_991264_1071520 6.8096000000000005
R27-104-115 n1_991264_1071520 n1_1028960_1071520 6.5968
R27-104-116 n1_1028960_1071520 n1_1067872_1071520 6.8096000000000005
R27-104-117 n1_1067872_1071520 n1_1105568_1071520 6.5968
R27-104-118 n1_1105568_1071520 n1_1144480_1071520 6.8096000000000005
R27-104-119 n1_1144480_1071520 n1_1182176_1071520 6.5968
R27-104-120 n1_1182176_1071520 n1_1219872_1071520 6.5968
R27-104-121 n1_1219872_1071520 n1_1258784_1071520 6.8096000000000005
R27-104-122 n1_1258784_1071520 n1_1296480_1071520 6.5968
R27-104-123 n1_1296480_1071520 n1_1335392_1071520 6.8096000000000005
R27-104-124 n1_1335392_1071520 n1_1373088_1071520 6.5968
R27-104-125 n1_1373088_1071520 n1_1412000_1071520 6.8096000000000005
R27-104-126 n1_1412000_1071520 n1_1449696_1071520 6.5968
R27-104-127 n1_1449696_1071520 n1_1487392_1071520 6.5968
R27-104-128 n1_1487392_1071520 n1_1526304_1071520 6.8096000000000005
R27-104-129 n1_1526304_1071520 n1_1564000_1071520 6.5968
R27-104-130 n1_1564000_1071520 n1_1602912_1071520 6.8096000000000005
R27-104-131 n1_1602912_1071520 n1_1641180_1071520 24.1908
R27-104-132 n1_1641180_1071520 n1_1641290_1071520 0.01925
R27-105-100 n1_474686_1108000 n1_474796_1108000 0.01925
R27-105-101 n1_474796_1108000 n1_493920_1108000 44.0378
R27-105-102 n1_493920_1108000 n1_532832_1108000 6.8096000000000005
R27-105-103 n1_532832_1108000 n1_570528_1108000 6.5968
R27-105-104 n1_570528_1108000 n1_609440_1108000 6.8096000000000005
R27-105-105 n1_609440_1108000 n1_647136_1108000 6.5968
R27-105-106 n1_647136_1108000 n1_686048_1108000 6.8096000000000005
R27-105-107 n1_686048_1108000 n1_723744_1108000 6.5968
R27-105-108 n1_723744_1108000 n1_761440_1108000 6.5968
R27-105-109 n1_761440_1108000 n1_800352_1108000 6.8096000000000005
R27-105-110 n1_800352_1108000 n1_838048_1108000 6.5968
R27-105-111 n1_838048_1108000 n1_876960_1108000 6.8096000000000005
R27-105-112 n1_876960_1108000 n1_914656_1108000 6.5968
R27-105-113 n1_914656_1108000 n1_952352_1108000 6.5968
R27-105-114 n1_952352_1108000 n1_991264_1108000 6.8096000000000005
R27-105-115 n1_991264_1108000 n1_1028960_1108000 6.5968
R27-105-116 n1_1028960_1108000 n1_1067872_1108000 6.8096000000000005
R27-105-117 n1_1067872_1108000 n1_1105568_1108000 6.5968
R27-105-118 n1_1105568_1108000 n1_1144480_1108000 6.8096000000000005
R27-105-119 n1_1144480_1108000 n1_1182176_1108000 6.5968
R27-105-120 n1_1182176_1108000 n1_1219872_1108000 6.5968
R27-105-121 n1_1219872_1108000 n1_1258784_1108000 6.8096000000000005
R27-105-122 n1_1258784_1108000 n1_1296480_1108000 6.5968
R27-105-123 n1_1296480_1108000 n1_1335392_1108000 6.8096000000000005
R27-105-124 n1_1335392_1108000 n1_1373088_1108000 6.5968
R27-105-125 n1_1373088_1108000 n1_1412000_1108000 6.8096000000000005
R27-105-126 n1_1412000_1108000 n1_1449696_1108000 6.5968
R27-105-127 n1_1449696_1108000 n1_1487392_1108000 6.5968
R27-105-128 n1_1487392_1108000 n1_1526304_1108000 6.8096000000000005
R27-105-129 n1_1526304_1108000 n1_1564000_1108000 6.5968
R27-105-130 n1_1564000_1108000 n1_1602912_1108000 6.8096000000000005
R27-105-131 n1_1602912_1108000 n1_1641180_1108000 6.696899999999999
R27-105-132 n1_1641180_1108000 n1_1641290_1108000 0.01925
R27-106-100 n1_474686_1146912 n1_474796_1146912 0.01925
R27-106-101 n1_474796_1146912 n1_493920_1146912 44.3668
R27-106-102 n1_493920_1146912 n1_532832_1146912 6.8096000000000005
R27-106-103 n1_532832_1146912 n1_570528_1146912 6.5968
R27-106-104 n1_570528_1146912 n1_609440_1146912 6.8096000000000005
R27-106-105 n1_609440_1146912 n1_647136_1146912 6.5968
R27-106-106 n1_647136_1146912 n1_686048_1146912 6.8096000000000005
R27-106-107 n1_686048_1146912 n1_723744_1146912 6.5968
R27-106-108 n1_723744_1146912 n1_761440_1146912 6.5968
R27-106-109 n1_761440_1146912 n1_800352_1146912 6.8096000000000005
R27-106-110 n1_800352_1146912 n1_838048_1146912 6.5968
R27-106-111 n1_838048_1146912 n1_876960_1146912 6.8096000000000005
R27-106-112 n1_876960_1146912 n1_914656_1146912 6.5968
R27-106-113 n1_914656_1146912 n1_952352_1146912 6.5968
R27-106-114 n1_952352_1146912 n1_991264_1146912 6.8096000000000005
R27-106-115 n1_991264_1146912 n1_1028960_1146912 6.5968
R27-106-116 n1_1028960_1146912 n1_1067872_1146912 6.8096000000000005
R27-106-117 n1_1067872_1146912 n1_1105568_1146912 6.5968
R27-106-118 n1_1105568_1146912 n1_1144480_1146912 6.8096000000000005
R27-106-119 n1_1144480_1146912 n1_1182176_1146912 6.5968
R27-106-120 n1_1182176_1146912 n1_1219872_1146912 6.5968
R27-106-121 n1_1219872_1146912 n1_1258784_1146912 6.8096000000000005
R27-106-122 n1_1258784_1146912 n1_1296480_1146912 6.5968
R27-106-123 n1_1296480_1146912 n1_1335392_1146912 6.8096000000000005
R27-106-124 n1_1335392_1146912 n1_1373088_1146912 6.5968
R27-106-125 n1_1373088_1146912 n1_1412000_1146912 6.8096000000000005
R27-106-126 n1_1412000_1146912 n1_1449696_1146912 6.5968
R27-106-127 n1_1449696_1146912 n1_1487392_1146912 6.5968
R27-106-128 n1_1487392_1146912 n1_1526304_1146912 6.8096000000000005
R27-106-129 n1_1526304_1146912 n1_1564000_1146912 6.5968
R27-106-130 n1_1564000_1146912 n1_1602912_1146912 6.8096000000000005
R27-106-131 n1_1602912_1146912 n1_1641180_1146912 6.696899999999999
R27-106-132 n1_1641180_1146912 n1_1641290_1146912 0.01925
R27-107-100 n1_474686_1183392 n1_474796_1183392 0.01925
R27-107-101 n1_474796_1183392 n1_493920_1183392 42.9193
R27-107-102 n1_493920_1183392 n1_532832_1183392 6.8096000000000005
R27-107-103 n1_532832_1183392 n1_570528_1183392 6.5968
R27-107-104 n1_570528_1183392 n1_609440_1183392 6.8096000000000005
R27-107-105 n1_609440_1183392 n1_647136_1183392 6.5968
R27-107-106 n1_647136_1183392 n1_686048_1183392 6.8096000000000005
R27-107-107 n1_686048_1183392 n1_723744_1183392 6.5968
R27-107-108 n1_723744_1183392 n1_761440_1183392 6.5968
R27-107-109 n1_761440_1183392 n1_800352_1183392 6.8096000000000005
R27-107-110 n1_800352_1183392 n1_838048_1183392 6.5968
R27-107-111 n1_838048_1183392 n1_876960_1183392 6.8096000000000005
R27-107-112 n1_876960_1183392 n1_914656_1183392 6.5968
R27-107-113 n1_914656_1183392 n1_952352_1183392 6.5968
R27-107-114 n1_952352_1183392 n1_991264_1183392 6.8096000000000005
R27-107-115 n1_991264_1183392 n1_1028960_1183392 6.5968
R27-107-116 n1_1028960_1183392 n1_1067872_1183392 6.8096000000000005
R27-107-117 n1_1067872_1183392 n1_1105568_1183392 6.5968
R27-107-118 n1_1105568_1183392 n1_1144480_1183392 6.8096000000000005
R27-107-119 n1_1144480_1183392 n1_1182176_1183392 6.5968
R27-107-120 n1_1182176_1183392 n1_1219872_1183392 6.5968
R27-107-121 n1_1219872_1183392 n1_1258784_1183392 6.8096000000000005
R27-107-122 n1_1258784_1183392 n1_1296480_1183392 6.5968
R27-107-123 n1_1296480_1183392 n1_1335392_1183392 6.8096000000000005
R27-107-124 n1_1335392_1183392 n1_1373088_1183392 6.5968
R27-107-125 n1_1373088_1183392 n1_1412000_1183392 6.8096000000000005
R27-107-126 n1_1412000_1183392 n1_1449696_1183392 6.5968
R27-107-127 n1_1449696_1183392 n1_1487392_1183392 6.5968
R27-107-128 n1_1487392_1183392 n1_1526304_1183392 6.8096000000000005
R27-107-129 n1_1526304_1183392 n1_1564000_1183392 6.5968
R27-107-130 n1_1564000_1183392 n1_1602912_1183392 6.8096000000000005
R27-107-131 n1_1602912_1183392 n1_1641180_1183392 6.696899999999999
R27-107-132 n1_1641180_1183392 n1_1641290_1183392 0.01925
R27-108-100 n1_474686_1222304 n1_474796_1222304 0.01925
R27-108-101 n1_474796_1222304 n1_493920_1222304 40.2461
R27-108-102 n1_493920_1222304 n1_532832_1222304 6.8096000000000005
R27-108-103 n1_532832_1222304 n1_570528_1222304 6.5968
R27-108-104 n1_570528_1222304 n1_609440_1222304 6.8096000000000005
R27-108-105 n1_609440_1222304 n1_647136_1222304 6.5968
R27-108-106 n1_647136_1222304 n1_686048_1222304 6.8096000000000005
R27-108-107 n1_686048_1222304 n1_723744_1222304 6.5968
R27-108-108 n1_723744_1222304 n1_761440_1222304 6.5968
R27-108-109 n1_761440_1222304 n1_800352_1222304 6.8096000000000005
R27-108-110 n1_800352_1222304 n1_838048_1222304 6.5968
R27-108-111 n1_838048_1222304 n1_876960_1222304 6.8096000000000005
R27-108-112 n1_876960_1222304 n1_914656_1222304 6.5968
R27-108-113 n1_914656_1222304 n1_952352_1222304 6.5968
R27-108-114 n1_952352_1222304 n1_991264_1222304 6.8096000000000005
R27-108-115 n1_991264_1222304 n1_1028960_1222304 6.5968
R27-108-116 n1_1028960_1222304 n1_1067872_1222304 6.8096000000000005
R27-108-117 n1_1067872_1222304 n1_1105568_1222304 6.5968
R27-108-118 n1_1105568_1222304 n1_1144480_1222304 6.8096000000000005
R27-108-119 n1_1144480_1222304 n1_1182176_1222304 6.5968
R27-108-120 n1_1182176_1222304 n1_1219872_1222304 6.5968
R27-108-121 n1_1219872_1222304 n1_1258784_1222304 6.8096000000000005
R27-108-122 n1_1258784_1222304 n1_1296480_1222304 6.5968
R27-108-123 n1_1296480_1222304 n1_1335392_1222304 6.8096000000000005
R27-108-124 n1_1335392_1222304 n1_1373088_1222304 6.5968
R27-108-125 n1_1373088_1222304 n1_1412000_1222304 6.8096000000000005
R27-108-126 n1_1412000_1222304 n1_1449696_1222304 6.5968
R27-108-127 n1_1449696_1222304 n1_1487392_1222304 6.5968
R27-108-128 n1_1487392_1222304 n1_1526304_1222304 6.8096000000000005
R27-108-129 n1_1526304_1222304 n1_1564000_1222304 6.5968
R27-108-130 n1_1564000_1222304 n1_1602912_1222304 6.8096000000000005
R27-108-131 n1_1602912_1222304 n1_1641180_1222304 6.696899999999999
R27-108-132 n1_1641180_1222304 n1_1641290_1222304 0.01925
R27-109-100 n1_474686_1261216 n1_474796_1261216 0.01925
R27-109-101 n1_474796_1261216 n1_493920_1261216 33.9658
R27-109-102 n1_493920_1261216 n1_532832_1261216 6.8096000000000005
R27-109-103 n1_532832_1261216 n1_570528_1261216 6.5968
R27-109-104 n1_570528_1261216 n1_609440_1261216 6.8096000000000005
R27-109-105 n1_609440_1261216 n1_647136_1261216 6.5968
R27-109-106 n1_647136_1261216 n1_686048_1261216 6.8096000000000005
R27-109-107 n1_686048_1261216 n1_723744_1261216 6.5968
R27-109-108 n1_723744_1261216 n1_761440_1261216 6.5968
R27-109-109 n1_761440_1261216 n1_800352_1261216 6.8096000000000005
R27-109-110 n1_800352_1261216 n1_838048_1261216 6.5968
R27-109-111 n1_838048_1261216 n1_876960_1261216 6.8096000000000005
R27-109-112 n1_876960_1261216 n1_914656_1261216 6.5968
R27-109-113 n1_914656_1261216 n1_952352_1261216 6.5968
R27-109-114 n1_952352_1261216 n1_991264_1261216 6.8096000000000005
R27-109-115 n1_991264_1261216 n1_1028960_1261216 6.5968
R27-109-116 n1_1028960_1261216 n1_1067872_1261216 6.8096000000000005
R27-109-117 n1_1067872_1261216 n1_1105568_1261216 6.5968
R27-109-118 n1_1105568_1261216 n1_1144480_1261216 6.8096000000000005
R27-109-119 n1_1144480_1261216 n1_1182176_1261216 6.5968
R27-109-120 n1_1182176_1261216 n1_1219872_1261216 6.5968
R27-109-121 n1_1219872_1261216 n1_1258784_1261216 6.8096000000000005
R27-109-122 n1_1258784_1261216 n1_1296480_1261216 6.5968
R27-109-123 n1_1296480_1261216 n1_1335392_1261216 6.8096000000000005
R27-109-124 n1_1335392_1261216 n1_1373088_1261216 6.5968
R27-109-125 n1_1373088_1261216 n1_1412000_1261216 6.8096000000000005
R27-109-126 n1_1412000_1261216 n1_1449696_1261216 6.5968
R27-109-127 n1_1449696_1261216 n1_1487392_1261216 6.5968
R27-109-128 n1_1487392_1261216 n1_1526304_1261216 6.8096000000000005
R27-109-129 n1_1526304_1261216 n1_1564000_1261216 6.5968
R27-109-130 n1_1564000_1261216 n1_1602912_1261216 6.8096000000000005
R27-109-131 n1_1602912_1261216 n1_1641180_1261216 6.696899999999999
R27-109-132 n1_1641180_1261216 n1_1641290_1261216 0.01925
R27-110-100 n1_474686_1297696 n1_474796_1297696 0.01925
R27-110-101 n1_474796_1297696 n1_493920_1297696 31.2798
R27-110-102 n1_493920_1297696 n1_532832_1297696 6.8096000000000005
R27-110-103 n1_532832_1297696 n1_570528_1297696 6.5968
R27-110-104 n1_570528_1297696 n1_609440_1297696 6.8096000000000005
R27-110-105 n1_609440_1297696 n1_647136_1297696 6.5968
R27-110-106 n1_647136_1297696 n1_686048_1297696 6.8096000000000005
R27-110-107 n1_686048_1297696 n1_723744_1297696 6.5968
R27-110-108 n1_723744_1297696 n1_761440_1297696 6.5968
R27-110-109 n1_761440_1297696 n1_800352_1297696 6.8096000000000005
R27-110-110 n1_800352_1297696 n1_838048_1297696 6.5968
R27-110-111 n1_838048_1297696 n1_876960_1297696 6.8096000000000005
R27-110-112 n1_876960_1297696 n1_914656_1297696 6.5968
R27-110-113 n1_914656_1297696 n1_952352_1297696 6.5968
R27-110-114 n1_952352_1297696 n1_991264_1297696 6.8096000000000005
R27-110-115 n1_991264_1297696 n1_1028960_1297696 6.5968
R27-110-116 n1_1028960_1297696 n1_1067872_1297696 6.8096000000000005
R27-110-117 n1_1067872_1297696 n1_1105568_1297696 6.5968
R27-110-118 n1_1105568_1297696 n1_1144480_1297696 6.8096000000000005
R27-110-119 n1_1144480_1297696 n1_1182176_1297696 6.5968
R27-110-120 n1_1182176_1297696 n1_1219872_1297696 6.5968
R27-110-121 n1_1219872_1297696 n1_1258784_1297696 6.8096000000000005
R27-110-122 n1_1258784_1297696 n1_1296480_1297696 6.5968
R27-110-123 n1_1296480_1297696 n1_1335392_1297696 6.8096000000000005
R27-110-124 n1_1335392_1297696 n1_1373088_1297696 6.5968
R27-110-125 n1_1373088_1297696 n1_1412000_1297696 6.8096000000000005
R27-110-126 n1_1412000_1297696 n1_1449696_1297696 6.5968
R27-110-127 n1_1449696_1297696 n1_1487392_1297696 6.5968
R27-110-128 n1_1487392_1297696 n1_1526304_1297696 6.8096000000000005
R27-110-129 n1_1526304_1297696 n1_1564000_1297696 6.5968
R27-110-130 n1_1564000_1297696 n1_1602912_1297696 6.8096000000000005
R27-110-131 n1_1602912_1297696 n1_1641180_1297696 6.696899999999999
R27-110-132 n1_1641180_1297696 n1_1641290_1297696 0.01925
R27-111-100 n1_474686_1336608 n1_474796_1336608 0.01925
R27-111-101 n1_474796_1336608 n1_493920_1336608 28.0218
R27-111-102 n1_493920_1336608 n1_532832_1336608 6.8096000000000005
R27-111-103 n1_532832_1336608 n1_570528_1336608 6.5968
R27-111-104 n1_570528_1336608 n1_609440_1336608 6.8096000000000005
R27-111-105 n1_609440_1336608 n1_647136_1336608 6.5968
R27-111-106 n1_647136_1336608 n1_686048_1336608 6.8096000000000005
R27-111-107 n1_686048_1336608 n1_723744_1336608 6.5968
R27-111-108 n1_723744_1336608 n1_761440_1336608 6.5968
R27-111-109 n1_761440_1336608 n1_800352_1336608 6.8096000000000005
R27-111-110 n1_800352_1336608 n1_838048_1336608 6.5968
R27-111-111 n1_838048_1336608 n1_876960_1336608 6.8096000000000005
R27-111-112 n1_876960_1336608 n1_914656_1336608 6.5968
R27-111-113 n1_914656_1336608 n1_952352_1336608 6.5968
R27-111-114 n1_952352_1336608 n1_991264_1336608 6.8096000000000005
R27-111-115 n1_991264_1336608 n1_1028960_1336608 6.5968
R27-111-116 n1_1028960_1336608 n1_1067872_1336608 6.8096000000000005
R27-111-117 n1_1067872_1336608 n1_1105568_1336608 6.5968
R27-111-118 n1_1105568_1336608 n1_1144480_1336608 6.8096000000000005
R27-111-119 n1_1144480_1336608 n1_1182176_1336608 6.5968
R27-111-120 n1_1182176_1336608 n1_1219872_1336608 6.5968
R27-111-121 n1_1219872_1336608 n1_1258784_1336608 6.8096000000000005
R27-111-122 n1_1258784_1336608 n1_1296480_1336608 6.5968
R27-111-123 n1_1296480_1336608 n1_1335392_1336608 6.8096000000000005
R27-111-124 n1_1335392_1336608 n1_1373088_1336608 6.5968
R27-111-125 n1_1373088_1336608 n1_1412000_1336608 6.8096000000000005
R27-111-126 n1_1412000_1336608 n1_1449696_1336608 6.5968
R27-111-127 n1_1449696_1336608 n1_1487392_1336608 6.5968
R27-111-128 n1_1487392_1336608 n1_1526304_1336608 6.8096000000000005
R27-111-129 n1_1526304_1336608 n1_1564000_1336608 6.5968
R27-111-130 n1_1564000_1336608 n1_1602912_1336608 6.8096000000000005
R27-111-131 n1_1602912_1336608 n1_1641180_1336608 6.696899999999999
R27-111-132 n1_1641180_1336608 n1_1641290_1336608 0.01925
R27-112-100 n1_474686_1373088 n1_474796_1373088 0.01925
R27-112-101 n1_474796_1373088 n1_493920_1373088 22.9339
R27-112-102 n1_493920_1373088 n1_532832_1373088 6.8096000000000005
R27-112-103 n1_532832_1373088 n1_570528_1373088 6.5968
R27-112-104 n1_570528_1373088 n1_609440_1373088 6.8096000000000005
R27-112-105 n1_609440_1373088 n1_647136_1373088 6.5968
R27-112-106 n1_647136_1373088 n1_686048_1373088 6.8096000000000005
R27-112-107 n1_686048_1373088 n1_723744_1373088 6.5968
R27-112-108 n1_723744_1373088 n1_761440_1373088 6.5968
R27-112-109 n1_761440_1373088 n1_800352_1373088 6.8096000000000005
R27-112-110 n1_800352_1373088 n1_838048_1373088 6.5968
R27-112-111 n1_838048_1373088 n1_876960_1373088 6.8096000000000005
R27-112-112 n1_876960_1373088 n1_914656_1373088 6.5968
R27-112-113 n1_914656_1373088 n1_952352_1373088 6.5968
R27-112-114 n1_952352_1373088 n1_991264_1373088 6.8096000000000005
R27-112-115 n1_991264_1373088 n1_1028960_1373088 6.5968
R27-112-116 n1_1028960_1373088 n1_1067872_1373088 6.8096000000000005
R27-112-117 n1_1067872_1373088 n1_1105568_1373088 6.5968
R27-112-118 n1_1105568_1373088 n1_1144480_1373088 6.8096000000000005
R27-112-119 n1_1144480_1373088 n1_1182176_1373088 6.5968
R27-112-120 n1_1182176_1373088 n1_1219872_1373088 6.5968
R27-112-121 n1_1219872_1373088 n1_1258784_1373088 6.8096000000000005
R27-112-122 n1_1258784_1373088 n1_1296480_1373088 6.5968
R27-112-123 n1_1296480_1373088 n1_1335392_1373088 6.8096000000000005
R27-112-124 n1_1335392_1373088 n1_1373088_1373088 6.5968
R27-112-125 n1_1373088_1373088 n1_1412000_1373088 6.8096000000000005
R27-112-126 n1_1412000_1373088 n1_1449696_1373088 6.5968
R27-112-127 n1_1449696_1373088 n1_1487392_1373088 6.5968
R27-112-128 n1_1487392_1373088 n1_1526304_1373088 6.8096000000000005
R27-112-129 n1_1526304_1373088 n1_1564000_1373088 6.5968
R27-112-130 n1_1564000_1373088 n1_1602912_1373088 6.8096000000000005
R27-112-131 n1_1602912_1373088 n1_1641180_1373088 6.696899999999999
R27-112-132 n1_1641180_1373088 n1_1641290_1373088 0.01925
R27-113-100 n1_474686_1412000 n1_474796_1412000 0.01925
R27-113-101 n1_474796_1412000 n1_493920_1412000 17.4793
R27-113-102 n1_493920_1412000 n1_532832_1412000 6.8096000000000005
R27-113-103 n1_532832_1412000 n1_570528_1412000 6.5968
R27-113-104 n1_570528_1412000 n1_609440_1412000 6.8096000000000005
R27-113-105 n1_609440_1412000 n1_647136_1412000 6.5968
R27-113-106 n1_647136_1412000 n1_686048_1412000 6.8096000000000005
R27-113-107 n1_686048_1412000 n1_723744_1412000 6.5968
R27-113-108 n1_723744_1412000 n1_761440_1412000 6.5968
R27-113-109 n1_761440_1412000 n1_800352_1412000 6.8096000000000005
R27-113-110 n1_800352_1412000 n1_838048_1412000 6.5968
R27-113-111 n1_838048_1412000 n1_876960_1412000 6.8096000000000005
R27-113-112 n1_876960_1412000 n1_914656_1412000 6.5968
R27-113-113 n1_914656_1412000 n1_952352_1412000 6.5968
R27-113-114 n1_952352_1412000 n1_991264_1412000 6.8096000000000005
R27-113-115 n1_991264_1412000 n1_1028960_1412000 6.5968
R27-113-116 n1_1028960_1412000 n1_1067872_1412000 6.8096000000000005
R27-113-117 n1_1067872_1412000 n1_1105568_1412000 6.5968
R27-113-118 n1_1105568_1412000 n1_1144480_1412000 6.8096000000000005
R27-113-119 n1_1144480_1412000 n1_1182176_1412000 6.5968
R27-113-120 n1_1182176_1412000 n1_1219872_1412000 6.5968
R27-113-121 n1_1219872_1412000 n1_1258784_1412000 6.8096000000000005
R27-113-122 n1_1258784_1412000 n1_1296480_1412000 6.5968
R27-113-123 n1_1296480_1412000 n1_1335392_1412000 6.8096000000000005
R27-113-124 n1_1335392_1412000 n1_1373088_1412000 6.5968
R27-113-125 n1_1373088_1412000 n1_1412000_1412000 6.8096000000000005
R27-113-126 n1_1412000_1412000 n1_1449696_1412000 6.5968
R27-113-127 n1_1449696_1412000 n1_1487392_1412000 6.5968
R27-113-128 n1_1487392_1412000 n1_1526304_1412000 6.8096000000000005
R27-113-129 n1_1526304_1412000 n1_1564000_1412000 6.5968
R27-113-130 n1_1564000_1412000 n1_1602912_1412000 6.8096000000000005
R27-113-131 n1_1602912_1412000 n1_1641180_1412000 6.696899999999999
R27-113-132 n1_1641180_1412000 n1_1641290_1412000 0.01925
R27-114-100 n1_474686_1448480 n1_474796_1448480 0.01925
R27-114-101 n1_474796_1448480 n1_493920_1448480 3.3467
R27-114-102 n1_493920_1448480 n1_532832_1448480 6.8096
R27-114-103 n1_532832_1448480 n1_570528_1448480 17.5053
R27-114-104 n1_570528_1448480 n1_609440_1448480 18.6528
R27-114-105 n1_609440_1448480 n1_647136_1448480 6.5968
R27-114-106 n1_647136_1448480 n1_686048_1448480 6.8096000000000005
R27-114-107 n1_686048_1448480 n1_723744_1448480 6.5968
R27-114-108 n1_723744_1448480 n1_761440_1448480 6.5968
R27-114-109 n1_761440_1448480 n1_800352_1448480 6.8096000000000005
R27-114-110 n1_800352_1448480 n1_838048_1448480 6.5968
R27-114-111 n1_838048_1448480 n1_876960_1448480 6.8096000000000005
R27-114-112 n1_876960_1448480 n1_914656_1448480 6.5968
R27-114-113 n1_914656_1448480 n1_952352_1448480 6.5968
R27-114-114 n1_952352_1448480 n1_991264_1448480 6.8096000000000005
R27-114-115 n1_991264_1448480 n1_1028960_1448480 6.5968
R27-114-116 n1_1028960_1448480 n1_1067872_1448480 6.8096000000000005
R27-114-117 n1_1067872_1448480 n1_1105568_1448480 6.5968
R27-114-118 n1_1105568_1448480 n1_1144480_1448480 6.8096000000000005
R27-114-119 n1_1144480_1448480 n1_1182176_1448480 6.5968
R27-114-120 n1_1182176_1448480 n1_1219872_1448480 6.5968
R27-114-121 n1_1219872_1448480 n1_1258784_1448480 6.8096000000000005
R27-114-122 n1_1258784_1448480 n1_1296480_1448480 6.5968
R27-114-123 n1_1296480_1448480 n1_1335392_1448480 6.8096000000000005
R27-114-124 n1_1335392_1448480 n1_1373088_1448480 6.5968
R27-114-125 n1_1373088_1448480 n1_1412000_1448480 6.8096000000000005
R27-114-126 n1_1412000_1448480 n1_1449696_1448480 6.5968
R27-114-127 n1_1449696_1448480 n1_1487392_1448480 6.5968
R27-114-128 n1_1487392_1448480 n1_1526304_1448480 6.8096000000000005
R27-114-129 n1_1526304_1448480 n1_1564000_1448480 6.5968
R27-114-130 n1_1564000_1448480 n1_1602912_1448480 6.8096000000000005
R27-114-131 n1_1602912_1448480 n1_1641180_1448480 6.696899999999999
R27-114-132 n1_1641180_1448480 n1_1641290_1448480 0.01925
R27-115-100 n1_474686_1487392 n1_474796_1487392 0.01925
R27-115-101 n1_474796_1487392 n1_493920_1487392 3.3467
R27-115-102 n1_493920_1487392 n1_532832_1487392 6.8096000000000005
R27-115-103 n1_532832_1487392 n1_570528_1487392 6.5968
R27-115-104 n1_570528_1487392 n1_609440_1487392 18.9882
R27-115-105 n1_609440_1487392 n1_647136_1487392 6.5968
R27-115-106 n1_647136_1487392 n1_686048_1487392 6.8096000000000005
R27-115-107 n1_686048_1487392 n1_723744_1487392 6.5968
R27-115-108 n1_723744_1487392 n1_761440_1487392 6.5968
R27-115-109 n1_761440_1487392 n1_800352_1487392 6.8096000000000005
R27-115-110 n1_800352_1487392 n1_838048_1487392 6.5968
R27-115-111 n1_838048_1487392 n1_876960_1487392 6.8096000000000005
R27-115-112 n1_876960_1487392 n1_914656_1487392 6.5968
R27-115-113 n1_914656_1487392 n1_952352_1487392 6.5968
R27-115-114 n1_952352_1487392 n1_991264_1487392 6.8096000000000005
R27-115-115 n1_991264_1487392 n1_1028960_1487392 6.5968
R27-115-116 n1_1028960_1487392 n1_1067872_1487392 6.8096000000000005
R27-115-117 n1_1067872_1487392 n1_1105568_1487392 6.5968
R27-115-118 n1_1105568_1487392 n1_1144480_1487392 6.8096000000000005
R27-115-119 n1_1144480_1487392 n1_1182176_1487392 6.5968
R27-115-120 n1_1182176_1487392 n1_1219872_1487392 6.5968
R27-115-121 n1_1219872_1487392 n1_1258784_1487392 6.8096000000000005
R27-115-122 n1_1258784_1487392 n1_1296480_1487392 6.5968
R27-115-123 n1_1296480_1487392 n1_1335392_1487392 6.8096000000000005
R27-115-124 n1_1335392_1487392 n1_1373088_1487392 6.5968
R27-115-125 n1_1373088_1487392 n1_1412000_1487392 13.8559
R27-115-126 n1_1412000_1487392 n1_1449696_1487392 6.5968
R27-115-127 n1_1449696_1487392 n1_1487392_1487392 6.5968
R27-115-128 n1_1487392_1487392 n1_1526304_1487392 6.8096000000000005
R27-115-129 n1_1526304_1487392 n1_1564000_1487392 6.5968
R27-115-130 n1_1564000_1487392 n1_1602912_1487392 6.8096000000000005
R27-115-131 n1_1602912_1487392 n1_1641180_1487392 6.696899999999999
R27-115-132 n1_1641180_1487392 n1_1641290_1487392 0.01925
R27-116-100 n1_474686_1526304 n1_474796_1526304 0.01925
R27-116-101 n1_474796_1526304 n1_493920_1526304 3.3467
R27-116-102 n1_493920_1526304 n1_532832_1526304 6.8096000000000005
R27-116-103 n1_532832_1526304 n1_570528_1526304 6.5968
R27-116-104 n1_570528_1526304 n1_609440_1526304 17.6341
R27-116-105 n1_609440_1526304 n1_647136_1526304 6.5968
R27-116-106 n1_647136_1526304 n1_686048_1526304 6.8096000000000005
R27-116-107 n1_686048_1526304 n1_723744_1526304 6.5968
R27-116-108 n1_723744_1526304 n1_761440_1526304 6.5968
R27-116-109 n1_761440_1526304 n1_800352_1526304 6.8096000000000005
R27-116-110 n1_800352_1526304 n1_838048_1526304 6.5968
R27-116-111 n1_838048_1526304 n1_876960_1526304 6.8096000000000005
R27-116-112 n1_876960_1526304 n1_914656_1526304 6.5968
R27-116-113 n1_914656_1526304 n1_952352_1526304 6.5968
R27-116-114 n1_952352_1526304 n1_991264_1526304 6.8096000000000005
R27-116-115 n1_991264_1526304 n1_1028960_1526304 6.5968
R27-116-116 n1_1028960_1526304 n1_1067872_1526304 6.8096000000000005
R27-116-117 n1_1067872_1526304 n1_1105568_1526304 6.5968
R27-116-118 n1_1105568_1526304 n1_1144480_1526304 6.8096000000000005
R27-116-119 n1_1144480_1526304 n1_1182176_1526304 6.5968
R27-116-120 n1_1182176_1526304 n1_1219872_1526304 6.5968
R27-116-121 n1_1219872_1526304 n1_1258784_1526304 6.8096000000000005
R27-116-122 n1_1258784_1526304 n1_1296480_1526304 6.5968
R27-116-123 n1_1296480_1526304 n1_1335392_1526304 6.8096000000000005
R27-116-124 n1_1335392_1526304 n1_1373088_1526304 6.5968
R27-116-125 n1_1373088_1526304 n1_1412000_1526304 10.8284
R27-116-126 n1_1412000_1526304 n1_1449696_1526304 6.5968
R27-116-127 n1_1449696_1526304 n1_1487392_1526304 6.5968
R27-116-128 n1_1487392_1526304 n1_1526304_1526304 6.8096000000000005
R27-116-129 n1_1526304_1526304 n1_1564000_1526304 6.5968
R27-116-130 n1_1564000_1526304 n1_1602912_1526304 6.8096000000000005
R27-116-131 n1_1602912_1526304 n1_1641180_1526304 6.696899999999999
R27-116-132 n1_1641180_1526304 n1_1641290_1526304 0.01925
R27-117-100 n1_474686_1562784 n1_474796_1562784 0.01925
R27-117-101 n1_474796_1562784 n1_493920_1562784 3.3467
R27-117-102 n1_493920_1562784 n1_532832_1562784 6.8096000000000005
R27-117-103 n1_532832_1562784 n1_570528_1562784 6.5968
R27-117-104 n1_570528_1562784 n1_609440_1562784 19.0728
R27-117-105 n1_609440_1562784 n1_647136_1562784 6.5968
R27-117-106 n1_647136_1562784 n1_686048_1562784 6.8096000000000005
R27-117-107 n1_686048_1562784 n1_723744_1562784 6.5968
R27-117-108 n1_723744_1562784 n1_761440_1562784 6.5968
R27-117-109 n1_761440_1562784 n1_800352_1562784 6.8096000000000005
R27-117-110 n1_800352_1562784 n1_838048_1562784 6.5968
R27-117-111 n1_838048_1562784 n1_876960_1562784 6.8096000000000005
R27-117-112 n1_876960_1562784 n1_914656_1562784 6.5968
R27-117-113 n1_914656_1562784 n1_952352_1562784 6.5968
R27-117-114 n1_952352_1562784 n1_991264_1562784 6.8096000000000005
R27-117-115 n1_991264_1562784 n1_1028960_1562784 6.5968
R27-117-116 n1_1028960_1562784 n1_1067872_1562784 6.8096000000000005
R27-117-117 n1_1067872_1562784 n1_1105568_1562784 6.5968
R27-117-118 n1_1105568_1562784 n1_1144480_1562784 6.8096000000000005
R27-117-119 n1_1144480_1562784 n1_1182176_1562784 6.5968
R27-117-120 n1_1182176_1562784 n1_1219872_1562784 6.5968
R27-117-121 n1_1219872_1562784 n1_1258784_1562784 6.8096000000000005
R27-117-122 n1_1258784_1562784 n1_1296480_1562784 6.5968
R27-117-123 n1_1296480_1562784 n1_1335392_1562784 6.8096000000000005
R27-117-124 n1_1335392_1562784 n1_1373088_1562784 6.5968
R27-117-125 n1_1373088_1562784 n1_1412000_1562784 11.3538
R27-117-126 n1_1412000_1562784 n1_1449696_1562784 6.5968
R27-117-127 n1_1449696_1562784 n1_1487392_1562784 6.5968
R27-117-128 n1_1487392_1562784 n1_1526304_1562784 6.8096000000000005
R27-117-129 n1_1526304_1562784 n1_1564000_1562784 6.5968
R27-117-130 n1_1564000_1562784 n1_1602912_1562784 6.8096000000000005
R27-117-131 n1_1602912_1562784 n1_1641180_1562784 6.696899999999999
R27-117-132 n1_1641180_1562784 n1_1641290_1562784 0.01925
R27-118-100 n1_474686_1601696 n1_474796_1601696 0.01925
R27-118-101 n1_474796_1601696 n1_493920_1601696 3.3467
R27-118-102 n1_493920_1601696 n1_532832_1601696 6.8096000000000005
R27-118-103 n1_532832_1601696 n1_570528_1601696 6.6069
R27-118-104 n1_570528_1601696 n1_609440_1601696 18.0665
R27-118-105 n1_609440_1601696 n1_647136_1601696 6.5968
R27-118-106 n1_647136_1601696 n1_686048_1601696 6.8096000000000005
R27-118-107 n1_686048_1601696 n1_723744_1601696 6.5968
R27-118-108 n1_723744_1601696 n1_761440_1601696 6.5968
R27-118-109 n1_761440_1601696 n1_800352_1601696 6.8096000000000005
R27-118-110 n1_800352_1601696 n1_838048_1601696 6.5968
R27-118-111 n1_838048_1601696 n1_876960_1601696 6.8096000000000005
R27-118-112 n1_876960_1601696 n1_914656_1601696 6.5968
R27-118-113 n1_914656_1601696 n1_952352_1601696 6.5968
R27-118-114 n1_952352_1601696 n1_991264_1601696 6.8096000000000005
R27-118-115 n1_991264_1601696 n1_1028960_1601696 6.5968
R27-118-116 n1_1028960_1601696 n1_1067872_1601696 6.8096000000000005
R27-118-117 n1_1067872_1601696 n1_1105568_1601696 6.5968
R27-118-118 n1_1105568_1601696 n1_1144480_1601696 6.8096000000000005
R27-118-119 n1_1144480_1601696 n1_1182176_1601696 6.5968
R27-118-120 n1_1182176_1601696 n1_1219872_1601696 6.5968
R27-118-121 n1_1219872_1601696 n1_1258784_1601696 6.8096000000000005
R27-118-122 n1_1258784_1601696 n1_1296480_1601696 6.5968
R27-118-123 n1_1296480_1601696 n1_1335392_1601696 6.8096000000000005
R27-118-124 n1_1335392_1601696 n1_1373088_1601696 6.5968
R27-118-125 n1_1373088_1601696 n1_1412000_1601696 6.8096000000000005
R27-118-126 n1_1412000_1601696 n1_1449696_1601696 6.5968
R27-118-127 n1_1449696_1601696 n1_1487392_1601696 6.5968
R27-118-128 n1_1487392_1601696 n1_1526304_1601696 6.8096000000000005
R27-118-129 n1_1526304_1601696 n1_1564000_1601696 6.5968
R27-118-130 n1_1564000_1601696 n1_1602912_1601696 6.8096000000000005
R27-118-131 n1_1602912_1601696 n1_1641180_1601696 6.696899999999999
R27-118-132 n1_1641180_1601696 n1_1641290_1601696 0.01925
R27-119-100 n1_474686_1641130 n1_474796_1641130 0.009625
R27-119-101 n1_474796_1641130 n1_493920_1641130 1.67335
R27-119-102 n1_493920_1641130 n1_532832_1641130 3.4048000000000003
R27-119-103 n1_532832_1641130 n1_570528_1641130 3.2984
R27-119-104 n1_570528_1641130 n1_609440_1641130 3.4048000000000003
R27-119-105 n1_609440_1641130 n1_647136_1641130 3.2984
R27-119-106 n1_647136_1641130 n1_686048_1641130 3.4048000000000003
R27-119-107 n1_686048_1641130 n1_723744_1641130 3.2984
R27-119-108 n1_723744_1641130 n1_761440_1641130 3.2984
R27-119-109 n1_761440_1641130 n1_800352_1641130 3.4048000000000003
R27-119-110 n1_800352_1641130 n1_838048_1641130 3.2984
R27-119-111 n1_838048_1641130 n1_876960_1641130 3.4048000000000003
R27-119-112 n1_876960_1641130 n1_914656_1641130 3.2984
R27-119-113 n1_914656_1641130 n1_952352_1641130 3.2984
R27-119-114 n1_952352_1641130 n1_979937_1641130 2.41369
R27-119-115 n1_979937_1641130 n1_991264_1641130 0.991113
R27-119-116 n1_991264_1641130 n1_1028960_1641130 3.2984
R27-119-117 n1_1028960_1641130 n1_1067872_1641130 3.4048000000000003
R27-119-118 n1_1067872_1641130 n1_1105568_1641130 3.2984
R27-119-119 n1_1105568_1641130 n1_1144480_1641130 3.4048000000000003
R27-119-120 n1_1144480_1641130 n1_1182176_1641130 3.2984
R27-119-121 n1_1182176_1641130 n1_1219872_1641130 3.2984
R27-119-122 n1_1219872_1641130 n1_1258784_1641130 3.4048000000000003
R27-119-123 n1_1258784_1641130 n1_1296480_1641130 3.2984
R27-119-124 n1_1296480_1641130 n1_1335392_1641130 3.4048000000000003
R27-119-125 n1_1335392_1641130 n1_1373088_1641130 3.2984
R27-119-126 n1_1373088_1641130 n1_1412000_1641130 3.4048000000000003
R27-119-127 n1_1412000_1641130 n1_1449696_1641130 3.2984
R27-119-128 n1_1449696_1641130 n1_1487392_1641130 3.2984
R27-119-129 n1_1487392_1641130 n1_1526304_1641130 3.4048000000000003
R27-119-130 n1_1526304_1641130 n1_1564000_1641130 3.2984
R27-119-131 n1_1564000_1641130 n1_1602912_1641130 3.4048000000000003
R27-119-132 n1_1602912_1641130 n1_1641180_1641130 3.3484499999999997
R27-119-133 n1_1641180_1641130 n1_1641290_1641130 0.009625
R27-120-100 n1_1641070_1619905 n1_1641180_1619905 0.0162105
R27-120-101 n1_1641180_1619905 n1_1820088_1619905 26.3654
R27-120-102 n1_1820088_1619905 n1_1825088_1619905 0.736842
R27-121-100 n1_474686_918304 n1_474796_918304 0.01925
R27-121-101 n1_474796_918304 n1_493920_918304 125.1571
R27-121-102 n1_493920_918304 n1_532832_918304 124.3589
R27-121-103 n1_532832_918304 n1_570528_918304 87.031
R27-121-104 n1_570528_918304 n1_609440_918304 6.8096000000000005
R27-121-105 n1_609440_918304 n1_647136_918304 6.5968
R27-121-106 n1_647136_918304 n1_686048_918304 6.8096000000000005
R27-121-107 n1_686048_918304 n1_723744_918304 6.5968
R27-121-108 n1_723744_918304 n1_761440_918304 6.5968
R27-121-109 n1_761440_918304 n1_800352_918304 6.8096000000000005
R27-121-110 n1_800352_918304 n1_838048_918304 6.5968
R27-121-111 n1_838048_918304 n1_876960_918304 6.8096000000000005
R27-121-112 n1_876960_918304 n1_914656_918304 6.5968
R27-121-113 n1_914656_918304 n1_952352_918304 6.5968
R27-121-114 n1_952352_918304 n1_991264_918304 6.8096000000000005
R27-121-115 n1_991264_918304 n1_1028960_918304 6.5968
R27-121-116 n1_1028960_918304 n1_1067872_918304 6.8096000000000005
R27-121-117 n1_1067872_918304 n1_1105568_918304 6.5968
R27-121-118 n1_1105568_918304 n1_1144480_918304 6.8096000000000005
R27-121-119 n1_1144480_918304 n1_1182176_918304 6.5968
R27-121-120 n1_1182176_918304 n1_1219872_918304 6.5968
R27-121-121 n1_1219872_918304 n1_1258784_918304 6.8096000000000005
R27-121-122 n1_1258784_918304 n1_1296480_918304 6.5968
R27-121-123 n1_1296480_918304 n1_1335392_918304 6.8096000000000005
R27-121-124 n1_1335392_918304 n1_1373088_918304 6.5968
R27-121-125 n1_1373088_918304 n1_1412000_918304 6.8096000000000005
R27-121-126 n1_1412000_918304 n1_1449696_918304 6.5968
R27-121-127 n1_1449696_918304 n1_1487392_918304 6.5968
R27-121-128 n1_1487392_918304 n1_1526304_918304 6.8096000000000005
R27-121-129 n1_1526304_918304 n1_1564000_918304 6.5968
R27-121-130 n1_1564000_918304 n1_1602912_918304 6.8096000000000005
R27-121-131 n1_1602912_918304 n1_1641180_918304 178.8158
R27-121-132 n1_1641180_918304 n1_1641290_918304 0.01925
R27-122-100 n1_474686_881824 n1_474796_881824 0.020069
R27-122-101 n1_474796_881824 n1_493920_881824 310.948
R27-122-102 n1_493920_881824 n1_532832_881824 22.6233
R27-122-103 n1_532832_881824 n1_570528_881824 6.5968
R27-122-104 n1_570528_881824 n1_609440_881824 6.8096000000000005
R27-122-105 n1_609440_881824 n1_647136_881824 6.5968
R27-122-106 n1_647136_881824 n1_686048_881824 6.8096000000000005
R27-122-107 n1_686048_881824 n1_723744_881824 6.5968
R27-122-108 n1_723744_881824 n1_761440_881824 6.5968
R27-122-109 n1_761440_881824 n1_800352_881824 6.8096000000000005
R27-122-110 n1_800352_881824 n1_838048_881824 6.5968
R27-122-111 n1_838048_881824 n1_876960_881824 6.8096000000000005
R27-122-112 n1_876960_881824 n1_914656_881824 6.5968
R27-122-113 n1_914656_881824 n1_952352_881824 6.5968
R27-122-114 n1_952352_881824 n1_991264_881824 6.8096000000000005
R27-122-115 n1_991264_881824 n1_1028960_881824 6.5968
R27-122-116 n1_1028960_881824 n1_1067872_881824 6.8096000000000005
R27-122-117 n1_1067872_881824 n1_1105568_881824 6.5968
R27-122-118 n1_1105568_881824 n1_1144480_881824 6.8096000000000005
R27-122-119 n1_1144480_881824 n1_1182176_881824 6.5968
R27-122-120 n1_1182176_881824 n1_1219872_881824 6.5968
R27-122-121 n1_1219872_881824 n1_1258784_881824 6.8096000000000005
R27-122-122 n1_1258784_881824 n1_1296480_881824 6.5968
R27-122-123 n1_1296480_881824 n1_1335392_881824 6.8096000000000005
R27-122-124 n1_1335392_881824 n1_1373088_881824 6.5968
R27-122-125 n1_1373088_881824 n1_1412000_881824 6.8096000000000005
R27-122-126 n1_1412000_881824 n1_1449696_881824 6.5968
R27-122-127 n1_1449696_881824 n1_1487392_881824 6.5968
R27-122-128 n1_1487392_881824 n1_1526304_881824 6.8096000000000005
R27-122-129 n1_1526304_881824 n1_1564000_881824 6.5968
R27-122-130 n1_1564000_881824 n1_1602912_881824 6.8096000000000005
R27-122-131 n1_1602912_881824 n1_1641180_881824 72.7905
R27-122-132 n1_1641180_881824 n1_1641290_881824 0.01925
R27-123-100 n1_474686_842912 n1_474796_842912 0.01925
R27-123-101 n1_474796_842912 n1_493920_842912 49.5087
R27-123-102 n1_493920_842912 n1_532832_842912 6.8096000000000005
R27-123-103 n1_532832_842912 n1_570528_842912 6.5968
R27-123-104 n1_570528_842912 n1_609440_842912 6.8096000000000005
R27-123-105 n1_609440_842912 n1_647136_842912 6.5968
R27-123-106 n1_647136_842912 n1_686048_842912 6.8096000000000005
R27-123-107 n1_686048_842912 n1_723744_842912 6.5968
R27-123-108 n1_723744_842912 n1_761440_842912 6.5968
R27-123-109 n1_761440_842912 n1_800352_842912 6.8096000000000005
R27-123-110 n1_800352_842912 n1_838048_842912 6.5968
R27-123-111 n1_838048_842912 n1_876960_842912 6.8096000000000005
R27-123-112 n1_876960_842912 n1_914656_842912 6.5968
R27-123-113 n1_914656_842912 n1_952352_842912 6.5968
R27-123-114 n1_952352_842912 n1_991264_842912 6.8096000000000005
R27-123-115 n1_991264_842912 n1_1028960_842912 6.5968
R27-123-116 n1_1028960_842912 n1_1067872_842912 6.8096000000000005
R27-123-117 n1_1067872_842912 n1_1105568_842912 6.5968
R27-123-118 n1_1105568_842912 n1_1144480_842912 6.8096000000000005
R27-123-119 n1_1144480_842912 n1_1182176_842912 6.5968
R27-123-120 n1_1182176_842912 n1_1219872_842912 6.5968
R27-123-121 n1_1219872_842912 n1_1258784_842912 6.8096000000000005
R27-123-122 n1_1258784_842912 n1_1296480_842912 6.5968
R27-123-123 n1_1296480_842912 n1_1335392_842912 6.8096000000000005
R27-123-124 n1_1335392_842912 n1_1373088_842912 6.5968
R27-123-125 n1_1373088_842912 n1_1412000_842912 6.8096000000000005
R27-123-126 n1_1412000_842912 n1_1449696_842912 6.5968
R27-123-127 n1_1449696_842912 n1_1487392_842912 6.5968
R27-123-128 n1_1487392_842912 n1_1526304_842912 6.8096000000000005
R27-123-129 n1_1526304_842912 n1_1564000_842912 6.5968
R27-123-130 n1_1564000_842912 n1_1602912_842912 6.8096000000000005
R27-123-131 n1_1602912_842912 n1_1641180_842912 467.2156
R27-123-132 n1_1641180_842912 n1_1641290_842912 0.020803
R27-124-100 n1_474686_804000 n1_474796_804000 0.01925
R27-124-101 n1_474796_804000 n1_493920_804000 51.8514
R27-124-102 n1_493920_804000 n1_532832_804000 6.8096000000000005
R27-124-103 n1_532832_804000 n1_570528_804000 6.5968
R27-124-104 n1_570528_804000 n1_609440_804000 6.8096000000000005
R27-124-105 n1_609440_804000 n1_647136_804000 6.5968
R27-124-106 n1_647136_804000 n1_686048_804000 6.8096000000000005
R27-124-107 n1_686048_804000 n1_723744_804000 6.5968
R27-124-108 n1_723744_804000 n1_761440_804000 6.5968
R27-124-109 n1_761440_804000 n1_800352_804000 6.8096000000000005
R27-124-110 n1_800352_804000 n1_838048_804000 6.5968
R27-124-111 n1_838048_804000 n1_876960_804000 6.8096000000000005
R27-124-112 n1_876960_804000 n1_914656_804000 6.5968
R27-124-113 n1_914656_804000 n1_952352_804000 6.5968
R27-124-114 n1_952352_804000 n1_991264_804000 6.8096000000000005
R27-124-115 n1_991264_804000 n1_1028960_804000 6.5968
R27-124-116 n1_1028960_804000 n1_1067872_804000 6.8096000000000005
R27-124-117 n1_1067872_804000 n1_1105568_804000 6.5968
R27-124-118 n1_1105568_804000 n1_1144480_804000 6.8096000000000005
R27-124-119 n1_1144480_804000 n1_1182176_804000 6.5968
R27-124-120 n1_1182176_804000 n1_1219872_804000 6.5968
R27-124-121 n1_1219872_804000 n1_1258784_804000 6.8096000000000005
R27-124-122 n1_1258784_804000 n1_1296480_804000 6.5968
R27-124-123 n1_1296480_804000 n1_1335392_804000 6.8096000000000005
R27-124-124 n1_1335392_804000 n1_1373088_804000 6.5968
R27-124-125 n1_1373088_804000 n1_1412000_804000 6.8096000000000005
R27-124-126 n1_1412000_804000 n1_1449696_804000 6.5968
R27-124-127 n1_1449696_804000 n1_1487392_804000 6.5968
R27-124-128 n1_1487392_804000 n1_1526304_804000 6.8096000000000005
R27-124-129 n1_1526304_804000 n1_1564000_804000 6.5968
R27-124-130 n1_1564000_804000 n1_1602912_804000 6.8096000000000005
R27-124-131 n1_1602912_804000 n1_1641180_804000 419.1487
R27-124-132 n1_1641180_804000 n1_1641290_804000 0.020691
R27-125-100 n1_474686_767520 n1_474796_767520 0.01925
R27-125-101 n1_474796_767520 n1_493920_767520 52.1898
R27-125-102 n1_493920_767520 n1_532832_767520 6.8096000000000005
R27-125-103 n1_532832_767520 n1_570528_767520 6.5968
R27-125-104 n1_570528_767520 n1_609440_767520 6.8096000000000005
R27-125-105 n1_609440_767520 n1_647136_767520 6.5968
R27-125-106 n1_647136_767520 n1_686048_767520 6.8096000000000005
R27-125-107 n1_686048_767520 n1_723744_767520 6.5968
R27-125-108 n1_723744_767520 n1_761440_767520 6.5968
R27-125-109 n1_761440_767520 n1_800352_767520 6.8096000000000005
R27-125-110 n1_800352_767520 n1_838048_767520 6.5968
R27-125-111 n1_838048_767520 n1_876960_767520 6.8096000000000005
R27-125-112 n1_876960_767520 n1_914656_767520 6.5968
R27-125-113 n1_914656_767520 n1_952352_767520 6.5968
R27-125-114 n1_952352_767520 n1_991264_767520 6.8096000000000005
R27-125-115 n1_991264_767520 n1_1028960_767520 6.5968
R27-125-116 n1_1028960_767520 n1_1067872_767520 6.8096000000000005
R27-125-117 n1_1067872_767520 n1_1105568_767520 6.5968
R27-125-118 n1_1105568_767520 n1_1144480_767520 6.8096000000000005
R27-125-119 n1_1144480_767520 n1_1182176_767520 6.5968
R27-125-120 n1_1182176_767520 n1_1219872_767520 6.5968
R27-125-121 n1_1219872_767520 n1_1258784_767520 6.8096000000000005
R27-125-122 n1_1258784_767520 n1_1296480_767520 6.5968
R27-125-123 n1_1296480_767520 n1_1335392_767520 6.8096000000000005
R27-125-124 n1_1335392_767520 n1_1373088_767520 6.5968
R27-125-125 n1_1373088_767520 n1_1412000_767520 6.8096000000000005
R27-125-126 n1_1412000_767520 n1_1449696_767520 6.5968
R27-125-127 n1_1449696_767520 n1_1487392_767520 6.5968
R27-125-128 n1_1487392_767520 n1_1526304_767520 6.8096000000000005
R27-125-129 n1_1526304_767520 n1_1564000_767520 6.5968
R27-125-130 n1_1564000_767520 n1_1602912_767520 6.8096000000000005
R27-125-131 n1_1602912_767520 n1_1641180_767520 419.659
R27-125-132 n1_1641180_767520 n1_1641290_767520 0.02074
R27-126-100 n1_474686_728608 n1_474796_728608 0.01925
R27-126-101 n1_474796_728608 n1_493920_728608 50.7316
R27-126-102 n1_493920_728608 n1_532832_728608 6.8096000000000005
R27-126-103 n1_532832_728608 n1_570528_728608 6.5968
R27-126-104 n1_570528_728608 n1_609440_728608 6.8096000000000005
R27-126-105 n1_609440_728608 n1_647136_728608 6.5968
R27-126-106 n1_647136_728608 n1_686048_728608 6.8096000000000005
R27-126-107 n1_686048_728608 n1_723744_728608 6.5968
R27-126-108 n1_723744_728608 n1_761440_728608 6.5968
R27-126-109 n1_761440_728608 n1_800352_728608 6.8096000000000005
R27-126-110 n1_800352_728608 n1_838048_728608 6.5968
R27-126-111 n1_838048_728608 n1_876960_728608 6.8096000000000005
R27-126-112 n1_876960_728608 n1_914656_728608 6.5968
R27-126-113 n1_914656_728608 n1_952352_728608 6.5968
R27-126-114 n1_952352_728608 n1_991264_728608 6.8096000000000005
R27-126-115 n1_991264_728608 n1_1028960_728608 6.5968
R27-126-116 n1_1028960_728608 n1_1067872_728608 6.8096000000000005
R27-126-117 n1_1067872_728608 n1_1105568_728608 6.5968
R27-126-118 n1_1105568_728608 n1_1144480_728608 6.8096000000000005
R27-126-119 n1_1144480_728608 n1_1182176_728608 6.5968
R27-126-120 n1_1182176_728608 n1_1219872_728608 6.5968
R27-126-121 n1_1219872_728608 n1_1258784_728608 6.8096000000000005
R27-126-122 n1_1258784_728608 n1_1296480_728608 6.5968
R27-126-123 n1_1296480_728608 n1_1335392_728608 6.8096000000000005
R27-126-124 n1_1335392_728608 n1_1373088_728608 6.5968
R27-126-125 n1_1373088_728608 n1_1412000_728608 6.8096000000000005
R27-126-126 n1_1412000_728608 n1_1449696_728608 6.5968
R27-126-127 n1_1449696_728608 n1_1487392_728608 6.5968
R27-126-128 n1_1487392_728608 n1_1526304_728608 6.8096000000000005
R27-126-129 n1_1526304_728608 n1_1564000_728608 6.5968
R27-126-130 n1_1564000_728608 n1_1602912_728608 6.8096000000000005
R27-126-131 n1_1602912_728608 n1_1641180_728608 424.224
R27-126-132 n1_1641180_728608 n1_1641290_728608 0.020781
R27-127-100 n1_474686_692128 n1_474796_692128 0.01925
R27-127-101 n1_474796_692128 n1_493920_692128 48.8197
R27-127-102 n1_493920_692128 n1_532832_692128 6.8096000000000005
R27-127-103 n1_532832_692128 n1_570528_692128 6.5968
R27-127-104 n1_570528_692128 n1_609440_692128 6.8096000000000005
R27-127-105 n1_609440_692128 n1_647136_692128 6.5968
R27-127-106 n1_647136_692128 n1_686048_692128 6.8096000000000005
R27-127-107 n1_686048_692128 n1_723744_692128 6.5968
R27-127-108 n1_723744_692128 n1_761440_692128 6.5968
R27-127-109 n1_761440_692128 n1_800352_692128 6.8096000000000005
R27-127-110 n1_800352_692128 n1_838048_692128 6.5968
R27-127-111 n1_838048_692128 n1_876960_692128 6.8096000000000005
R27-127-112 n1_876960_692128 n1_914656_692128 6.5968
R27-127-113 n1_914656_692128 n1_952352_692128 6.5968
R27-127-114 n1_952352_692128 n1_991264_692128 6.8096000000000005
R27-127-115 n1_991264_692128 n1_1028960_692128 6.5968
R27-127-116 n1_1028960_692128 n1_1067872_692128 6.8096000000000005
R27-127-117 n1_1067872_692128 n1_1105568_692128 6.5968
R27-127-118 n1_1105568_692128 n1_1144480_692128 6.8096000000000005
R27-127-119 n1_1144480_692128 n1_1182176_692128 6.5968
R27-127-120 n1_1182176_692128 n1_1219872_692128 6.5968
R27-127-121 n1_1219872_692128 n1_1258784_692128 6.8096000000000005
R27-127-122 n1_1258784_692128 n1_1296480_692128 6.5968
R27-127-123 n1_1296480_692128 n1_1335392_692128 6.8096000000000005
R27-127-124 n1_1335392_692128 n1_1373088_692128 6.5968
R27-127-125 n1_1373088_692128 n1_1412000_692128 6.8096000000000005
R27-127-126 n1_1412000_692128 n1_1449696_692128 6.5968
R27-127-127 n1_1449696_692128 n1_1487392_692128 6.5968
R27-127-128 n1_1487392_692128 n1_1526304_692128 6.8096000000000005
R27-127-129 n1_1526304_692128 n1_1564000_692128 6.5968
R27-127-130 n1_1564000_692128 n1_1602912_692128 6.8096000000000005
R27-127-131 n1_1602912_692128 n1_1641180_692128 424.932
R27-127-132 n1_1641180_692128 n1_1641290_692128 0.020804
R27-128-100 n1_474686_653216 n1_474796_653216 0.01925
R27-128-101 n1_474796_653216 n1_493920_653216 118.2888
R27-128-102 n1_493920_653216 n1_532832_653216 112.5122
R27-128-103 n1_532832_653216 n1_570528_653216 80.4967
R27-128-104 n1_570528_653216 n1_609440_653216 6.8096000000000005
R27-128-105 n1_609440_653216 n1_647136_653216 6.5968
R27-128-106 n1_647136_653216 n1_686048_653216 6.8096000000000005
R27-128-107 n1_686048_653216 n1_723744_653216 6.5968
R27-128-108 n1_723744_653216 n1_761440_653216 6.5968
R27-128-109 n1_761440_653216 n1_800352_653216 6.8096000000000005
R27-128-110 n1_800352_653216 n1_838048_653216 6.5968
R27-128-111 n1_838048_653216 n1_876960_653216 6.8096000000000005
R27-128-112 n1_876960_653216 n1_914656_653216 6.5968
R27-128-113 n1_914656_653216 n1_952352_653216 6.5968
R27-128-114 n1_952352_653216 n1_991264_653216 6.8096000000000005
R27-128-115 n1_991264_653216 n1_1028960_653216 6.5968
R27-128-116 n1_1028960_653216 n1_1067872_653216 6.8096000000000005
R27-128-117 n1_1067872_653216 n1_1105568_653216 6.5968
R27-128-118 n1_1105568_653216 n1_1144480_653216 6.8096000000000005
R27-128-119 n1_1144480_653216 n1_1182176_653216 6.5968
R27-128-120 n1_1182176_653216 n1_1219872_653216 6.5968
R27-128-121 n1_1219872_653216 n1_1258784_653216 6.8096000000000005
R27-128-122 n1_1258784_653216 n1_1296480_653216 6.5968
R27-128-123 n1_1296480_653216 n1_1335392_653216 6.8096000000000005
R27-128-124 n1_1335392_653216 n1_1373088_653216 6.5968
R27-128-125 n1_1373088_653216 n1_1412000_653216 6.8096000000000005
R27-128-126 n1_1412000_653216 n1_1449696_653216 6.5968
R27-128-127 n1_1449696_653216 n1_1487392_653216 6.5968
R27-128-128 n1_1487392_653216 n1_1526304_653216 6.8096000000000005
R27-128-129 n1_1526304_653216 n1_1564000_653216 6.5968
R27-128-130 n1_1564000_653216 n1_1602912_653216 6.8096000000000005
R27-128-131 n1_1602912_653216 n1_1641180_653216 548.1522
R27-128-132 n1_1641180_653216 n1_1641290_653216 0.020827
R27-129-100 n1_474686_614304 n1_474796_614304 0.01925
R27-129-101 n1_474796_614304 n1_493920_614304 87.4394
R27-129-102 n1_493920_614304 n1_532832_614304 81.8178
R27-129-103 n1_532832_614304 n1_570528_614304 62.3319
R27-129-104 n1_570528_614304 n1_609440_614304 6.8096000000000005
R27-129-105 n1_609440_614304 n1_647136_614304 6.5968
R27-129-106 n1_647136_614304 n1_686048_614304 6.8096000000000005
R27-129-107 n1_686048_614304 n1_723744_614304 6.5968
R27-129-108 n1_723744_614304 n1_761440_614304 6.5968
R27-129-109 n1_761440_614304 n1_800352_614304 6.8096000000000005
R27-129-110 n1_800352_614304 n1_838048_614304 6.5968
R27-129-111 n1_838048_614304 n1_876960_614304 6.8096000000000005
R27-129-112 n1_876960_614304 n1_914656_614304 6.5968
R27-129-113 n1_914656_614304 n1_952352_614304 6.5968
R27-129-114 n1_952352_614304 n1_991264_614304 6.8096000000000005
R27-129-115 n1_991264_614304 n1_1028960_614304 6.5968
R27-129-116 n1_1028960_614304 n1_1067872_614304 6.8096000000000005
R27-129-117 n1_1067872_614304 n1_1105568_614304 6.5968
R27-129-118 n1_1105568_614304 n1_1144480_614304 6.8096000000000005
R27-129-119 n1_1144480_614304 n1_1182176_614304 6.5968
R27-129-120 n1_1182176_614304 n1_1219872_614304 6.5968
R27-129-121 n1_1219872_614304 n1_1258784_614304 6.8096000000000005
R27-129-122 n1_1258784_614304 n1_1296480_614304 6.5968
R27-129-123 n1_1296480_614304 n1_1335392_614304 6.8096000000000005
R27-129-124 n1_1335392_614304 n1_1373088_614304 6.5968
R27-129-125 n1_1373088_614304 n1_1412000_614304 6.8096000000000005
R27-129-126 n1_1412000_614304 n1_1449696_614304 6.5968
R27-129-127 n1_1449696_614304 n1_1487392_614304 6.5968
R27-129-128 n1_1487392_614304 n1_1526304_614304 6.8096000000000005
R27-129-129 n1_1526304_614304 n1_1564000_614304 6.5968
R27-129-130 n1_1564000_614304 n1_1602912_614304 6.8096000000000005
R27-129-131 n1_1602912_614304 n1_1641180_614304 542.7027
R27-129-132 n1_1641180_614304 n1_1641290_614304 0.020835
R27-130-100 n1_474686_577824 n1_474796_577824 0.01925
R27-130-101 n1_474796_577824 n1_493920_577824 121.6898
R27-130-102 n1_493920_577824 n1_532832_577824 6.8096000000000005
R27-130-103 n1_532832_577824 n1_570528_577824 6.5968
R27-130-104 n1_570528_577824 n1_609440_577824 6.8096000000000005
R27-130-105 n1_609440_577824 n1_647136_577824 6.5968
R27-130-106 n1_647136_577824 n1_686048_577824 6.8096000000000005
R27-130-107 n1_686048_577824 n1_723744_577824 6.5968
R27-130-108 n1_723744_577824 n1_761440_577824 6.5968
R27-130-109 n1_761440_577824 n1_800352_577824 6.8096000000000005
R27-130-110 n1_800352_577824 n1_838048_577824 6.5968
R27-130-111 n1_838048_577824 n1_876960_577824 6.8096000000000005
R27-130-112 n1_876960_577824 n1_914656_577824 6.5968
R27-130-113 n1_914656_577824 n1_952352_577824 6.5968
R27-130-114 n1_952352_577824 n1_991264_577824 6.8096000000000005
R27-130-115 n1_991264_577824 n1_1028960_577824 6.5968
R27-130-116 n1_1028960_577824 n1_1067872_577824 6.8096000000000005
R27-130-117 n1_1067872_577824 n1_1105568_577824 6.5968
R27-130-118 n1_1105568_577824 n1_1144480_577824 6.8096000000000005
R27-130-119 n1_1144480_577824 n1_1182176_577824 6.5968
R27-130-120 n1_1182176_577824 n1_1219872_577824 6.5968
R27-130-121 n1_1219872_577824 n1_1258784_577824 6.8096000000000005
R27-130-122 n1_1258784_577824 n1_1296480_577824 6.5968
R27-130-123 n1_1296480_577824 n1_1335392_577824 6.8096000000000005
R27-130-124 n1_1335392_577824 n1_1373088_577824 6.5968
R27-130-125 n1_1373088_577824 n1_1412000_577824 6.8096000000000005
R27-130-126 n1_1412000_577824 n1_1449696_577824 6.5968
R27-130-127 n1_1449696_577824 n1_1487392_577824 50.4184
R27-130-128 n1_1487392_577824 n1_1526304_577824 80.0314
R27-130-129 n1_1526304_577824 n1_1564000_577824 82.8416
R27-130-130 n1_1564000_577824 n1_1602912_577824 6.8096
R27-130-131 n1_1602912_577824 n1_1641180_577824 551.3566
R27-130-132 n1_1641180_577824 n1_1641290_577824 0.020808
R27-131-100 n1_474686_538912 n1_474796_538912 0.01925
R27-131-101 n1_474796_538912 n1_493920_538912 111.9316
R27-131-102 n1_493920_538912 n1_532832_538912 6.8096000000000005
R27-131-103 n1_532832_538912 n1_570528_538912 6.5968
R27-131-104 n1_570528_538912 n1_609440_538912 6.8096000000000005
R27-131-105 n1_609440_538912 n1_647136_538912 6.5968
R27-131-106 n1_647136_538912 n1_686048_538912 6.8096000000000005
R27-131-107 n1_686048_538912 n1_723744_538912 6.5968
R27-131-108 n1_723744_538912 n1_761440_538912 6.5968
R27-131-109 n1_761440_538912 n1_800352_538912 6.8096000000000005
R27-131-110 n1_800352_538912 n1_838048_538912 6.5968
R27-131-111 n1_838048_538912 n1_876960_538912 6.8096000000000005
R27-131-112 n1_876960_538912 n1_914656_538912 6.5968
R27-131-113 n1_914656_538912 n1_952352_538912 6.5968
R27-131-114 n1_952352_538912 n1_991264_538912 6.8096000000000005
R27-131-115 n1_991264_538912 n1_1028960_538912 6.5968
R27-131-116 n1_1028960_538912 n1_1067872_538912 6.8096000000000005
R27-131-117 n1_1067872_538912 n1_1105568_538912 6.5968
R27-131-118 n1_1105568_538912 n1_1144480_538912 6.8096000000000005
R27-131-119 n1_1144480_538912 n1_1182176_538912 6.5968
R27-131-120 n1_1182176_538912 n1_1219872_538912 6.5968
R27-131-121 n1_1219872_538912 n1_1258784_538912 6.8096000000000005
R27-131-122 n1_1258784_538912 n1_1296480_538912 6.5968
R27-131-123 n1_1296480_538912 n1_1335392_538912 6.8096000000000005
R27-131-124 n1_1335392_538912 n1_1373088_538912 6.5968
R27-131-125 n1_1373088_538912 n1_1412000_538912 6.8096000000000005
R27-131-126 n1_1412000_538912 n1_1449696_538912 6.5968
R27-131-127 n1_1449696_538912 n1_1487392_538912 63.0386
R27-131-128 n1_1487392_538912 n1_1526304_538912 76.2791
R27-131-129 n1_1526304_538912 n1_1564000_538912 75.4468
R27-131-130 n1_1564000_538912 n1_1602912_538912 6.8096
R27-131-131 n1_1602912_538912 n1_1641180_538912 547.9786
R27-131-132 n1_1641180_538912 n1_1641290_538912 0.020763
R27-132-100 n1_474686_502432 n1_474796_502432 0.01925
R27-132-101 n1_474796_502432 n1_493920_502432 116.2694
R27-132-102 n1_493920_502432 n1_532832_502432 6.8096000000000005
R27-132-103 n1_532832_502432 n1_570528_502432 6.5968
R27-132-104 n1_570528_502432 n1_609440_502432 6.8096000000000005
R27-132-105 n1_609440_502432 n1_647136_502432 6.5968
R27-132-106 n1_647136_502432 n1_686048_502432 6.8096000000000005
R27-132-107 n1_686048_502432 n1_723744_502432 6.5968
R27-132-108 n1_723744_502432 n1_761440_502432 6.5968
R27-132-109 n1_761440_502432 n1_800352_502432 6.8096000000000005
R27-132-110 n1_800352_502432 n1_838048_502432 6.5968
R27-132-111 n1_838048_502432 n1_876960_502432 6.8096000000000005
R27-132-112 n1_876960_502432 n1_914656_502432 6.5968
R27-132-113 n1_914656_502432 n1_952352_502432 6.5968
R27-132-114 n1_952352_502432 n1_991264_502432 6.8096000000000005
R27-132-115 n1_991264_502432 n1_1028960_502432 6.5968
R27-132-116 n1_1028960_502432 n1_1067872_502432 6.8096000000000005
R27-132-117 n1_1067872_502432 n1_1105568_502432 6.5968
R27-132-118 n1_1105568_502432 n1_1144480_502432 6.8096000000000005
R27-132-119 n1_1144480_502432 n1_1182176_502432 6.5968
R27-132-120 n1_1182176_502432 n1_1219872_502432 6.5968
R27-132-121 n1_1219872_502432 n1_1258784_502432 6.8096000000000005
R27-132-122 n1_1258784_502432 n1_1296480_502432 6.5968
R27-132-123 n1_1296480_502432 n1_1335392_502432 6.8096000000000005
R27-132-124 n1_1335392_502432 n1_1373088_502432 6.5968
R27-132-125 n1_1373088_502432 n1_1412000_502432 6.8096000000000005
R27-132-126 n1_1412000_502432 n1_1449696_502432 54.6712
R27-132-127 n1_1449696_502432 n1_1487392_502432 62.1234
R27-132-128 n1_1487392_502432 n1_1526304_502432 70.4419
R27-132-129 n1_1526304_502432 n1_1564000_502432 79.5591
R27-132-130 n1_1564000_502432 n1_1602912_502432 6.9204
R27-132-131 n1_1602912_502432 n1_1641180_502432 402.7673
R27-132-132 n1_1641180_502432 n1_1641290_502432 0.020508
R27-133-100 n1_474686_480880 n1_474796_480880 0.009625
R27-133-101 n1_474796_480880 n1_493920_480880 1.67335
R27-133-102 n1_493920_480880 n1_532832_480880 3.4048000000000003
R27-133-103 n1_532832_480880 n1_570528_480880 3.2984
R27-133-104 n1_570528_480880 n1_609440_480880 3.4048000000000003
R27-133-105 n1_609440_480880 n1_647136_480880 3.2984
R27-133-106 n1_647136_480880 n1_686048_480880 3.4048000000000003
R27-133-107 n1_686048_480880 n1_723744_480880 3.2984
R27-133-108 n1_723744_480880 n1_761440_480880 3.2984
R27-133-109 n1_761440_480880 n1_800352_480880 3.4048000000000003
R27-133-110 n1_800352_480880 n1_838048_480880 3.2984
R27-133-111 n1_838048_480880 n1_876960_480880 3.4048000000000003
R27-133-112 n1_876960_480880 n1_914656_480880 3.2984
R27-133-113 n1_914656_480880 n1_952352_480880 3.2984
R27-133-114 n1_952352_480880 n1_991264_480880 3.4048000000000003
R27-133-115 n1_991264_480880 n1_1028960_480880 3.2984
R27-133-116 n1_1028960_480880 n1_1067872_480880 3.4048000000000003
R27-133-117 n1_1067872_480880 n1_1105568_480880 3.2984
R27-133-118 n1_1105568_480880 n1_1144480_480880 3.4048000000000003
R27-133-119 n1_1144480_480880 n1_1182176_480880 3.2984
R27-133-120 n1_1182176_480880 n1_1219872_480880 3.2984
R27-133-121 n1_1219872_480880 n1_1258784_480880 3.4048000000000003
R27-133-122 n1_1258784_480880 n1_1296480_480880 3.2984
R27-133-123 n1_1296480_480880 n1_1335392_480880 3.4048000000000003
R27-133-124 n1_1335392_480880 n1_1373088_480880 3.2984
R27-133-125 n1_1373088_480880 n1_1412000_480880 3.4048000000000003
R27-133-126 n1_1412000_480880 n1_1449696_480880 3.2984
R27-133-127 n1_1449696_480880 n1_1487392_480880 3.2984
R27-133-128 n1_1487392_480880 n1_1526304_480880 3.4048000000000003
R27-133-129 n1_1526304_480880 n1_1564000_480880 3.2984
R27-133-130 n1_1564000_480880 n1_1602912_480880 3.4048000000000003
R27-133-131 n1_1602912_480880 n1_1620161_480880 284.2406
R27-133-132 n1_1620161_480880 n1_1641180_480880 2.0216
R27-133-133 n1_1641180_480880 n1_1641290_480880 0.009625
R25-100-100 n1_474796_480880 n1_474796_480720 0.00727273
R25-100-101 n1_474796_502432 n1_474796_480880 0.979636
R25-100-102 n1_474796_538912 n1_474796_502432 1.6581800000000002
R25-100-103 n1_474796_577824 n1_474796_538912 1.7687300000000001
R25-100-104 n1_474796_614304 n1_474796_577824 1.6581800000000002
R25-100-105 n1_474796_653216 n1_474796_614304 1.7687300000000001
R25-100-106 n1_474796_692128 n1_474796_653216 1.7687300000000001
R25-100-107 n1_474796_728608 n1_474796_692128 1.6581800000000002
R25-100-108 n1_474796_767520 n1_474796_728608 1.7687300000000001
R25-100-109 n1_474796_804000 n1_474796_767520 1.6581800000000002
R25-100-110 n1_474796_842912 n1_474796_804000 1.7687300000000001
R25-100-111 n1_474796_881824 n1_474796_842912 1.7687300000000001
R25-100-112 n1_474796_918304 n1_474796_881824 1.6581800000000002
R25-100-113 n1_474796_940095 n1_474796_918304 0.9904999999999999
R25-100-114 n1_474796_957216 n1_474796_940095 0.778227
R25-100-115 n1_474796_993696 n1_474796_957216 1.6581800000000002
R25-100-116 n1_474796_1032608 n1_474796_993696 1.7687300000000001
R25-100-117 n1_474796_1071520 n1_474796_1032608 1.7687300000000001
R25-100-118 n1_474796_1108000 n1_474796_1071520 1.6581800000000002
R25-100-119 n1_474796_1146912 n1_474796_1108000 1.7687300000000001
R25-100-120 n1_474796_1183392 n1_474796_1146912 1.6581800000000002
R25-100-121 n1_474796_1222304 n1_474796_1183392 1.7687300000000001
R25-100-122 n1_474796_1261216 n1_474796_1222304 1.7687300000000001
R25-100-123 n1_474796_1297696 n1_474796_1261216 1.6581800000000002
R25-100-124 n1_474796_1336608 n1_474796_1297696 1.7687300000000001
R25-100-125 n1_474796_1373088 n1_474796_1336608 1.6581800000000002
R25-100-126 n1_474796_1412000 n1_474796_1373088 1.7687300000000001
R25-100-127 n1_474796_1448480 n1_474796_1412000 1.6581800000000002
R25-100-128 n1_474796_1487392 n1_474796_1448480 1.7687300000000001
R25-100-129 n1_474796_1526304 n1_474796_1487392 1.7687300000000001
R25-100-130 n1_474796_1562784 n1_474796_1526304 1.6581800000000002
R25-100-131 n1_474796_1601696 n1_474796_1562784 1.7687300000000001
R25-100-132 n1_474796_1641130 n1_474796_1601696 1.7924499999999999
R25-100-133 n1_474796_1641290 n1_474796_1641130 0.00727273
R25-101-100 n1_493920_480880 n1_493920_480720 0.0145455
R25-101-101 n1_493920_502432 n1_493920_480880 1.95927
R25-101-102 n1_493920_538912 n1_493920_502432 3.3163600000000004
R25-101-103 n1_493920_577824 n1_493920_538912 3.5374499999999998
R25-101-104 n1_493920_614304 n1_493920_577824 3.3163600000000004
R25-101-105 n1_493920_653216 n1_493920_614304 3.5374499999999998
R25-101-106 n1_493920_692128 n1_493920_653216 3.5374499999999998
R25-101-107 n1_493920_728608 n1_493920_692128 3.3163600000000004
R25-101-108 n1_493920_767520 n1_493920_728608 3.5374499999999998
R25-101-109 n1_493920_804000 n1_493920_767520 3.3163600000000004
R25-101-110 n1_493920_842912 n1_493920_804000 3.5374499999999998
R25-101-111 n1_493920_881824 n1_493920_842912 3.5374499999999998
R25-101-112 n1_493920_918304 n1_493920_881824 3.3163600000000004
R25-101-113 n1_493920_957216 n1_493920_918304 3.5374499999999998
R25-101-114 n1_493920_993696 n1_493920_957216 3.3163600000000004
R25-101-115 n1_493920_1032608 n1_493920_993696 3.5374499999999998
R25-101-116 n1_493920_1071520 n1_493920_1032608 3.5374499999999998
R25-101-117 n1_493920_1108000 n1_493920_1071520 3.3163600000000004
R25-101-118 n1_493920_1146912 n1_493920_1108000 3.5374499999999998
R25-101-119 n1_493920_1183392 n1_493920_1146912 3.3163600000000004
R25-101-120 n1_493920_1222304 n1_493920_1183392 3.5374499999999998
R25-101-121 n1_493920_1261216 n1_493920_1222304 3.5374499999999998
R25-101-122 n1_493920_1297696 n1_493920_1261216 3.3163600000000004
R25-101-123 n1_493920_1336608 n1_493920_1297696 3.5374499999999998
R25-101-124 n1_493920_1373088 n1_493920_1336608 3.3163600000000004
R25-101-125 n1_493920_1412000 n1_493920_1373088 3.5374499999999998
R25-101-126 n1_493920_1448480 n1_493920_1412000 3.3163600000000004
R25-101-127 n1_493920_1487392 n1_493920_1448480 3.5374499999999998
R25-101-128 n1_493920_1526304 n1_493920_1487392 3.5374499999999998
R25-101-129 n1_493920_1562784 n1_493920_1526304 3.3163600000000004
R25-101-130 n1_493920_1601696 n1_493920_1562784 3.5374499999999998
R25-101-131 n1_493920_1641130 n1_493920_1601696 18.1868
R25-101-132 n1_493920_1641290 n1_493920_1641130 0.014545
R25-102-100 n1_532832_480880 n1_532832_480720 0.0145455
R25-102-101 n1_532832_502432 n1_532832_480880 1.95927
R25-102-102 n1_532832_538912 n1_532832_502432 3.3163600000000004
R25-102-103 n1_532832_577824 n1_532832_538912 3.5374499999999998
R25-102-104 n1_532832_614304 n1_532832_577824 3.3163600000000004
R25-102-105 n1_532832_653216 n1_532832_614304 3.5374499999999998
R25-102-106 n1_532832_692128 n1_532832_653216 3.5374499999999998
R25-102-107 n1_532832_728608 n1_532832_692128 3.3163600000000004
R25-102-108 n1_532832_767520 n1_532832_728608 3.5374499999999998
R25-102-109 n1_532832_804000 n1_532832_767520 3.3163600000000004
R25-102-110 n1_532832_842912 n1_532832_804000 3.5374499999999998
R25-102-111 n1_532832_881824 n1_532832_842912 3.5374499999999998
R25-102-112 n1_532832_918304 n1_532832_881824 3.3163600000000004
R25-102-113 n1_532832_957216 n1_532832_918304 3.5374499999999998
R25-102-114 n1_532832_993696 n1_532832_957216 3.3163600000000004
R25-102-115 n1_532832_1032608 n1_532832_993696 3.5374499999999998
R25-102-116 n1_532832_1071520 n1_532832_1032608 3.5374499999999998
R25-102-117 n1_532832_1108000 n1_532832_1071520 3.3163600000000004
R25-102-118 n1_532832_1146912 n1_532832_1108000 3.5374499999999998
R25-102-119 n1_532832_1183392 n1_532832_1146912 3.3163600000000004
R25-102-120 n1_532832_1222304 n1_532832_1183392 3.5374499999999998
R25-102-121 n1_532832_1261216 n1_532832_1222304 3.5374499999999998
R25-102-122 n1_532832_1297696 n1_532832_1261216 3.3163600000000004
R25-102-123 n1_532832_1336608 n1_532832_1297696 3.5374499999999998
R25-102-124 n1_532832_1373088 n1_532832_1336608 3.3163600000000004
R25-102-125 n1_532832_1412000 n1_532832_1373088 3.5374499999999998
R25-102-126 n1_532832_1448480 n1_532832_1412000 3.3163600000000004
R25-102-127 n1_532832_1487392 n1_532832_1448480 3.5374499999999998
R25-102-128 n1_532832_1526304 n1_532832_1487392 3.5374499999999998
R25-102-129 n1_532832_1562784 n1_532832_1526304 3.3163600000000004
R25-102-130 n1_532832_1601696 n1_532832_1562784 3.5374499999999998
R25-102-131 n1_532832_1641130 n1_532832_1601696 23.3407
R25-102-132 n1_532832_1641290 n1_532832_1641130 0.014545
R25-103-100 n1_570528_480880 n1_570528_480720 0.0145455
R25-103-101 n1_570528_502432 n1_570528_480880 1.95927
R25-103-102 n1_570528_538912 n1_570528_502432 3.3163600000000004
R25-103-103 n1_570528_577824 n1_570528_538912 3.5374499999999998
R25-103-104 n1_570528_614304 n1_570528_577824 3.3163600000000004
R25-103-105 n1_570528_653216 n1_570528_614304 3.5374499999999998
R25-103-106 n1_570528_692128 n1_570528_653216 3.5374499999999998
R25-103-107 n1_570528_728608 n1_570528_692128 3.3163600000000004
R25-103-108 n1_570528_767520 n1_570528_728608 3.5374499999999998
R25-103-109 n1_570528_804000 n1_570528_767520 3.3163600000000004
R25-103-110 n1_570528_842912 n1_570528_804000 3.5374499999999998
R25-103-111 n1_570528_881824 n1_570528_842912 3.5374499999999998
R25-103-112 n1_570528_918304 n1_570528_881824 3.3163600000000004
R25-103-113 n1_570528_957216 n1_570528_918304 3.5374499999999998
R25-103-114 n1_570528_993696 n1_570528_957216 3.3163600000000004
R25-103-115 n1_570528_1032608 n1_570528_993696 3.5374499999999998
R25-103-116 n1_570528_1071520 n1_570528_1032608 3.5374499999999998
R25-103-117 n1_570528_1108000 n1_570528_1071520 3.3163600000000004
R25-103-118 n1_570528_1146912 n1_570528_1108000 3.5374499999999998
R25-103-119 n1_570528_1183392 n1_570528_1146912 3.3163600000000004
R25-103-120 n1_570528_1222304 n1_570528_1183392 3.5374499999999998
R25-103-121 n1_570528_1261216 n1_570528_1222304 3.5374499999999998
R25-103-122 n1_570528_1297696 n1_570528_1261216 3.3163600000000004
R25-103-123 n1_570528_1336608 n1_570528_1297696 3.5374499999999998
R25-103-124 n1_570528_1373088 n1_570528_1336608 3.3163600000000004
R25-103-125 n1_570528_1412000 n1_570528_1373088 3.5374499999999998
R25-103-126 n1_570528_1448480 n1_570528_1412000 3.3163600000000004
R25-103-127 n1_570528_1487392 n1_570528_1448480 3.5374499999999998
R25-103-128 n1_570528_1526304 n1_570528_1487392 3.5374499999999998
R25-103-129 n1_570528_1562784 n1_570528_1526304 3.3163600000000004
R25-103-130 n1_570528_1601696 n1_570528_1562784 3.5374499999999998
R25-103-131 n1_570528_1641130 n1_570528_1601696 20.1639
R25-103-132 n1_570528_1641290 n1_570528_1641130 0.014545
R25-104-100 n1_609440_480880 n1_609440_480720 0.0145455
R25-104-101 n1_609440_502432 n1_609440_480880 1.95927
R25-104-102 n1_609440_538912 n1_609440_502432 3.3163600000000004
R25-104-103 n1_609440_577824 n1_609440_538912 3.5374499999999998
R25-104-104 n1_609440_614304 n1_609440_577824 3.3163600000000004
R25-104-105 n1_609440_653216 n1_609440_614304 3.5374499999999998
R25-104-106 n1_609440_692128 n1_609440_653216 3.5374499999999998
R25-104-107 n1_609440_728608 n1_609440_692128 3.3163600000000004
R25-104-108 n1_609440_767520 n1_609440_728608 3.5374499999999998
R25-104-109 n1_609440_804000 n1_609440_767520 3.3163600000000004
R25-104-110 n1_609440_842912 n1_609440_804000 3.5374499999999998
R25-104-111 n1_609440_881824 n1_609440_842912 3.5374499999999998
R25-104-112 n1_609440_918304 n1_609440_881824 3.3163600000000004
R25-104-113 n1_609440_957216 n1_609440_918304 3.5374499999999998
R25-104-114 n1_609440_993696 n1_609440_957216 3.3163600000000004
R25-104-115 n1_609440_1032608 n1_609440_993696 3.5374499999999998
R25-104-116 n1_609440_1071520 n1_609440_1032608 3.5374499999999998
R25-104-117 n1_609440_1108000 n1_609440_1071520 3.3163600000000004
R25-104-118 n1_609440_1146912 n1_609440_1108000 3.5374499999999998
R25-104-119 n1_609440_1183392 n1_609440_1146912 3.3163600000000004
R25-104-120 n1_609440_1222304 n1_609440_1183392 3.5374499999999998
R25-104-121 n1_609440_1261216 n1_609440_1222304 3.5374499999999998
R25-104-122 n1_609440_1297696 n1_609440_1261216 3.3163600000000004
R25-104-123 n1_609440_1336608 n1_609440_1297696 3.5374499999999998
R25-104-124 n1_609440_1373088 n1_609440_1336608 3.3163600000000004
R25-104-125 n1_609440_1412000 n1_609440_1373088 3.5374499999999998
R25-104-126 n1_609440_1448480 n1_609440_1412000 3.3163600000000004
R25-104-127 n1_609440_1487392 n1_609440_1448480 3.5374499999999998
R25-104-128 n1_609440_1526304 n1_609440_1487392 4.9412
R25-104-129 n1_609440_1562784 n1_609440_1526304 45.2346
R25-104-130 n1_609440_1601696 n1_609440_1562784 67.1673
R25-104-131 n1_609440_1641130 n1_609440_1601696 140.371
R25-104-132 n1_609440_1641290 n1_609440_1641130 0.014545
R25-105-100 n1_647136_480880 n1_647136_480720 0.0145455
R25-105-101 n1_647136_502432 n1_647136_480880 1.95927
R25-105-102 n1_647136_538912 n1_647136_502432 3.3163600000000004
R25-105-103 n1_647136_577824 n1_647136_538912 3.5374499999999998
R25-105-104 n1_647136_614304 n1_647136_577824 3.3163600000000004
R25-105-105 n1_647136_653216 n1_647136_614304 3.5374499999999998
R25-105-106 n1_647136_692128 n1_647136_653216 3.5374499999999998
R25-105-107 n1_647136_728608 n1_647136_692128 3.3163600000000004
R25-105-108 n1_647136_767520 n1_647136_728608 3.5374499999999998
R25-105-109 n1_647136_804000 n1_647136_767520 3.3163600000000004
R25-105-110 n1_647136_842912 n1_647136_804000 3.5374499999999998
R25-105-111 n1_647136_881824 n1_647136_842912 3.5374499999999998
R25-105-112 n1_647136_918304 n1_647136_881824 3.3163600000000004
R25-105-113 n1_647136_957216 n1_647136_918304 3.5374499999999998
R25-105-114 n1_647136_993696 n1_647136_957216 3.3163600000000004
R25-105-115 n1_647136_1032608 n1_647136_993696 3.5374499999999998
R25-105-116 n1_647136_1071520 n1_647136_1032608 3.5374499999999998
R25-105-117 n1_647136_1108000 n1_647136_1071520 3.3163600000000004
R25-105-118 n1_647136_1146912 n1_647136_1108000 3.5374499999999998
R25-105-119 n1_647136_1183392 n1_647136_1146912 3.3163600000000004
R25-105-120 n1_647136_1222304 n1_647136_1183392 3.5374499999999998
R25-105-121 n1_647136_1261216 n1_647136_1222304 3.5374499999999998
R25-105-122 n1_647136_1297696 n1_647136_1261216 3.3163600000000004
R25-105-123 n1_647136_1336608 n1_647136_1297696 3.5374499999999998
R25-105-124 n1_647136_1373088 n1_647136_1336608 3.3163600000000004
R25-105-125 n1_647136_1412000 n1_647136_1373088 3.5374499999999998
R25-105-126 n1_647136_1448480 n1_647136_1412000 3.3163600000000004
R25-105-127 n1_647136_1487392 n1_647136_1448480 3.5374499999999998
R25-105-128 n1_647136_1526304 n1_647136_1487392 3.5374499999999998
R25-105-129 n1_647136_1562784 n1_647136_1526304 7.851
R25-105-130 n1_647136_1601696 n1_647136_1562784 54.9948
R25-105-131 n1_647136_1641130 n1_647136_1601696 268.8273
R25-105-132 n1_647136_1641290 n1_647136_1641130 0.014545
R25-106-100 n1_686048_480880 n1_686048_480720 0.0145455
R25-106-101 n1_686048_502432 n1_686048_480880 1.95927
R25-106-102 n1_686048_538912 n1_686048_502432 3.3163600000000004
R25-106-103 n1_686048_577824 n1_686048_538912 3.5374499999999998
R25-106-104 n1_686048_614304 n1_686048_577824 3.3163600000000004
R25-106-105 n1_686048_653216 n1_686048_614304 3.5374499999999998
R25-106-106 n1_686048_692128 n1_686048_653216 3.5374499999999998
R25-106-107 n1_686048_728608 n1_686048_692128 3.3163600000000004
R25-106-108 n1_686048_767520 n1_686048_728608 3.5374499999999998
R25-106-109 n1_686048_804000 n1_686048_767520 3.3163600000000004
R25-106-110 n1_686048_842912 n1_686048_804000 3.5374499999999998
R25-106-111 n1_686048_881824 n1_686048_842912 3.5374499999999998
R25-106-112 n1_686048_918304 n1_686048_881824 3.3163600000000004
R25-106-113 n1_686048_957216 n1_686048_918304 3.5374499999999998
R25-106-114 n1_686048_993696 n1_686048_957216 3.3163600000000004
R25-106-115 n1_686048_1032608 n1_686048_993696 3.5374499999999998
R25-106-116 n1_686048_1071520 n1_686048_1032608 3.5374499999999998
R25-106-117 n1_686048_1108000 n1_686048_1071520 3.3163600000000004
R25-106-118 n1_686048_1146912 n1_686048_1108000 3.5374499999999998
R25-106-119 n1_686048_1183392 n1_686048_1146912 3.3163600000000004
R25-106-120 n1_686048_1222304 n1_686048_1183392 3.5374499999999998
R25-106-121 n1_686048_1261216 n1_686048_1222304 3.5374499999999998
R25-106-122 n1_686048_1297696 n1_686048_1261216 3.3163600000000004
R25-106-123 n1_686048_1336608 n1_686048_1297696 3.5374499999999998
R25-106-124 n1_686048_1373088 n1_686048_1336608 3.3163600000000004
R25-106-125 n1_686048_1412000 n1_686048_1373088 3.5374499999999998
R25-106-126 n1_686048_1448480 n1_686048_1412000 3.3163600000000004
R25-106-127 n1_686048_1487392 n1_686048_1448480 3.5374499999999998
R25-106-128 n1_686048_1526304 n1_686048_1487392 3.5374499999999998
R25-106-129 n1_686048_1562784 n1_686048_1526304 3.3163600000000004
R25-106-130 n1_686048_1601696 n1_686048_1562784 10.225
R25-106-131 n1_686048_1641130 n1_686048_1601696 316.851
R25-106-132 n1_686048_1641290 n1_686048_1641130 0.014545
R25-107-100 n1_723744_480880 n1_723744_480720 0.0145455
R25-107-101 n1_723744_502432 n1_723744_480880 1.95927
R25-107-102 n1_723744_538912 n1_723744_502432 3.3163600000000004
R25-107-103 n1_723744_577824 n1_723744_538912 3.5374499999999998
R25-107-104 n1_723744_614304 n1_723744_577824 3.3163600000000004
R25-107-105 n1_723744_653216 n1_723744_614304 3.5374499999999998
R25-107-106 n1_723744_692128 n1_723744_653216 3.5374499999999998
R25-107-107 n1_723744_728608 n1_723744_692128 3.3163600000000004
R25-107-108 n1_723744_767520 n1_723744_728608 3.5374499999999998
R25-107-109 n1_723744_804000 n1_723744_767520 3.3163600000000004
R25-107-110 n1_723744_842912 n1_723744_804000 3.5374499999999998
R25-107-111 n1_723744_881824 n1_723744_842912 3.5374499999999998
R25-107-112 n1_723744_918304 n1_723744_881824 3.3163600000000004
R25-107-113 n1_723744_957216 n1_723744_918304 3.5374499999999998
R25-107-114 n1_723744_993696 n1_723744_957216 3.3163600000000004
R25-107-115 n1_723744_1032608 n1_723744_993696 3.5374499999999998
R25-107-116 n1_723744_1071520 n1_723744_1032608 3.5374499999999998
R25-107-117 n1_723744_1108000 n1_723744_1071520 3.3163600000000004
R25-107-118 n1_723744_1146912 n1_723744_1108000 3.5374499999999998
R25-107-119 n1_723744_1183392 n1_723744_1146912 3.3163600000000004
R25-107-120 n1_723744_1222304 n1_723744_1183392 3.5374499999999998
R25-107-121 n1_723744_1261216 n1_723744_1222304 3.5374499999999998
R25-107-122 n1_723744_1297696 n1_723744_1261216 3.3163600000000004
R25-107-123 n1_723744_1336608 n1_723744_1297696 3.5374499999999998
R25-107-124 n1_723744_1373088 n1_723744_1336608 3.3163600000000004
R25-107-125 n1_723744_1412000 n1_723744_1373088 3.5374499999999998
R25-107-126 n1_723744_1448480 n1_723744_1412000 3.3163600000000004
R25-107-127 n1_723744_1487392 n1_723744_1448480 3.5374499999999998
R25-107-128 n1_723744_1526304 n1_723744_1487392 3.5374499999999998
R25-107-129 n1_723744_1562784 n1_723744_1526304 3.3163600000000004
R25-107-130 n1_723744_1601696 n1_723744_1562784 3.5374499999999998
R25-107-131 n1_723744_1641130 n1_723744_1601696 462.1981
R25-107-132 n1_723744_1641290 n1_723744_1641130 0.014545
R25-108-100 n1_761440_480880 n1_761440_480720 0.0145455
R25-108-101 n1_761440_502432 n1_761440_480880 1.95927
R25-108-102 n1_761440_538912 n1_761440_502432 3.3163600000000004
R25-108-103 n1_761440_577824 n1_761440_538912 3.5374499999999998
R25-108-104 n1_761440_614304 n1_761440_577824 3.3163600000000004
R25-108-105 n1_761440_653216 n1_761440_614304 3.5374499999999998
R25-108-106 n1_761440_692128 n1_761440_653216 3.5374499999999998
R25-108-107 n1_761440_728608 n1_761440_692128 3.3163600000000004
R25-108-108 n1_761440_767520 n1_761440_728608 3.5374499999999998
R25-108-109 n1_761440_804000 n1_761440_767520 3.3163600000000004
R25-108-110 n1_761440_842912 n1_761440_804000 3.5374499999999998
R25-108-111 n1_761440_881824 n1_761440_842912 3.5374499999999998
R25-108-112 n1_761440_918304 n1_761440_881824 3.3163600000000004
R25-108-113 n1_761440_957216 n1_761440_918304 3.5374499999999998
R25-108-114 n1_761440_993696 n1_761440_957216 3.3163600000000004
R25-108-115 n1_761440_1032608 n1_761440_993696 3.5374499999999998
R25-108-116 n1_761440_1071520 n1_761440_1032608 3.5374499999999998
R25-108-117 n1_761440_1108000 n1_761440_1071520 3.3163600000000004
R25-108-118 n1_761440_1146912 n1_761440_1108000 3.5374499999999998
R25-108-119 n1_761440_1183392 n1_761440_1146912 3.3163600000000004
R25-108-120 n1_761440_1222304 n1_761440_1183392 3.5374499999999998
R25-108-121 n1_761440_1261216 n1_761440_1222304 3.5374499999999998
R25-108-122 n1_761440_1297696 n1_761440_1261216 3.3163600000000004
R25-108-123 n1_761440_1336608 n1_761440_1297696 3.5374499999999998
R25-108-124 n1_761440_1373088 n1_761440_1336608 3.3163600000000004
R25-108-125 n1_761440_1412000 n1_761440_1373088 3.5374499999999998
R25-108-126 n1_761440_1448480 n1_761440_1412000 3.3163600000000004
R25-108-127 n1_761440_1487392 n1_761440_1448480 3.5374499999999998
R25-108-128 n1_761440_1526304 n1_761440_1487392 3.5374499999999998
R25-108-129 n1_761440_1562784 n1_761440_1526304 3.3163600000000004
R25-108-130 n1_761440_1601696 n1_761440_1562784 3.5374499999999998
R25-108-131 n1_761440_1641130 n1_761440_1601696 485.3848
R25-108-132 n1_761440_1641290 n1_761440_1641130 0.014545
R25-109-100 n1_800352_480880 n1_800352_480720 0.0145455
R25-109-101 n1_800352_502432 n1_800352_480880 1.95927
R25-109-102 n1_800352_538912 n1_800352_502432 3.3163600000000004
R25-109-103 n1_800352_577824 n1_800352_538912 3.5374499999999998
R25-109-104 n1_800352_614304 n1_800352_577824 3.3163600000000004
R25-109-105 n1_800352_653216 n1_800352_614304 3.5374499999999998
R25-109-106 n1_800352_692128 n1_800352_653216 3.5374499999999998
R25-109-107 n1_800352_728608 n1_800352_692128 3.3163600000000004
R25-109-108 n1_800352_767520 n1_800352_728608 3.5374499999999998
R25-109-109 n1_800352_804000 n1_800352_767520 3.3163600000000004
R25-109-110 n1_800352_842912 n1_800352_804000 3.5374499999999998
R25-109-111 n1_800352_881824 n1_800352_842912 3.5374499999999998
R25-109-112 n1_800352_918304 n1_800352_881824 3.3163600000000004
R25-109-113 n1_800352_957216 n1_800352_918304 3.5374499999999998
R25-109-114 n1_800352_993696 n1_800352_957216 3.3163600000000004
R25-109-115 n1_800352_1032608 n1_800352_993696 3.5374499999999998
R25-109-116 n1_800352_1071520 n1_800352_1032608 3.5374499999999998
R25-109-117 n1_800352_1108000 n1_800352_1071520 3.3163600000000004
R25-109-118 n1_800352_1146912 n1_800352_1108000 3.5374499999999998
R25-109-119 n1_800352_1183392 n1_800352_1146912 3.3163600000000004
R25-109-120 n1_800352_1222304 n1_800352_1183392 3.5374499999999998
R25-109-121 n1_800352_1261216 n1_800352_1222304 3.5374499999999998
R25-109-122 n1_800352_1297696 n1_800352_1261216 3.3163600000000004
R25-109-123 n1_800352_1336608 n1_800352_1297696 3.5374499999999998
R25-109-124 n1_800352_1373088 n1_800352_1336608 3.3163600000000004
R25-109-125 n1_800352_1412000 n1_800352_1373088 3.5374499999999998
R25-109-126 n1_800352_1448480 n1_800352_1412000 3.3163600000000004
R25-109-127 n1_800352_1487392 n1_800352_1448480 3.5374499999999998
R25-109-128 n1_800352_1526304 n1_800352_1487392 3.5374499999999998
R25-109-129 n1_800352_1562784 n1_800352_1526304 3.3163600000000004
R25-109-130 n1_800352_1601696 n1_800352_1562784 3.5374499999999998
R25-109-131 n1_800352_1641130 n1_800352_1601696 510.2804
R25-109-132 n1_800352_1641290 n1_800352_1641130 0.014545
R25-110-100 n1_838048_480880 n1_838048_480720 0.0145455
R25-110-101 n1_838048_502432 n1_838048_480880 1.95927
R25-110-102 n1_838048_538912 n1_838048_502432 3.3163600000000004
R25-110-103 n1_838048_577824 n1_838048_538912 3.5374499999999998
R25-110-104 n1_838048_614304 n1_838048_577824 3.3163600000000004
R25-110-105 n1_838048_653216 n1_838048_614304 3.5374499999999998
R25-110-106 n1_838048_692128 n1_838048_653216 3.5374499999999998
R25-110-107 n1_838048_728608 n1_838048_692128 3.3163600000000004
R25-110-108 n1_838048_767520 n1_838048_728608 3.5374499999999998
R25-110-109 n1_838048_804000 n1_838048_767520 3.3163600000000004
R25-110-110 n1_838048_842912 n1_838048_804000 3.5374499999999998
R25-110-111 n1_838048_881824 n1_838048_842912 3.5374499999999998
R25-110-112 n1_838048_918304 n1_838048_881824 3.3163600000000004
R25-110-113 n1_838048_957216 n1_838048_918304 3.5374499999999998
R25-110-114 n1_838048_993696 n1_838048_957216 3.3163600000000004
R25-110-115 n1_838048_1032608 n1_838048_993696 3.5374499999999998
R25-110-116 n1_838048_1071520 n1_838048_1032608 3.5374499999999998
R25-110-117 n1_838048_1108000 n1_838048_1071520 3.3163600000000004
R25-110-118 n1_838048_1146912 n1_838048_1108000 3.5374499999999998
R25-110-119 n1_838048_1183392 n1_838048_1146912 3.3163600000000004
R25-110-120 n1_838048_1222304 n1_838048_1183392 3.5374499999999998
R25-110-121 n1_838048_1261216 n1_838048_1222304 3.5374499999999998
R25-110-122 n1_838048_1297696 n1_838048_1261216 3.3163600000000004
R25-110-123 n1_838048_1336608 n1_838048_1297696 3.5374499999999998
R25-110-124 n1_838048_1373088 n1_838048_1336608 3.3163600000000004
R25-110-125 n1_838048_1412000 n1_838048_1373088 3.5374499999999998
R25-110-126 n1_838048_1448480 n1_838048_1412000 3.3163600000000004
R25-110-127 n1_838048_1487392 n1_838048_1448480 3.5374499999999998
R25-110-128 n1_838048_1526304 n1_838048_1487392 3.5374499999999998
R25-110-129 n1_838048_1562784 n1_838048_1526304 3.3163600000000004
R25-110-130 n1_838048_1601696 n1_838048_1562784 3.5374499999999998
R25-110-131 n1_838048_1641130 n1_838048_1601696 509.7773
R25-110-132 n1_838048_1641290 n1_838048_1641130 0.014545
R25-111-100 n1_876960_480880 n1_876960_480720 0.0145455
R25-111-101 n1_876960_502432 n1_876960_480880 1.95927
R25-111-102 n1_876960_538912 n1_876960_502432 3.3163600000000004
R25-111-103 n1_876960_577824 n1_876960_538912 3.5374499999999998
R25-111-104 n1_876960_614304 n1_876960_577824 3.3163600000000004
R25-111-105 n1_876960_653216 n1_876960_614304 3.5374499999999998
R25-111-106 n1_876960_692128 n1_876960_653216 3.5374499999999998
R25-111-107 n1_876960_728608 n1_876960_692128 3.3163600000000004
R25-111-108 n1_876960_767520 n1_876960_728608 3.5374499999999998
R25-111-109 n1_876960_804000 n1_876960_767520 3.3163600000000004
R25-111-110 n1_876960_842912 n1_876960_804000 3.5374499999999998
R25-111-111 n1_876960_881824 n1_876960_842912 3.5374499999999998
R25-111-112 n1_876960_918304 n1_876960_881824 3.3163600000000004
R25-111-113 n1_876960_957216 n1_876960_918304 3.5374499999999998
R25-111-114 n1_876960_993696 n1_876960_957216 3.3163600000000004
R25-111-115 n1_876960_1032608 n1_876960_993696 3.5374499999999998
R25-111-116 n1_876960_1071520 n1_876960_1032608 3.5374499999999998
R25-111-117 n1_876960_1108000 n1_876960_1071520 3.3163600000000004
R25-111-118 n1_876960_1146912 n1_876960_1108000 3.5374499999999998
R25-111-119 n1_876960_1183392 n1_876960_1146912 3.3163600000000004
R25-111-120 n1_876960_1222304 n1_876960_1183392 3.5374499999999998
R25-111-121 n1_876960_1261216 n1_876960_1222304 3.5374499999999998
R25-111-122 n1_876960_1297696 n1_876960_1261216 3.3163600000000004
R25-111-123 n1_876960_1336608 n1_876960_1297696 3.5374499999999998
R25-111-124 n1_876960_1373088 n1_876960_1336608 3.3163600000000004
R25-111-125 n1_876960_1412000 n1_876960_1373088 3.5374499999999998
R25-111-126 n1_876960_1448480 n1_876960_1412000 3.3163600000000004
R25-111-127 n1_876960_1487392 n1_876960_1448480 3.5374499999999998
R25-111-128 n1_876960_1526304 n1_876960_1487392 3.5374499999999998
R25-111-129 n1_876960_1562784 n1_876960_1526304 3.3163600000000004
R25-111-130 n1_876960_1601696 n1_876960_1562784 3.5374499999999998
R25-111-131 n1_876960_1641130 n1_876960_1601696 517.4079
R25-111-132 n1_876960_1641290 n1_876960_1641130 0.014545
R25-112-100 n1_914656_480880 n1_914656_480720 0.0145455
R25-112-101 n1_914656_502432 n1_914656_480880 1.95927
R25-112-102 n1_914656_538912 n1_914656_502432 3.3163600000000004
R25-112-103 n1_914656_577824 n1_914656_538912 3.5374499999999998
R25-112-104 n1_914656_614304 n1_914656_577824 3.3163600000000004
R25-112-105 n1_914656_653216 n1_914656_614304 3.5374499999999998
R25-112-106 n1_914656_692128 n1_914656_653216 3.5374499999999998
R25-112-107 n1_914656_728608 n1_914656_692128 3.3163600000000004
R25-112-108 n1_914656_767520 n1_914656_728608 3.5374499999999998
R25-112-109 n1_914656_804000 n1_914656_767520 3.3163600000000004
R25-112-110 n1_914656_842912 n1_914656_804000 3.5374499999999998
R25-112-111 n1_914656_881824 n1_914656_842912 3.5374499999999998
R25-112-112 n1_914656_918304 n1_914656_881824 3.3163600000000004
R25-112-113 n1_914656_957216 n1_914656_918304 3.5374499999999998
R25-112-114 n1_914656_993696 n1_914656_957216 3.3163600000000004
R25-112-115 n1_914656_1032608 n1_914656_993696 3.5374499999999998
R25-112-116 n1_914656_1071520 n1_914656_1032608 3.5374499999999998
R25-112-117 n1_914656_1108000 n1_914656_1071520 3.3163600000000004
R25-112-118 n1_914656_1146912 n1_914656_1108000 3.5374499999999998
R25-112-119 n1_914656_1183392 n1_914656_1146912 3.3163600000000004
R25-112-120 n1_914656_1222304 n1_914656_1183392 3.5374499999999998
R25-112-121 n1_914656_1261216 n1_914656_1222304 3.5374499999999998
R25-112-122 n1_914656_1297696 n1_914656_1261216 3.3163600000000004
R25-112-123 n1_914656_1336608 n1_914656_1297696 3.5374499999999998
R25-112-124 n1_914656_1373088 n1_914656_1336608 3.3163600000000004
R25-112-125 n1_914656_1412000 n1_914656_1373088 3.5374499999999998
R25-112-126 n1_914656_1448480 n1_914656_1412000 3.3163600000000004
R25-112-127 n1_914656_1487392 n1_914656_1448480 3.5374499999999998
R25-112-128 n1_914656_1526304 n1_914656_1487392 3.5374499999999998
R25-112-129 n1_914656_1562784 n1_914656_1526304 3.3163600000000004
R25-112-130 n1_914656_1601696 n1_914656_1562784 3.5374499999999998
R25-112-131 n1_914656_1641130 n1_914656_1601696 493.0095
R25-112-132 n1_914656_1641290 n1_914656_1641130 0.014545
R25-113-100 n1_952352_480880 n1_952352_480720 0.0145455
R25-113-101 n1_952352_502432 n1_952352_480880 1.95927
R25-113-102 n1_952352_538912 n1_952352_502432 3.3163600000000004
R25-113-103 n1_952352_577824 n1_952352_538912 3.5374499999999998
R25-113-104 n1_952352_614304 n1_952352_577824 3.3163600000000004
R25-113-105 n1_952352_653216 n1_952352_614304 3.5374499999999998
R25-113-106 n1_952352_692128 n1_952352_653216 3.5374499999999998
R25-113-107 n1_952352_728608 n1_952352_692128 3.3163600000000004
R25-113-108 n1_952352_767520 n1_952352_728608 3.5374499999999998
R25-113-109 n1_952352_804000 n1_952352_767520 3.3163600000000004
R25-113-110 n1_952352_842912 n1_952352_804000 3.5374499999999998
R25-113-111 n1_952352_881824 n1_952352_842912 3.5374499999999998
R25-113-112 n1_952352_918304 n1_952352_881824 3.3163600000000004
R25-113-113 n1_952352_957216 n1_952352_918304 3.5374499999999998
R25-113-114 n1_952352_993696 n1_952352_957216 3.3163600000000004
R25-113-115 n1_952352_1032608 n1_952352_993696 3.5374499999999998
R25-113-116 n1_952352_1071520 n1_952352_1032608 3.5374499999999998
R25-113-117 n1_952352_1108000 n1_952352_1071520 3.3163600000000004
R25-113-118 n1_952352_1146912 n1_952352_1108000 3.5374499999999998
R25-113-119 n1_952352_1183392 n1_952352_1146912 3.3163600000000004
R25-113-120 n1_952352_1222304 n1_952352_1183392 3.5374499999999998
R25-113-121 n1_952352_1261216 n1_952352_1222304 3.5374499999999998
R25-113-122 n1_952352_1297696 n1_952352_1261216 3.3163600000000004
R25-113-123 n1_952352_1336608 n1_952352_1297696 3.5374499999999998
R25-113-124 n1_952352_1373088 n1_952352_1336608 3.3163600000000004
R25-113-125 n1_952352_1412000 n1_952352_1373088 3.5374499999999998
R25-113-126 n1_952352_1448480 n1_952352_1412000 3.3163600000000004
R25-113-127 n1_952352_1487392 n1_952352_1448480 3.5374499999999998
R25-113-128 n1_952352_1526304 n1_952352_1487392 3.5374499999999998
R25-113-129 n1_952352_1562784 n1_952352_1526304 3.3163600000000004
R25-113-130 n1_952352_1601696 n1_952352_1562784 3.5374499999999998
R25-113-131 n1_952352_1641130 n1_952352_1601696 445.3762
R25-113-132 n1_952352_1641290 n1_952352_1641130 0.014545
R25-114-100 n1_991264_480880 n1_991264_480720 0.0145455
R25-114-101 n1_991264_502432 n1_991264_480880 1.95927
R25-114-102 n1_991264_538912 n1_991264_502432 3.3163600000000004
R25-114-103 n1_991264_577824 n1_991264_538912 3.5374499999999998
R25-114-104 n1_991264_614304 n1_991264_577824 3.3163600000000004
R25-114-105 n1_991264_653216 n1_991264_614304 3.5374499999999998
R25-114-106 n1_991264_692128 n1_991264_653216 3.5374499999999998
R25-114-107 n1_991264_728608 n1_991264_692128 3.3163600000000004
R25-114-108 n1_991264_767520 n1_991264_728608 3.5374499999999998
R25-114-109 n1_991264_804000 n1_991264_767520 3.3163600000000004
R25-114-110 n1_991264_842912 n1_991264_804000 3.5374499999999998
R25-114-111 n1_991264_881824 n1_991264_842912 3.5374499999999998
R25-114-112 n1_991264_918304 n1_991264_881824 3.3163600000000004
R25-114-113 n1_991264_957216 n1_991264_918304 3.5374499999999998
R25-114-114 n1_991264_993696 n1_991264_957216 3.3163600000000004
R25-114-115 n1_991264_1032608 n1_991264_993696 3.5374499999999998
R25-114-116 n1_991264_1071520 n1_991264_1032608 3.5374499999999998
R25-114-117 n1_991264_1108000 n1_991264_1071520 3.3163600000000004
R25-114-118 n1_991264_1146912 n1_991264_1108000 3.5374499999999998
R25-114-119 n1_991264_1183392 n1_991264_1146912 3.3163600000000004
R25-114-120 n1_991264_1222304 n1_991264_1183392 3.5374499999999998
R25-114-121 n1_991264_1261216 n1_991264_1222304 3.5374499999999998
R25-114-122 n1_991264_1297696 n1_991264_1261216 3.3163600000000004
R25-114-123 n1_991264_1336608 n1_991264_1297696 3.5374499999999998
R25-114-124 n1_991264_1373088 n1_991264_1336608 3.3163600000000004
R25-114-125 n1_991264_1412000 n1_991264_1373088 3.5374499999999998
R25-114-126 n1_991264_1448480 n1_991264_1412000 3.3163600000000004
R25-114-127 n1_991264_1487392 n1_991264_1448480 3.5374499999999998
R25-114-128 n1_991264_1526304 n1_991264_1487392 3.5374499999999998
R25-114-129 n1_991264_1562784 n1_991264_1526304 3.3163600000000004
R25-114-130 n1_991264_1601696 n1_991264_1562784 3.5374499999999998
R25-114-131 n1_991264_1641130 n1_991264_1601696 630.7404
R25-114-132 n1_991264_1641290 n1_991264_1641130 0.014983
R25-115-100 n1_1028960_480880 n1_1028960_480720 0.0145455
R25-115-101 n1_1028960_502432 n1_1028960_480880 1.95927
R25-115-102 n1_1028960_538912 n1_1028960_502432 3.3163600000000004
R25-115-103 n1_1028960_577824 n1_1028960_538912 3.5374499999999998
R25-115-104 n1_1028960_614304 n1_1028960_577824 3.3163600000000004
R25-115-105 n1_1028960_653216 n1_1028960_614304 3.5374499999999998
R25-115-106 n1_1028960_692128 n1_1028960_653216 3.5374499999999998
R25-115-107 n1_1028960_728608 n1_1028960_692128 3.3163600000000004
R25-115-108 n1_1028960_767520 n1_1028960_728608 3.5374499999999998
R25-115-109 n1_1028960_804000 n1_1028960_767520 3.3163600000000004
R25-115-110 n1_1028960_842912 n1_1028960_804000 3.5374499999999998
R25-115-111 n1_1028960_881824 n1_1028960_842912 3.5374499999999998
R25-115-112 n1_1028960_918304 n1_1028960_881824 3.3163600000000004
R25-115-113 n1_1028960_957216 n1_1028960_918304 3.5374499999999998
R25-115-114 n1_1028960_993696 n1_1028960_957216 3.3163600000000004
R25-115-115 n1_1028960_1032608 n1_1028960_993696 3.5374499999999998
R25-115-116 n1_1028960_1071520 n1_1028960_1032608 3.5374499999999998
R25-115-117 n1_1028960_1108000 n1_1028960_1071520 3.3163600000000004
R25-115-118 n1_1028960_1146912 n1_1028960_1108000 3.5374499999999998
R25-115-119 n1_1028960_1183392 n1_1028960_1146912 3.3163600000000004
R25-115-120 n1_1028960_1222304 n1_1028960_1183392 3.5374499999999998
R25-115-121 n1_1028960_1261216 n1_1028960_1222304 3.5374499999999998
R25-115-122 n1_1028960_1297696 n1_1028960_1261216 3.3163600000000004
R25-115-123 n1_1028960_1336608 n1_1028960_1297696 3.5374499999999998
R25-115-124 n1_1028960_1373088 n1_1028960_1336608 3.3163600000000004
R25-115-125 n1_1028960_1412000 n1_1028960_1373088 3.5374499999999998
R25-115-126 n1_1028960_1448480 n1_1028960_1412000 3.3163600000000004
R25-115-127 n1_1028960_1487392 n1_1028960_1448480 3.5374499999999998
R25-115-128 n1_1028960_1526304 n1_1028960_1487392 3.5374499999999998
R25-115-129 n1_1028960_1562784 n1_1028960_1526304 3.3163600000000004
R25-115-130 n1_1028960_1601696 n1_1028960_1562784 3.5374499999999998
R25-115-131 n1_1028960_1641130 n1_1028960_1601696 459.6989
R25-115-132 n1_1028960_1641290 n1_1028960_1641130 0.014545
R25-116-100 n1_1067872_480880 n1_1067872_480720 0.0145455
R25-116-101 n1_1067872_502432 n1_1067872_480880 1.95927
R25-116-102 n1_1067872_538912 n1_1067872_502432 3.3163600000000004
R25-116-103 n1_1067872_577824 n1_1067872_538912 3.5374499999999998
R25-116-104 n1_1067872_614304 n1_1067872_577824 3.3163600000000004
R25-116-105 n1_1067872_653216 n1_1067872_614304 3.5374499999999998
R25-116-106 n1_1067872_692128 n1_1067872_653216 3.5374499999999998
R25-116-107 n1_1067872_728608 n1_1067872_692128 3.3163600000000004
R25-116-108 n1_1067872_767520 n1_1067872_728608 3.5374499999999998
R25-116-109 n1_1067872_804000 n1_1067872_767520 3.3163600000000004
R25-116-110 n1_1067872_842912 n1_1067872_804000 3.5374499999999998
R25-116-111 n1_1067872_881824 n1_1067872_842912 3.5374499999999998
R25-116-112 n1_1067872_918304 n1_1067872_881824 3.3163600000000004
R25-116-113 n1_1067872_957216 n1_1067872_918304 3.5374499999999998
R25-116-114 n1_1067872_993696 n1_1067872_957216 3.3163600000000004
R25-116-115 n1_1067872_1032608 n1_1067872_993696 3.5374499999999998
R25-116-116 n1_1067872_1071520 n1_1067872_1032608 3.5374499999999998
R25-116-117 n1_1067872_1108000 n1_1067872_1071520 3.3163600000000004
R25-116-118 n1_1067872_1146912 n1_1067872_1108000 3.5374499999999998
R25-116-119 n1_1067872_1183392 n1_1067872_1146912 3.3163600000000004
R25-116-120 n1_1067872_1222304 n1_1067872_1183392 3.5374499999999998
R25-116-121 n1_1067872_1261216 n1_1067872_1222304 3.5374499999999998
R25-116-122 n1_1067872_1297696 n1_1067872_1261216 3.3163600000000004
R25-116-123 n1_1067872_1336608 n1_1067872_1297696 3.5374499999999998
R25-116-124 n1_1067872_1373088 n1_1067872_1336608 3.3163600000000004
R25-116-125 n1_1067872_1412000 n1_1067872_1373088 3.5374499999999998
R25-116-126 n1_1067872_1448480 n1_1067872_1412000 3.3163600000000004
R25-116-127 n1_1067872_1487392 n1_1067872_1448480 3.5374499999999998
R25-116-128 n1_1067872_1526304 n1_1067872_1487392 3.5374499999999998
R25-116-129 n1_1067872_1562784 n1_1067872_1526304 3.3163600000000004
R25-116-130 n1_1067872_1601696 n1_1067872_1562784 3.5374499999999998
R25-116-131 n1_1067872_1641130 n1_1067872_1601696 508.5741
R25-116-132 n1_1067872_1641290 n1_1067872_1641130 0.014545
R25-117-100 n1_1105568_480880 n1_1105568_480720 0.0145455
R25-117-101 n1_1105568_502432 n1_1105568_480880 1.95927
R25-117-102 n1_1105568_538912 n1_1105568_502432 3.3163600000000004
R25-117-103 n1_1105568_577824 n1_1105568_538912 3.5374499999999998
R25-117-104 n1_1105568_614304 n1_1105568_577824 3.3163600000000004
R25-117-105 n1_1105568_653216 n1_1105568_614304 3.5374499999999998
R25-117-106 n1_1105568_692128 n1_1105568_653216 3.5374499999999998
R25-117-107 n1_1105568_728608 n1_1105568_692128 3.3163600000000004
R25-117-108 n1_1105568_767520 n1_1105568_728608 3.5374499999999998
R25-117-109 n1_1105568_804000 n1_1105568_767520 3.3163600000000004
R25-117-110 n1_1105568_842912 n1_1105568_804000 3.5374499999999998
R25-117-111 n1_1105568_881824 n1_1105568_842912 3.5374499999999998
R25-117-112 n1_1105568_918304 n1_1105568_881824 3.3163600000000004
R25-117-113 n1_1105568_957216 n1_1105568_918304 3.5374499999999998
R25-117-114 n1_1105568_993696 n1_1105568_957216 3.3163600000000004
R25-117-115 n1_1105568_1032608 n1_1105568_993696 3.5374499999999998
R25-117-116 n1_1105568_1071520 n1_1105568_1032608 3.5374499999999998
R25-117-117 n1_1105568_1108000 n1_1105568_1071520 3.3163600000000004
R25-117-118 n1_1105568_1146912 n1_1105568_1108000 3.5374499999999998
R25-117-119 n1_1105568_1183392 n1_1105568_1146912 3.3163600000000004
R25-117-120 n1_1105568_1222304 n1_1105568_1183392 3.5374499999999998
R25-117-121 n1_1105568_1261216 n1_1105568_1222304 3.5374499999999998
R25-117-122 n1_1105568_1297696 n1_1105568_1261216 3.3163600000000004
R25-117-123 n1_1105568_1336608 n1_1105568_1297696 3.5374499999999998
R25-117-124 n1_1105568_1373088 n1_1105568_1336608 3.3163600000000004
R25-117-125 n1_1105568_1412000 n1_1105568_1373088 3.5374499999999998
R25-117-126 n1_1105568_1448480 n1_1105568_1412000 3.3163600000000004
R25-117-127 n1_1105568_1487392 n1_1105568_1448480 3.5374499999999998
R25-117-128 n1_1105568_1526304 n1_1105568_1487392 3.5374499999999998
R25-117-129 n1_1105568_1562784 n1_1105568_1526304 3.3163600000000004
R25-117-130 n1_1105568_1601696 n1_1105568_1562784 3.5374499999999998
R25-117-131 n1_1105568_1641130 n1_1105568_1601696 507.4866
R25-117-132 n1_1105568_1641290 n1_1105568_1641130 0.014545
R25-118-100 n1_1144480_480880 n1_1144480_480720 0.0145455
R25-118-101 n1_1144480_502432 n1_1144480_480880 1.95927
R25-118-102 n1_1144480_538912 n1_1144480_502432 3.3163600000000004
R25-118-103 n1_1144480_577824 n1_1144480_538912 3.5374499999999998
R25-118-104 n1_1144480_614304 n1_1144480_577824 3.3163600000000004
R25-118-105 n1_1144480_653216 n1_1144480_614304 3.5374499999999998
R25-118-106 n1_1144480_692128 n1_1144480_653216 3.5374499999999998
R25-118-107 n1_1144480_728608 n1_1144480_692128 3.3163600000000004
R25-118-108 n1_1144480_767520 n1_1144480_728608 3.5374499999999998
R25-118-109 n1_1144480_804000 n1_1144480_767520 3.3163600000000004
R25-118-110 n1_1144480_842912 n1_1144480_804000 3.5374499999999998
R25-118-111 n1_1144480_881824 n1_1144480_842912 3.5374499999999998
R25-118-112 n1_1144480_918304 n1_1144480_881824 3.3163600000000004
R25-118-113 n1_1144480_957216 n1_1144480_918304 3.5374499999999998
R25-118-114 n1_1144480_993696 n1_1144480_957216 3.3163600000000004
R25-118-115 n1_1144480_1032608 n1_1144480_993696 3.5374499999999998
R25-118-116 n1_1144480_1071520 n1_1144480_1032608 3.5374499999999998
R25-118-117 n1_1144480_1108000 n1_1144480_1071520 3.3163600000000004
R25-118-118 n1_1144480_1146912 n1_1144480_1108000 3.5374499999999998
R25-118-119 n1_1144480_1183392 n1_1144480_1146912 3.3163600000000004
R25-118-120 n1_1144480_1222304 n1_1144480_1183392 3.5374499999999998
R25-118-121 n1_1144480_1261216 n1_1144480_1222304 3.5374499999999998
R25-118-122 n1_1144480_1297696 n1_1144480_1261216 3.3163600000000004
R25-118-123 n1_1144480_1336608 n1_1144480_1297696 3.5374499999999998
R25-118-124 n1_1144480_1373088 n1_1144480_1336608 3.3163600000000004
R25-118-125 n1_1144480_1412000 n1_1144480_1373088 3.5374499999999998
R25-118-126 n1_1144480_1448480 n1_1144480_1412000 3.3163600000000004
R25-118-127 n1_1144480_1487392 n1_1144480_1448480 3.5374499999999998
R25-118-128 n1_1144480_1526304 n1_1144480_1487392 3.5374499999999998
R25-118-129 n1_1144480_1562784 n1_1144480_1526304 3.3163600000000004
R25-118-130 n1_1144480_1601696 n1_1144480_1562784 3.5374499999999998
R25-118-131 n1_1144480_1641130 n1_1144480_1601696 509.3973
R25-118-132 n1_1144480_1641290 n1_1144480_1641130 0.014545
R25-119-100 n1_1182176_480880 n1_1182176_480720 0.0145455
R25-119-101 n1_1182176_502432 n1_1182176_480880 1.95927
R25-119-102 n1_1182176_538912 n1_1182176_502432 3.3163600000000004
R25-119-103 n1_1182176_577824 n1_1182176_538912 3.5374499999999998
R25-119-104 n1_1182176_614304 n1_1182176_577824 3.3163600000000004
R25-119-105 n1_1182176_653216 n1_1182176_614304 3.5374499999999998
R25-119-106 n1_1182176_692128 n1_1182176_653216 3.5374499999999998
R25-119-107 n1_1182176_728608 n1_1182176_692128 3.3163600000000004
R25-119-108 n1_1182176_767520 n1_1182176_728608 3.5374499999999998
R25-119-109 n1_1182176_804000 n1_1182176_767520 3.3163600000000004
R25-119-110 n1_1182176_842912 n1_1182176_804000 3.5374499999999998
R25-119-111 n1_1182176_881824 n1_1182176_842912 3.5374499999999998
R25-119-112 n1_1182176_918304 n1_1182176_881824 3.3163600000000004
R25-119-113 n1_1182176_957216 n1_1182176_918304 3.5374499999999998
R25-119-114 n1_1182176_993696 n1_1182176_957216 3.3163600000000004
R25-119-115 n1_1182176_1032608 n1_1182176_993696 3.5374499999999998
R25-119-116 n1_1182176_1071520 n1_1182176_1032608 3.5374499999999998
R25-119-117 n1_1182176_1108000 n1_1182176_1071520 3.3163600000000004
R25-119-118 n1_1182176_1146912 n1_1182176_1108000 3.5374499999999998
R25-119-119 n1_1182176_1183392 n1_1182176_1146912 3.3163600000000004
R25-119-120 n1_1182176_1222304 n1_1182176_1183392 3.5374499999999998
R25-119-121 n1_1182176_1261216 n1_1182176_1222304 3.5374499999999998
R25-119-122 n1_1182176_1297696 n1_1182176_1261216 3.3163600000000004
R25-119-123 n1_1182176_1336608 n1_1182176_1297696 3.5374499999999998
R25-119-124 n1_1182176_1373088 n1_1182176_1336608 3.3163600000000004
R25-119-125 n1_1182176_1412000 n1_1182176_1373088 3.5374499999999998
R25-119-126 n1_1182176_1448480 n1_1182176_1412000 3.3163600000000004
R25-119-127 n1_1182176_1487392 n1_1182176_1448480 3.5374499999999998
R25-119-128 n1_1182176_1526304 n1_1182176_1487392 3.5374499999999998
R25-119-129 n1_1182176_1562784 n1_1182176_1526304 3.3163600000000004
R25-119-130 n1_1182176_1601696 n1_1182176_1562784 3.5374499999999998
R25-119-131 n1_1182176_1641130 n1_1182176_1601696 490.8738
R25-119-132 n1_1182176_1641290 n1_1182176_1641130 0.014545
R25-120-100 n1_1219872_480880 n1_1219872_480720 0.0145455
R25-120-101 n1_1219872_502432 n1_1219872_480880 1.95927
R25-120-102 n1_1219872_538912 n1_1219872_502432 3.3163600000000004
R25-120-103 n1_1219872_577824 n1_1219872_538912 3.5374499999999998
R25-120-104 n1_1219872_614304 n1_1219872_577824 3.3163600000000004
R25-120-105 n1_1219872_653216 n1_1219872_614304 3.5374499999999998
R25-120-106 n1_1219872_692128 n1_1219872_653216 3.5374499999999998
R25-120-107 n1_1219872_728608 n1_1219872_692128 3.3163600000000004
R25-120-108 n1_1219872_767520 n1_1219872_728608 3.5374499999999998
R25-120-109 n1_1219872_804000 n1_1219872_767520 3.3163600000000004
R25-120-110 n1_1219872_842912 n1_1219872_804000 3.5374499999999998
R25-120-111 n1_1219872_881824 n1_1219872_842912 3.5374499999999998
R25-120-112 n1_1219872_918304 n1_1219872_881824 3.3163600000000004
R25-120-113 n1_1219872_957216 n1_1219872_918304 3.5374499999999998
R25-120-114 n1_1219872_993696 n1_1219872_957216 3.3163600000000004
R25-120-115 n1_1219872_1032608 n1_1219872_993696 3.5374499999999998
R25-120-116 n1_1219872_1071520 n1_1219872_1032608 3.5374499999999998
R25-120-117 n1_1219872_1108000 n1_1219872_1071520 3.3163600000000004
R25-120-118 n1_1219872_1146912 n1_1219872_1108000 3.5374499999999998
R25-120-119 n1_1219872_1183392 n1_1219872_1146912 3.3163600000000004
R25-120-120 n1_1219872_1222304 n1_1219872_1183392 3.5374499999999998
R25-120-121 n1_1219872_1261216 n1_1219872_1222304 3.5374499999999998
R25-120-122 n1_1219872_1297696 n1_1219872_1261216 3.3163600000000004
R25-120-123 n1_1219872_1336608 n1_1219872_1297696 3.5374499999999998
R25-120-124 n1_1219872_1373088 n1_1219872_1336608 3.3163600000000004
R25-120-125 n1_1219872_1412000 n1_1219872_1373088 3.5374499999999998
R25-120-126 n1_1219872_1448480 n1_1219872_1412000 3.3163600000000004
R25-120-127 n1_1219872_1487392 n1_1219872_1448480 3.5374499999999998
R25-120-128 n1_1219872_1526304 n1_1219872_1487392 3.5374499999999998
R25-120-129 n1_1219872_1562784 n1_1219872_1526304 3.3163600000000004
R25-120-130 n1_1219872_1601696 n1_1219872_1562784 3.5374499999999998
R25-120-131 n1_1219872_1641130 n1_1219872_1601696 473.6007
R25-120-132 n1_1219872_1641290 n1_1219872_1641130 0.014545
R25-121-100 n1_1258784_480880 n1_1258784_480720 0.0145455
R25-121-101 n1_1258784_502432 n1_1258784_480880 1.95927
R25-121-102 n1_1258784_538912 n1_1258784_502432 3.3163600000000004
R25-121-103 n1_1258784_577824 n1_1258784_538912 3.5374499999999998
R25-121-104 n1_1258784_614304 n1_1258784_577824 3.3163600000000004
R25-121-105 n1_1258784_653216 n1_1258784_614304 3.5374499999999998
R25-121-106 n1_1258784_692128 n1_1258784_653216 3.5374499999999998
R25-121-107 n1_1258784_728608 n1_1258784_692128 3.3163600000000004
R25-121-108 n1_1258784_767520 n1_1258784_728608 3.5374499999999998
R25-121-109 n1_1258784_804000 n1_1258784_767520 3.3163600000000004
R25-121-110 n1_1258784_842912 n1_1258784_804000 3.5374499999999998
R25-121-111 n1_1258784_881824 n1_1258784_842912 3.5374499999999998
R25-121-112 n1_1258784_918304 n1_1258784_881824 3.3163600000000004
R25-121-113 n1_1258784_957216 n1_1258784_918304 3.5374499999999998
R25-121-114 n1_1258784_993696 n1_1258784_957216 3.3163600000000004
R25-121-115 n1_1258784_1032608 n1_1258784_993696 3.5374499999999998
R25-121-116 n1_1258784_1071520 n1_1258784_1032608 3.5374499999999998
R25-121-117 n1_1258784_1108000 n1_1258784_1071520 3.3163600000000004
R25-121-118 n1_1258784_1146912 n1_1258784_1108000 3.5374499999999998
R25-121-119 n1_1258784_1183392 n1_1258784_1146912 3.3163600000000004
R25-121-120 n1_1258784_1222304 n1_1258784_1183392 3.5374499999999998
R25-121-121 n1_1258784_1261216 n1_1258784_1222304 3.5374499999999998
R25-121-122 n1_1258784_1297696 n1_1258784_1261216 3.3163600000000004
R25-121-123 n1_1258784_1336608 n1_1258784_1297696 3.5374499999999998
R25-121-124 n1_1258784_1373088 n1_1258784_1336608 3.3163600000000004
R25-121-125 n1_1258784_1412000 n1_1258784_1373088 3.5374499999999998
R25-121-126 n1_1258784_1448480 n1_1258784_1412000 3.3163600000000004
R25-121-127 n1_1258784_1487392 n1_1258784_1448480 3.5374499999999998
R25-121-128 n1_1258784_1526304 n1_1258784_1487392 3.5374499999999998
R25-121-129 n1_1258784_1562784 n1_1258784_1526304 3.3163600000000004
R25-121-130 n1_1258784_1601696 n1_1258784_1562784 3.5374499999999998
R25-121-131 n1_1258784_1641130 n1_1258784_1601696 383.1791
R25-121-132 n1_1258784_1641290 n1_1258784_1641130 0.014545
R25-122-100 n1_1296480_480880 n1_1296480_480720 0.0145455
R25-122-101 n1_1296480_502432 n1_1296480_480880 1.95927
R25-122-102 n1_1296480_538912 n1_1296480_502432 3.3163600000000004
R25-122-103 n1_1296480_577824 n1_1296480_538912 3.5374499999999998
R25-122-104 n1_1296480_614304 n1_1296480_577824 3.3163600000000004
R25-122-105 n1_1296480_653216 n1_1296480_614304 3.5374499999999998
R25-122-106 n1_1296480_692128 n1_1296480_653216 3.5374499999999998
R25-122-107 n1_1296480_728608 n1_1296480_692128 3.3163600000000004
R25-122-108 n1_1296480_767520 n1_1296480_728608 3.5374499999999998
R25-122-109 n1_1296480_804000 n1_1296480_767520 3.3163600000000004
R25-122-110 n1_1296480_842912 n1_1296480_804000 3.5374499999999998
R25-122-111 n1_1296480_881824 n1_1296480_842912 3.5374499999999998
R25-122-112 n1_1296480_918304 n1_1296480_881824 3.3163600000000004
R25-122-113 n1_1296480_957216 n1_1296480_918304 3.5374499999999998
R25-122-114 n1_1296480_993696 n1_1296480_957216 3.3163600000000004
R25-122-115 n1_1296480_1032608 n1_1296480_993696 3.5374499999999998
R25-122-116 n1_1296480_1071520 n1_1296480_1032608 3.5374499999999998
R25-122-117 n1_1296480_1108000 n1_1296480_1071520 3.3163600000000004
R25-122-118 n1_1296480_1146912 n1_1296480_1108000 3.5374499999999998
R25-122-119 n1_1296480_1183392 n1_1296480_1146912 3.3163600000000004
R25-122-120 n1_1296480_1222304 n1_1296480_1183392 3.5374499999999998
R25-122-121 n1_1296480_1261216 n1_1296480_1222304 3.5374499999999998
R25-122-122 n1_1296480_1297696 n1_1296480_1261216 3.3163600000000004
R25-122-123 n1_1296480_1336608 n1_1296480_1297696 3.5374499999999998
R25-122-124 n1_1296480_1373088 n1_1296480_1336608 3.3163600000000004
R25-122-125 n1_1296480_1412000 n1_1296480_1373088 3.5374499999999998
R25-122-126 n1_1296480_1448480 n1_1296480_1412000 3.3163600000000004
R25-122-127 n1_1296480_1487392 n1_1296480_1448480 3.5374499999999998
R25-122-128 n1_1296480_1526304 n1_1296480_1487392 3.5374499999999998
R25-122-129 n1_1296480_1562784 n1_1296480_1526304 3.3163600000000004
R25-122-130 n1_1296480_1601696 n1_1296480_1562784 9.979
R25-122-131 n1_1296480_1641130 n1_1296480_1601696 351.776
R25-122-132 n1_1296480_1641290 n1_1296480_1641130 0.014545
R25-123-100 n1_1335392_480880 n1_1335392_480720 0.0145455
R25-123-101 n1_1335392_502432 n1_1335392_480880 1.95927
R25-123-102 n1_1335392_538912 n1_1335392_502432 3.3163600000000004
R25-123-103 n1_1335392_577824 n1_1335392_538912 3.5374499999999998
R25-123-104 n1_1335392_614304 n1_1335392_577824 3.3163600000000004
R25-123-105 n1_1335392_653216 n1_1335392_614304 3.5374499999999998
R25-123-106 n1_1335392_692128 n1_1335392_653216 3.5374499999999998
R25-123-107 n1_1335392_728608 n1_1335392_692128 3.3163600000000004
R25-123-108 n1_1335392_767520 n1_1335392_728608 3.5374499999999998
R25-123-109 n1_1335392_804000 n1_1335392_767520 3.3163600000000004
R25-123-110 n1_1335392_842912 n1_1335392_804000 3.5374499999999998
R25-123-111 n1_1335392_881824 n1_1335392_842912 3.5374499999999998
R25-123-112 n1_1335392_918304 n1_1335392_881824 3.3163600000000004
R25-123-113 n1_1335392_957216 n1_1335392_918304 3.5374499999999998
R25-123-114 n1_1335392_993696 n1_1335392_957216 3.3163600000000004
R25-123-115 n1_1335392_1032608 n1_1335392_993696 3.5374499999999998
R25-123-116 n1_1335392_1071520 n1_1335392_1032608 3.5374499999999998
R25-123-117 n1_1335392_1108000 n1_1335392_1071520 3.3163600000000004
R25-123-118 n1_1335392_1146912 n1_1335392_1108000 3.5374499999999998
R25-123-119 n1_1335392_1183392 n1_1335392_1146912 3.3163600000000004
R25-123-120 n1_1335392_1222304 n1_1335392_1183392 3.5374499999999998
R25-123-121 n1_1335392_1261216 n1_1335392_1222304 3.5374499999999998
R25-123-122 n1_1335392_1297696 n1_1335392_1261216 3.3163600000000004
R25-123-123 n1_1335392_1336608 n1_1335392_1297696 3.5374499999999998
R25-123-124 n1_1335392_1373088 n1_1335392_1336608 3.3163600000000004
R25-123-125 n1_1335392_1412000 n1_1335392_1373088 3.5374499999999998
R25-123-126 n1_1335392_1448480 n1_1335392_1412000 3.3163600000000004
R25-123-127 n1_1335392_1487392 n1_1335392_1448480 3.5374499999999998
R25-123-128 n1_1335392_1526304 n1_1335392_1487392 3.5374499999999998
R25-123-129 n1_1335392_1562784 n1_1335392_1526304 7.9446
R25-123-130 n1_1335392_1601696 n1_1335392_1562784 56.142
R25-123-131 n1_1335392_1641130 n1_1335392_1601696 245.6354
R25-123-132 n1_1335392_1641290 n1_1335392_1641130 0.014545
R25-124-100 n1_1373088_480880 n1_1373088_480720 0.0145455
R25-124-101 n1_1373088_502432 n1_1373088_480880 1.95927
R25-124-102 n1_1373088_538912 n1_1373088_502432 3.3163600000000004
R25-124-103 n1_1373088_577824 n1_1373088_538912 3.5374499999999998
R25-124-104 n1_1373088_614304 n1_1373088_577824 3.3163600000000004
R25-124-105 n1_1373088_653216 n1_1373088_614304 3.5374499999999998
R25-124-106 n1_1373088_692128 n1_1373088_653216 3.5374499999999998
R25-124-107 n1_1373088_728608 n1_1373088_692128 3.3163600000000004
R25-124-108 n1_1373088_767520 n1_1373088_728608 3.5374499999999998
R25-124-109 n1_1373088_804000 n1_1373088_767520 3.3163600000000004
R25-124-110 n1_1373088_842912 n1_1373088_804000 3.5374499999999998
R25-124-111 n1_1373088_881824 n1_1373088_842912 3.5374499999999998
R25-124-112 n1_1373088_918304 n1_1373088_881824 3.3163600000000004
R25-124-113 n1_1373088_957216 n1_1373088_918304 3.5374499999999998
R25-124-114 n1_1373088_993696 n1_1373088_957216 3.3163600000000004
R25-124-115 n1_1373088_1032608 n1_1373088_993696 3.5374499999999998
R25-124-116 n1_1373088_1071520 n1_1373088_1032608 3.5374499999999998
R25-124-117 n1_1373088_1108000 n1_1373088_1071520 3.3163600000000004
R25-124-118 n1_1373088_1146912 n1_1373088_1108000 3.5374499999999998
R25-124-119 n1_1373088_1183392 n1_1373088_1146912 3.3163600000000004
R25-124-120 n1_1373088_1222304 n1_1373088_1183392 3.5374499999999998
R25-124-121 n1_1373088_1261216 n1_1373088_1222304 3.5374499999999998
R25-124-122 n1_1373088_1297696 n1_1373088_1261216 3.3163600000000004
R25-124-123 n1_1373088_1336608 n1_1373088_1297696 3.5374499999999998
R25-124-124 n1_1373088_1373088 n1_1373088_1336608 3.3163600000000004
R25-124-125 n1_1373088_1412000 n1_1373088_1373088 3.5374499999999998
R25-124-126 n1_1373088_1448480 n1_1373088_1412000 3.3163600000000004
R25-124-127 n1_1373088_1487392 n1_1373088_1448480 3.5374499999999998
R25-124-128 n1_1373088_1526304 n1_1373088_1487392 6.1343
R25-124-129 n1_1373088_1562784 n1_1373088_1526304 44.8952
R25-124-130 n1_1373088_1601696 n1_1373088_1562784 65.1262
R25-124-131 n1_1373088_1641130 n1_1373088_1601696 150.4494
R25-124-132 n1_1373088_1641290 n1_1373088_1641130 0.014545
R25-125-100 n1_1412000_480880 n1_1412000_480720 0.0145455
R25-125-101 n1_1412000_502432 n1_1412000_480880 1.95927
R25-125-102 n1_1412000_538912 n1_1412000_502432 3.3163600000000004
R25-125-103 n1_1412000_577824 n1_1412000_538912 3.5374499999999998
R25-125-104 n1_1412000_614304 n1_1412000_577824 3.3163600000000004
R25-125-105 n1_1412000_653216 n1_1412000_614304 3.5374499999999998
R25-125-106 n1_1412000_692128 n1_1412000_653216 3.5374499999999998
R25-125-107 n1_1412000_728608 n1_1412000_692128 3.3163600000000004
R25-125-108 n1_1412000_767520 n1_1412000_728608 3.5374499999999998
R25-125-109 n1_1412000_804000 n1_1412000_767520 3.3163600000000004
R25-125-110 n1_1412000_842912 n1_1412000_804000 3.5374499999999998
R25-125-111 n1_1412000_881824 n1_1412000_842912 3.5374499999999998
R25-125-112 n1_1412000_918304 n1_1412000_881824 3.3163600000000004
R25-125-113 n1_1412000_957216 n1_1412000_918304 3.5374499999999998
R25-125-114 n1_1412000_993696 n1_1412000_957216 3.3163600000000004
R25-125-115 n1_1412000_1032608 n1_1412000_993696 3.5374499999999998
R25-125-116 n1_1412000_1071520 n1_1412000_1032608 3.5374499999999998
R25-125-117 n1_1412000_1108000 n1_1412000_1071520 3.3163600000000004
R25-125-118 n1_1412000_1146912 n1_1412000_1108000 3.5374499999999998
R25-125-119 n1_1412000_1183392 n1_1412000_1146912 3.3163600000000004
R25-125-120 n1_1412000_1222304 n1_1412000_1183392 3.5374499999999998
R25-125-121 n1_1412000_1261216 n1_1412000_1222304 3.5374499999999998
R25-125-122 n1_1412000_1297696 n1_1412000_1261216 3.3163600000000004
R25-125-123 n1_1412000_1336608 n1_1412000_1297696 3.5374499999999998
R25-125-124 n1_1412000_1373088 n1_1412000_1336608 3.3163600000000004
R25-125-125 n1_1412000_1412000 n1_1412000_1373088 3.5374499999999998
R25-125-126 n1_1412000_1448480 n1_1412000_1412000 3.3163600000000004
R25-125-127 n1_1412000_1487392 n1_1412000_1448480 3.5374499999999998
R25-125-128 n1_1412000_1526304 n1_1412000_1487392 3.5374499999999998
R25-125-129 n1_1412000_1562784 n1_1412000_1526304 3.3163600000000004
R25-125-130 n1_1412000_1601696 n1_1412000_1562784 3.5374499999999998
R25-125-131 n1_1412000_1641130 n1_1412000_1601696 20.3115
R25-125-132 n1_1412000_1641290 n1_1412000_1641130 0.014545
R25-126-100 n1_1449696_480880 n1_1449696_480720 0.0145455
R25-126-101 n1_1449696_502432 n1_1449696_480880 1.95927
R25-126-102 n1_1449696_538912 n1_1449696_502432 3.3163600000000004
R25-126-103 n1_1449696_577824 n1_1449696_538912 3.5374499999999998
R25-126-104 n1_1449696_614304 n1_1449696_577824 3.3163600000000004
R25-126-105 n1_1449696_653216 n1_1449696_614304 3.5374499999999998
R25-126-106 n1_1449696_692128 n1_1449696_653216 3.5374499999999998
R25-126-107 n1_1449696_728608 n1_1449696_692128 3.3163600000000004
R25-126-108 n1_1449696_767520 n1_1449696_728608 3.5374499999999998
R25-126-109 n1_1449696_804000 n1_1449696_767520 3.3163600000000004
R25-126-110 n1_1449696_842912 n1_1449696_804000 3.5374499999999998
R25-126-111 n1_1449696_881824 n1_1449696_842912 3.5374499999999998
R25-126-112 n1_1449696_918304 n1_1449696_881824 3.3163600000000004
R25-126-113 n1_1449696_957216 n1_1449696_918304 3.5374499999999998
R25-126-114 n1_1449696_993696 n1_1449696_957216 3.3163600000000004
R25-126-115 n1_1449696_1032608 n1_1449696_993696 3.5374499999999998
R25-126-116 n1_1449696_1071520 n1_1449696_1032608 3.5374499999999998
R25-126-117 n1_1449696_1108000 n1_1449696_1071520 3.3163600000000004
R25-126-118 n1_1449696_1146912 n1_1449696_1108000 3.5374499999999998
R25-126-119 n1_1449696_1183392 n1_1449696_1146912 3.3163600000000004
R25-126-120 n1_1449696_1222304 n1_1449696_1183392 3.5374499999999998
R25-126-121 n1_1449696_1261216 n1_1449696_1222304 3.5374499999999998
R25-126-122 n1_1449696_1297696 n1_1449696_1261216 3.3163600000000004
R25-126-123 n1_1449696_1336608 n1_1449696_1297696 3.5374499999999998
R25-126-124 n1_1449696_1373088 n1_1449696_1336608 3.3163600000000004
R25-126-125 n1_1449696_1412000 n1_1449696_1373088 3.5374499999999998
R25-126-126 n1_1449696_1448480 n1_1449696_1412000 3.3163600000000004
R25-126-127 n1_1449696_1487392 n1_1449696_1448480 3.5374499999999998
R25-126-128 n1_1449696_1526304 n1_1449696_1487392 3.5374499999999998
R25-126-129 n1_1449696_1562784 n1_1449696_1526304 3.3163600000000004
R25-126-130 n1_1449696_1601696 n1_1449696_1562784 3.5374499999999998
R25-126-131 n1_1449696_1641130 n1_1449696_1601696 23.8225
R25-126-132 n1_1449696_1641290 n1_1449696_1641130 0.014545
R25-127-100 n1_1487392_480880 n1_1487392_480720 0.0145455
R25-127-101 n1_1487392_502432 n1_1487392_480880 1.95927
R25-127-102 n1_1487392_538912 n1_1487392_502432 3.3163600000000004
R25-127-103 n1_1487392_577824 n1_1487392_538912 3.5374499999999998
R25-127-104 n1_1487392_614304 n1_1487392_577824 3.3163600000000004
R25-127-105 n1_1487392_653216 n1_1487392_614304 3.5374499999999998
R25-127-106 n1_1487392_692128 n1_1487392_653216 3.5374499999999998
R25-127-107 n1_1487392_728608 n1_1487392_692128 3.3163600000000004
R25-127-108 n1_1487392_767520 n1_1487392_728608 3.5374499999999998
R25-127-109 n1_1487392_804000 n1_1487392_767520 3.3163600000000004
R25-127-110 n1_1487392_842912 n1_1487392_804000 3.5374499999999998
R25-127-111 n1_1487392_881824 n1_1487392_842912 3.5374499999999998
R25-127-112 n1_1487392_918304 n1_1487392_881824 3.3163600000000004
R25-127-113 n1_1487392_957216 n1_1487392_918304 3.5374499999999998
R25-127-114 n1_1487392_993696 n1_1487392_957216 3.3163600000000004
R25-127-115 n1_1487392_1032608 n1_1487392_993696 3.5374499999999998
R25-127-116 n1_1487392_1071520 n1_1487392_1032608 3.5374499999999998
R25-127-117 n1_1487392_1108000 n1_1487392_1071520 3.3163600000000004
R25-127-118 n1_1487392_1146912 n1_1487392_1108000 3.5374499999999998
R25-127-119 n1_1487392_1183392 n1_1487392_1146912 3.3163600000000004
R25-127-120 n1_1487392_1222304 n1_1487392_1183392 3.5374499999999998
R25-127-121 n1_1487392_1261216 n1_1487392_1222304 3.5374499999999998
R25-127-122 n1_1487392_1297696 n1_1487392_1261216 3.3163600000000004
R25-127-123 n1_1487392_1336608 n1_1487392_1297696 3.5374499999999998
R25-127-124 n1_1487392_1373088 n1_1487392_1336608 3.3163600000000004
R25-127-125 n1_1487392_1412000 n1_1487392_1373088 3.5374499999999998
R25-127-126 n1_1487392_1448480 n1_1487392_1412000 3.3163600000000004
R25-127-127 n1_1487392_1487392 n1_1487392_1448480 3.5374499999999998
R25-127-128 n1_1487392_1526304 n1_1487392_1487392 3.5374499999999998
R25-127-129 n1_1487392_1562784 n1_1487392_1526304 3.3163600000000004
R25-127-130 n1_1487392_1601696 n1_1487392_1562784 3.5374499999999998
R25-127-131 n1_1487392_1641130 n1_1487392_1601696 22.6506
R25-127-132 n1_1487392_1641290 n1_1487392_1641130 0.014545
R25-128-100 n1_1526304_480880 n1_1526304_480720 0.0145455
R25-128-101 n1_1526304_502432 n1_1526304_480880 1.95927
R25-128-102 n1_1526304_538912 n1_1526304_502432 3.3163600000000004
R25-128-103 n1_1526304_577824 n1_1526304_538912 3.5374499999999998
R25-128-104 n1_1526304_614304 n1_1526304_577824 3.3163600000000004
R25-128-105 n1_1526304_653216 n1_1526304_614304 3.5374499999999998
R25-128-106 n1_1526304_692128 n1_1526304_653216 3.5374499999999998
R25-128-107 n1_1526304_728608 n1_1526304_692128 3.3163600000000004
R25-128-108 n1_1526304_767520 n1_1526304_728608 3.5374499999999998
R25-128-109 n1_1526304_804000 n1_1526304_767520 3.3163600000000004
R25-128-110 n1_1526304_842912 n1_1526304_804000 3.5374499999999998
R25-128-111 n1_1526304_881824 n1_1526304_842912 3.5374499999999998
R25-128-112 n1_1526304_918304 n1_1526304_881824 3.3163600000000004
R25-128-113 n1_1526304_957216 n1_1526304_918304 3.5374499999999998
R25-128-114 n1_1526304_993696 n1_1526304_957216 3.3163600000000004
R25-128-115 n1_1526304_1032608 n1_1526304_993696 3.5374499999999998
R25-128-116 n1_1526304_1071520 n1_1526304_1032608 3.5374499999999998
R25-128-117 n1_1526304_1108000 n1_1526304_1071520 3.3163600000000004
R25-128-118 n1_1526304_1146912 n1_1526304_1108000 3.5374499999999998
R25-128-119 n1_1526304_1183392 n1_1526304_1146912 3.3163600000000004
R25-128-120 n1_1526304_1222304 n1_1526304_1183392 3.5374499999999998
R25-128-121 n1_1526304_1261216 n1_1526304_1222304 3.5374499999999998
R25-128-122 n1_1526304_1297696 n1_1526304_1261216 3.3163600000000004
R25-128-123 n1_1526304_1336608 n1_1526304_1297696 3.5374499999999998
R25-128-124 n1_1526304_1373088 n1_1526304_1336608 3.3163600000000004
R25-128-125 n1_1526304_1412000 n1_1526304_1373088 3.5374499999999998
R25-128-126 n1_1526304_1448480 n1_1526304_1412000 3.3163600000000004
R25-128-127 n1_1526304_1487392 n1_1526304_1448480 3.5374499999999998
R25-128-128 n1_1526304_1526304 n1_1526304_1487392 3.5374499999999998
R25-128-129 n1_1526304_1562784 n1_1526304_1526304 3.3163600000000004
R25-128-130 n1_1526304_1601696 n1_1526304_1562784 3.5374499999999998
R25-128-131 n1_1526304_1641130 n1_1526304_1601696 22.1706
R25-128-132 n1_1526304_1641290 n1_1526304_1641130 0.014545
R25-129-100 n1_1564000_480880 n1_1564000_480720 0.014545
R25-129-101 n1_1564000_502432 n1_1564000_480880 45.4908
R25-129-102 n1_1564000_538912 n1_1564000_502432 3.3163600000000004
R25-129-103 n1_1564000_577824 n1_1564000_538912 3.5374499999999998
R25-129-104 n1_1564000_614304 n1_1564000_577824 3.3163600000000004
R25-129-105 n1_1564000_653216 n1_1564000_614304 3.5374499999999998
R25-129-106 n1_1564000_692128 n1_1564000_653216 3.5374499999999998
R25-129-107 n1_1564000_728608 n1_1564000_692128 3.3163600000000004
R25-129-108 n1_1564000_767520 n1_1564000_728608 3.5374499999999998
R25-129-109 n1_1564000_804000 n1_1564000_767520 3.3163600000000004
R25-129-110 n1_1564000_842912 n1_1564000_804000 3.5374499999999998
R25-129-111 n1_1564000_881824 n1_1564000_842912 3.5374499999999998
R25-129-112 n1_1564000_918304 n1_1564000_881824 3.3163600000000004
R25-129-113 n1_1564000_957216 n1_1564000_918304 3.5374499999999998
R25-129-114 n1_1564000_993696 n1_1564000_957216 3.3163600000000004
R25-129-115 n1_1564000_1032608 n1_1564000_993696 3.5374499999999998
R25-129-116 n1_1564000_1071520 n1_1564000_1032608 3.5374499999999998
R25-129-117 n1_1564000_1108000 n1_1564000_1071520 3.3163600000000004
R25-129-118 n1_1564000_1146912 n1_1564000_1108000 3.5374499999999998
R25-129-119 n1_1564000_1183392 n1_1564000_1146912 3.3163600000000004
R25-129-120 n1_1564000_1222304 n1_1564000_1183392 3.5374499999999998
R25-129-121 n1_1564000_1261216 n1_1564000_1222304 3.5374499999999998
R25-129-122 n1_1564000_1297696 n1_1564000_1261216 3.3163600000000004
R25-129-123 n1_1564000_1336608 n1_1564000_1297696 3.5374499999999998
R25-129-124 n1_1564000_1373088 n1_1564000_1336608 3.3163600000000004
R25-129-125 n1_1564000_1412000 n1_1564000_1373088 3.5374499999999998
R25-129-126 n1_1564000_1448480 n1_1564000_1412000 3.3163600000000004
R25-129-127 n1_1564000_1487392 n1_1564000_1448480 3.5374499999999998
R25-129-128 n1_1564000_1526304 n1_1564000_1487392 7.7023
R25-129-129 n1_1564000_1562784 n1_1564000_1526304 44.4095
R25-129-130 n1_1564000_1601696 n1_1564000_1562784 63.7844
R25-129-131 n1_1564000_1641130 n1_1564000_1601696 72.3095
R25-129-132 n1_1564000_1641290 n1_1564000_1641130 0.014545
R25-130-100 n1_1602912_480880 n1_1602912_480720 0.015265
R25-130-101 n1_1602912_502432 n1_1602912_480880 163.7331
R25-130-102 n1_1602912_538912 n1_1602912_502432 3.3163600000000004
R25-130-103 n1_1602912_577824 n1_1602912_538912 3.5374499999999998
R25-130-104 n1_1602912_614304 n1_1602912_577824 3.3163600000000004
R25-130-105 n1_1602912_653216 n1_1602912_614304 3.5374499999999998
R25-130-106 n1_1602912_692128 n1_1602912_653216 3.5374499999999998
R25-130-107 n1_1602912_728608 n1_1602912_692128 3.3163600000000004
R25-130-108 n1_1602912_767520 n1_1602912_728608 3.5374499999999998
R25-130-109 n1_1602912_804000 n1_1602912_767520 3.3163600000000004
R25-130-110 n1_1602912_842912 n1_1602912_804000 3.5374499999999998
R25-130-111 n1_1602912_881824 n1_1602912_842912 3.5374499999999998
R25-130-112 n1_1602912_918304 n1_1602912_881824 3.3163600000000004
R25-130-113 n1_1602912_957216 n1_1602912_918304 3.5374499999999998
R25-130-114 n1_1602912_993696 n1_1602912_957216 3.3163600000000004
R25-130-115 n1_1602912_1032608 n1_1602912_993696 3.5374499999999998
R25-130-116 n1_1602912_1071520 n1_1602912_1032608 3.5374499999999998
R25-130-117 n1_1602912_1108000 n1_1602912_1071520 3.3163600000000004
R25-130-118 n1_1602912_1146912 n1_1602912_1108000 3.5374499999999998
R25-130-119 n1_1602912_1183392 n1_1602912_1146912 3.3163600000000004
R25-130-120 n1_1602912_1222304 n1_1602912_1183392 3.5374499999999998
R25-130-121 n1_1602912_1261216 n1_1602912_1222304 3.5374499999999998
R25-130-122 n1_1602912_1297696 n1_1602912_1261216 3.3163600000000004
R25-130-123 n1_1602912_1336608 n1_1602912_1297696 3.5374499999999998
R25-130-124 n1_1602912_1373088 n1_1602912_1336608 3.3163600000000004
R25-130-125 n1_1602912_1412000 n1_1602912_1373088 3.5374499999999998
R25-130-126 n1_1602912_1448480 n1_1602912_1412000 3.3163600000000004
R25-130-127 n1_1602912_1487392 n1_1602912_1448480 3.5374499999999998
R25-130-128 n1_1602912_1526304 n1_1602912_1487392 3.5374499999999998
R25-130-129 n1_1602912_1562784 n1_1602912_1526304 3.3163600000000004
R25-130-130 n1_1602912_1601696 n1_1602912_1562784 3.5374499999999998
R25-130-131 n1_1602912_1641130 n1_1602912_1601696 23.1338
R25-130-132 n1_1602912_1641290 n1_1602912_1641130 0.014545
R25-131-100 n1_1641180_480880 n1_1641180_480720 0.007273
R25-131-101 n1_1641180_502432 n1_1641180_480880 162.1945
R25-131-102 n1_1641180_538912 n1_1641180_502432 1.6581800000000002
R25-131-103 n1_1641180_577824 n1_1641180_538912 1.7687300000000001
R25-131-104 n1_1641180_614304 n1_1641180_577824 1.6581800000000002
R25-131-105 n1_1641180_653216 n1_1641180_614304 1.7687300000000001
R25-131-106 n1_1641180_692128 n1_1641180_653216 1.7687300000000001
R25-131-107 n1_1641180_728608 n1_1641180_692128 1.6581800000000002
R25-131-108 n1_1641180_767520 n1_1641180_728608 1.7687300000000001
R25-131-109 n1_1641180_804000 n1_1641180_767520 1.6581800000000002
R25-131-110 n1_1641180_842912 n1_1641180_804000 1.7687300000000001
R25-131-111 n1_1641180_881824 n1_1641180_842912 1.7687300000000001
R25-131-112 n1_1641180_918304 n1_1641180_881824 1.6581800000000002
R25-131-113 n1_1641180_957216 n1_1641180_918304 1.7687300000000001
R25-131-114 n1_1641180_993696 n1_1641180_957216 1.6581800000000002
R25-131-115 n1_1641180_1032608 n1_1641180_993696 1.7687300000000001
R25-131-116 n1_1641180_1071520 n1_1641180_1032608 1.7687300000000001
R25-131-117 n1_1641180_1108000 n1_1641180_1071520 1.6581800000000002
R25-131-118 n1_1641180_1146912 n1_1641180_1108000 1.7687300000000001
R25-131-119 n1_1641180_1183392 n1_1641180_1146912 1.6581800000000002
R25-131-120 n1_1641180_1222304 n1_1641180_1183392 1.7687300000000001
R25-131-121 n1_1641180_1261216 n1_1641180_1222304 1.7687300000000001
R25-131-122 n1_1641180_1297696 n1_1641180_1261216 1.6581800000000002
R25-131-123 n1_1641180_1336608 n1_1641180_1297696 1.7687300000000001
R25-131-124 n1_1641180_1373088 n1_1641180_1336608 1.6581800000000002
R25-131-125 n1_1641180_1412000 n1_1641180_1373088 1.7687300000000001
R25-131-126 n1_1641180_1448480 n1_1641180_1412000 1.6581800000000002
R25-131-127 n1_1641180_1487392 n1_1641180_1448480 1.7687300000000001
R25-131-128 n1_1641180_1526304 n1_1641180_1487392 1.7687300000000001
R25-131-129 n1_1641180_1562784 n1_1641180_1526304 1.6581800000000002
R25-131-130 n1_1641180_1601696 n1_1641180_1562784 1.7687300000000001
R25-131-131 n1_1641180_1619905 n1_1641180_1601696 32.795
R25-131-132 n1_1641180_1641130 n1_1641180_1619905 0.92449
R25-131-133 n1_1641180_1641290 n1_1641180_1641130 0.00727273
R41-100-100 n1_979937_1641130 n1_979937_1640970 0.0028
R41-100-101 n1_979937_1820000 n1_979937_1641130 3.13023
R41-100-102 n1_979937_1825000 n1_979937_1820000 0.0875
R41-101-100 n1_1620161_300000 n1_1620161_295000 0.0875
R41-101-101 n1_1620161_480880 n1_1620161_300000 3.1654
R41-101-102 n1_1620161_481040 n1_1620161_480880 0.0028
iB00_0_v n1_295000_940095 0 -0.0004133276
iB00_1_v n1_300000_940095 0 -0.0046292344000000004
iB00_2_v n1_474796_940095 0 1.497960826560285e-15
iB00_3_v n1_474906_940095 0 -1.498168e-15
iB00_4_v n1_474796_918304 0 -2.371692252312041e-19
iB00_5_v n1_474796_957216 0 1.1858461261560205e-19
iB00_6_v n1_474796_993696 0 0.0
iB00_7_v n1_493920_957216 0 1.6114700000000014e-05
iB00_8_v n1_474686_957216 0 0.0
iB00_9_v n1_532832_957216 0 4.7870480000000075e-05
iB00_10_v n1_493920_918304 0 1.4998900000000017e-05
iB00_11_v n1_493920_993696 0 1.0150000000000021e-05
iB00_12_v n1_493920_1032608 0 2.0301399999999904e-05
iB00_13_v n1_532832_993696 0 3.458182000000004e-05
iB00_14_v n1_474686_993696 0 0.0
iB00_15_v n1_474796_1032608 0 -2.7999999999587057e-09
iB00_16_v n1_474796_1071520 0 0.0
iB00_17_v n1_474686_1032608 0 0.0
iB00_18_v n1_532832_1032608 0 3.778460000000001e-05
iB00_19_v n1_493920_1071520 0 2.0300699999999973e-05
iB00_20_v n1_493920_1108000 0 1.4998200000000012e-05
iB00_21_v n1_532832_1071520 0 4.13616e-05
iB00_22_v n1_474686_1071520 0 0.0
iB00_23_v n1_474796_1108000 0 -6.999999999896764e-10
iB00_24_v n1_474796_1146912 0 0.0
iB00_25_v n1_474686_1108000 0 0.0
iB00_26_v n1_532832_1108000 0 2.968615999999997e-05
iB00_27_v n1_493920_1146912 0 1.1655000000000001e-05
iB00_28_v n1_493920_1183392 0 2.0300559999999984e-05
iB00_29_v n1_532832_1146912 0 5.0531179999999993e-05
iB00_30_v n1_474686_1146912 0 0.0
iB00_31_v n1_474796_1183392 0 1.4823076576950256e-20
iB00_32_v n1_474796_1222304 0 7.000000000193226e-11
iB00_33_v n1_474686_1183392 0 0.0
iB00_34_v n1_532832_1183392 0 3.3503364999999986e-05
iB00_35_v n1_493920_1222304 0 1.0150560000000008e-05
iB00_36_v n1_493920_1261216 0 2.030091e-05
iB00_37_v n1_532832_1222304 0 3.665658499999998e-05
iB00_38_v n1_474686_1222304 0 0.0
iB00_39_v n1_474796_1261216 0 -4.8999999999870274e-11
iB00_40_v n1_474796_1297696 0 4.8999999992458735e-11
iB00_41_v n1_474686_1261216 0 0.0
iB00_42_v n1_532832_1261216 0 3.9542230000000004e-05
iB00_43_v n1_493920_1297696 0 1.8874870000000002e-05
iB00_44_v n1_493920_1336608 0 1.8969299999999995e-05
iB00_45_v n1_532832_1297696 0 4.496380000000001e-05
iB00_46_v n1_474686_1297696 0 0.0
iB00_47_v n1_474796_1336608 0 -1.3999999999645298e-10
iB00_48_v n1_474796_1373088 0 -7.000000000193226e-11
iB00_49_v n1_474686_1336608 0 0.0
iB00_50_v n1_532832_1336608 0 4.386158e-05
iB00_51_v n1_493920_1373088 0 2.0623959999999995e-05
iB00_52_v n1_493920_1412000 0 1.3639759e-05
iB00_53_v n1_532832_1373088 0 3.634316000000001e-05
iB00_54_v n1_474686_1373088 0 0.0
iB00_55_v n1_474796_1412000 0 1.3999999999830586e-10
iB00_56_v n1_474796_1448480 0 2.7999999999290596e-10
iB00_57_v n1_474686_1412000 0 0.0
iB00_58_v n1_532832_1412000 0 3.045114099999999e-05
iB00_59_v n1_493920_1448480 0 2.0300665000000008e-05
iB00_60_v n1_493920_1487392 0 1.8041759400000012e-05
iB00_61_v n1_532832_1448480 0 3.5932785000000015e-05
iB00_62_v n1_474686_1448480 0 0.0
iB00_63_v n1_474796_1487392 0 -6.593999999982741e-10
iB00_64_v n1_474796_1526304 0 2.8000000000772904e-10
iB00_65_v n1_474686_1487392 0 0.0
iB00_66_v n1_532832_1487392 0 4.622940000000001e-05
iB00_67_v n1_493920_1526304 0 1.122204999999999e-05
iB00_68_v n1_493920_1562784 0 2.0300910000000015e-05
iB00_69_v n1_532832_1526304 0 3.575684e-05
iB00_70_v n1_474686_1526304 0 0.0
iB00_71_v n1_474796_1562784 0 -1.3999999999645298e-10
iB00_72_v n1_474796_1601696 0 2.7999999999290596e-10
iB00_73_v n1_474686_1562784 0 0.0
iB00_74_v n1_532832_1562784 0 5.9476760000000003e-05
iB00_75_v n1_493920_1601696 0 1.0150419999999997e-05
iB00_76_v n1_493920_1641130 0 -2.0999833035261986e-10
iB00_77_v n1_532832_1601696 0 5.595190999999999e-05
iB00_78_v n1_474686_1601696 0 0.0
iB00_79_v n1_474796_1641130 0 3.3393426912553537e-15
iB00_80_v n1_474796_1641290 0 -3.339343e-15
iB00_81_v n1_474686_1641130 0 0.0
iB00_82_v n1_532832_1641130 0 1.669682823076577e-15
iB00_83_v n1_493920_1641290 0 -1.6696680000000001e-15
iB00_84_v n1_570528_1641130 0 -6.999983303183308e-10
iB00_85_v n1_532832_1641290 0 -1.6696680000000001e-15
iB00_86_v n1_570528_1601696 0 4.808580000000001e-05
iB00_87_v n1_609440_1601696 0 5.536789999999998e-05
iB00_88_v n1_570528_1562784 0 5.375159999999998e-05
iB00_89_v n1_570528_1641290 0 -1.6696680000000001e-15
iB00_90_v n1_609440_1641130 0 1.6696087076936923e-15
iB00_91_v n1_647136_1641130 0 -6.999983301404539e-10
iB00_92_v n1_609440_1641290 0 -1.6696680000000001e-15
iB00_93_v n1_609440_1562784 0 4.951030000000004e-05
iB00_94_v n1_647136_1601696 0 4.765389999999997e-05
iB00_95_v n1_686048_1601696 0 5.5424600000000066e-05
iB00_96_v n1_647136_1562784 0 7.275519999999996e-05
iB00_97_v n1_647136_1641290 0 -1.6696680000000001e-15
iB00_98_v n1_686048_1641130 0 -1.399998330311353e-09
iB00_99_v n1_723744_1641130 0 1.6696713456276768e-15
iB00_100_v n1_686048_1641290 0 -1.6696680000000001e-15
iB00_101_v n1_686048_1562784 0 4.711700000000006e-05
iB00_102_v n1_723744_1601696 0 6.595469999999997e-05
iB00_103_v n1_761440_1601696 0 4.568270000000001e-05
iB00_104_v n1_723744_1562784 0 5.6867299999999956e-05
iB00_105_v n1_723744_1641290 0 -1.6696680000000001e-15
iB00_106_v n1_761440_1641130 0 1.6696087076936923e-15
iB00_107_v n1_800352_1641130 0 1.6694341764024456e-15
iB00_108_v n1_761440_1641290 0 -1.6696680000000001e-15
iB00_109_v n1_761440_1562784 0 3.9071899999999974e-05
iB00_110_v n1_800352_1601696 0 5.101179999999998e-05
iB00_111_v n1_838048_1601696 0 5.408129999999995e-05
iB00_112_v n1_800352_1562784 0 5.872930000000018e-05
iB00_113_v n1_800352_1641290 0 -1.6696680000000001e-15
iB00_114_v n1_838048_1641130 0 -2.099998329885983e-09
iB00_115_v n1_876960_1641130 0 7.000000834851022e-09
iB00_116_v n1_838048_1641290 0 -1.6696680000000001e-15
iB00_117_v n1_838048_1562784 0 4.7168099999999925e-05
iB00_118_v n1_876960_1601696 0 5.4887000000000107e-05
iB00_119_v n1_914656_1601696 0 5.36199999999997e-05
iB00_120_v n1_876960_1562784 0 3.9095000000000106e-05
iB00_121_v n1_876960_1641290 0 -8.348340000000001e-16
iB00_122_v n1_914656_1641130 0 -6.9999991649441795e-09
iB00_123_v n1_952352_1641130 0 8.348356728138384e-16
iB00_124_v n1_914656_1641290 0 -8.348340000000001e-16
iB00_125_v n1_914656_1562784 0 5.73720000000001e-05
iB00_126_v n1_952352_1601696 0 5.1527699999999666e-05
iB00_127_v n1_991264_1601696 0 6.172530000000034e-05
iB00_128_v n1_952352_1562784 0 5.750359999999994e-05
iB00_129_v n1_952352_1641290 0 -8.348340000000001e-16
iB00_130_v n1_979937_1641130 0 0.0
iB00_131_v n1_991264_1641130 0 -6.999999163758333e-09
iB00_132_v n1_979937_1640970 0 0.0
iB00_133_v n1_979937_1820000 0 -0.00761628
iB00_134_v n1_979937_1825000 0 -0.011453190000000002
iB00_135_v n1_1028960_1641130 0 8.348356728138384e-16
iB00_136_v n1_991264_1641290 0 -8.348340000000001e-16
iB00_137_v n1_991264_1562784 0 5.295429999999985e-05
iB00_138_v n1_1028960_1601696 0 4.594099999999994e-05
iB00_139_v n1_1067872_1601696 0 4.0187000000000014e-05
iB00_140_v n1_1028960_1562784 0 5.408409999999991e-05
iB00_141_v n1_1028960_1641290 0 -8.348340000000001e-16
iB00_142_v n1_1067872_1641130 0 -6.999999165181349e-09
iB00_143_v n1_1105568_1641130 0 2.8000016698672206e-09
iB00_144_v n1_1067872_1641290 0 -8.348340000000001e-16
iB00_145_v n1_1067872_1562784 0 5.980799999999999e-05
iB00_146_v n1_1105568_1601696 0 3.95122e-05
iB00_147_v n1_1144480_1601696 0 4.17599e-05
iB00_148_v n1_1105568_1562784 0 5.622330000000003e-05
iB00_149_v n1_1105568_1641290 0 -1.6696680000000001e-15
iB00_150_v n1_1144480_1641130 0 -2.099998330419614e-09
iB00_151_v n1_1182176_1641130 0 3.5000016695604355e-09
iB00_152_v n1_1144480_1641290 0 -1.6696680000000001e-15
iB00_153_v n1_1144480_1562784 0 5.1311400000000066e-05
iB00_154_v n1_1182176_1601696 0 3.6357300000000046e-05
iB00_155_v n1_1219872_1601696 0 4.604669999999998e-05
iB00_156_v n1_1182176_1562784 0 5.268619999999995e-05
iB00_157_v n1_1182176_1641290 0 -1.6696680000000001e-15
iB00_158_v n1_1219872_1641130 0 -2.7999983302907057e-09
iB00_159_v n1_1258784_1641130 0 1.4000016695914062e-09
iB00_160_v n1_1219872_1641290 0 -1.6696680000000001e-15
iB00_161_v n1_1219872_1562784 0 6.42921999999999e-05
iB00_162_v n1_1258784_1601696 0 4.832169999999996e-05
iB00_163_v n1_1296480_1601696 0 5.163130000000001e-05
iB00_164_v n1_1258784_1562784 0 6.225170000000003e-05
iB00_165_v n1_1258784_1641290 0 -1.6696680000000001e-15
iB00_166_v n1_1296480_1641130 0 1.6696680000000001e-15
iB00_167_v n1_1335392_1641130 0 1.6696861687042538e-15
iB00_168_v n1_1296480_1641290 0 -1.6696680000000001e-15
iB00_169_v n1_1296480_1562784 0 5.98997e-05
iB00_170_v n1_1335392_1601696 0 4.5796239999999976e-05
iB00_171_v n1_1373088_1601696 0 5.501964999999996e-05
iB00_172_v n1_1335392_1562784 0 4.975964000000003e-05
iB00_173_v n1_1335392_1641290 0 -1.6696680000000001e-15
iB00_174_v n1_1373088_1641130 0 7.000166968475533e-11
iB00_175_v n1_1412000_1641130 0 -6.999833031576355e-11
iB00_176_v n1_1373088_1641290 0 -1.6696680000000001e-15
iB00_177_v n1_1373088_1562784 0 6.181265999999998e-05
iB00_178_v n1_1412000_1601696 0 4.928930999999999e-05
iB00_179_v n1_1449696_1601696 0 5.488280000000002e-05
iB00_180_v n1_1412000_1562784 0 5.0380399999999996e-05
iB00_181_v n1_1412000_1641290 0 -1.6696680000000001e-15
iB00_182_v n1_1449696_1641130 0 1.6696383538468462e-15
iB00_183_v n1_1487392_1641130 0 1.6697899302402924e-15
iB00_184_v n1_1449696_1641290 0 -1.6696680000000001e-15
iB00_185_v n1_1449696_1562784 0 5.169500000000001e-05
iB00_186_v n1_1487392_1601696 0 4.856459999999999e-05
iB00_187_v n1_1526304_1601696 0 3.8292100000000026e-05
iB00_188_v n1_1487392_1562784 0 5.670419999999999e-05
iB00_189_v n1_1487392_1641290 0 -1.6696680000000001e-15
iB00_190_v n1_1526304_1641130 0 1.400001669676999e-09
iB00_191_v n1_1564000_1641130 0 -3.4999983300991596e-09
iB00_192_v n1_1526304_1641290 0 -1.6696680000000001e-15
iB00_193_v n1_1526304_1562784 0 5.086900000000001e-05
iB00_194_v n1_1564000_1601696 0 4.562529999999991e-05
iB00_195_v n1_1602912_1601696 0 4.419940000000001e-05
iB00_196_v n1_1564000_1562784 0 4.375700000000007e-05
iB00_197_v n1_1564000_1641290 0 -1.6696680000000001e-15
iB00_198_v n1_1602912_1641130 0 2.100001669577737e-09
iB00_199_v n1_1641180_1641130 0 3.339343e-15
iB00_200_v n1_1602912_1641290 0 -1.6696680000000001e-15
iB00_201_v n1_1602912_1562784 0 4.2905100000000065e-05
iB00_202_v n1_1641180_1601696 0 0.0
iB00_203_v n1_1641290_1601696 0 0.0
iB00_204_v n1_1641180_1562784 0 2.800000000017998e-09
iB00_205_v n1_1641180_1619905 0 1.498168e-15
iB00_206_v n1_1820088_1619905 0 -0.0039345208
iB00_207_v n1_1641070_1619905 0 -1.498168e-15
iB00_208_v n1_1825088_1619905 0 -0.0003512992
iB00_209_v n1_1641180_1641290 0 -3.339343e-15
iB00_210_v n1_1641290_1641130 0 0.0
iB00_211_v n1_1641180_1526304 0 7.000000000489687e-10
iB00_212_v n1_1641290_1562784 0 0.0
iB00_213_v n1_1602912_1526304 0 4.0479599999999964e-05
iB00_214_v n1_1602912_1487392 0 3.998959999999996e-05
iB00_215_v n1_1564000_1526304 0 5.5019999999999985e-05
iB00_216_v n1_1526304_1526304 0 5.83016e-05
iB00_217_v n1_1564000_1487392 0 5.07192e-05
iB00_218_v n1_1526304_1487392 0 7.075879999999994e-05
iB00_219_v n1_1487392_1526304 0 6.0270000000000024e-05
iB00_220_v n1_1449696_1526304 0 7.527939999999997e-05
iB00_221_v n1_1487392_1487392 0 8.004639999999999e-05
iB00_222_v n1_1449696_1487392 0 7.99652e-05
iB00_223_v n1_1412000_1526304 0 6.434777999999999e-05
iB00_224_v n1_1373088_1526304 0 5.5959120000000006e-05
iB00_225_v n1_1412000_1487392 0 5.860862000000002e-05
iB00_226_v n1_1373088_1487392 0 7.084196000000003e-05
iB00_227_v n1_1335392_1526304 0 7.55132e-05
iB00_228_v n1_1296480_1526304 0 7.252209999999996e-05
iB00_229_v n1_1335392_1487392 0 6.536292000000001e-05
iB00_230_v n1_1296480_1487392 0 5.836040000000005e-05
iB00_231_v n1_1258784_1526304 0 7.019250000000004e-05
iB00_232_v n1_1219872_1526304 0 6.565160000000001e-05
iB00_233_v n1_1258784_1487392 0 7.965229999999996e-05
iB00_234_v n1_1219872_1487392 0 5.850320000000002e-05
iB00_235_v n1_1182176_1526304 0 6.281169999999999e-05
iB00_236_v n1_1144480_1526304 0 4.3119299999999985e-05
iB00_237_v n1_1182176_1487392 0 9.376710000000006e-05
iB00_238_v n1_1144480_1487392 0 4.900420000000006e-05
iB00_239_v n1_1105568_1526304 0 4.7219200000000065e-05
iB00_240_v n1_1067872_1526304 0 4.271539999999984e-05
iB00_241_v n1_1105568_1487392 0 4.865559999999987e-05
iB00_242_v n1_1067872_1487392 0 5.371100000000014e-05
iB00_243_v n1_1028960_1526304 0 4.5739400000000066e-05
iB00_244_v n1_991264_1526304 0 4.272170000000016e-05
iB00_245_v n1_1028960_1487392 0 5.265680000000021e-05
iB00_246_v n1_991264_1487392 0 5.981150000000023e-05
iB00_247_v n1_952352_1526304 0 5.428570000000002e-05
iB00_248_v n1_914656_1526304 0 4.361140000000003e-05
iB00_249_v n1_952352_1487392 0 6.218379999999996e-05
iB00_250_v n1_914656_1487392 0 4.564070000000004e-05
iB00_251_v n1_876960_1526304 0 4.0917799999999786e-05
iB00_252_v n1_838048_1526304 0 3.947580000000042e-05
iB00_253_v n1_876960_1487392 0 4.88117e-05
iB00_254_v n1_838048_1487392 0 6.521830000000006e-05
iB00_255_v n1_800352_1526304 0 5.8078999999999814e-05
iB00_256_v n1_761440_1526304 0 5.0073100000000014e-05
iB00_257_v n1_800352_1487392 0 5.7487500000000056e-05
iB00_258_v n1_761440_1487392 0 5.370680000000002e-05
iB00_259_v n1_723744_1526304 0 4.83594999999999e-05
iB00_260_v n1_686048_1526304 0 5.846680000000002e-05
iB00_261_v n1_723744_1487392 0 4.3425199999999924e-05
iB00_262_v n1_686048_1487392 0 4.964890000000004e-05
iB00_263_v n1_647136_1526304 0 5.364379999999997e-05
iB00_264_v n1_609440_1526304 0 4.553499999999997e-05
iB00_265_v n1_647136_1487392 0 5.1355500000000013e-05
iB00_266_v n1_609440_1487392 0 4.681320000000006e-05
iB00_267_v n1_570528_1526304 0 6.140609999999998e-05
iB00_268_v n1_570528_1487392 0 3.8143000000000004e-05
iB00_269_v n1_570528_1448480 0 4.759286000000001e-05
iB00_270_v n1_570528_1412000 0 4.584075999999999e-05
iB00_271_v n1_609440_1448480 0 4.805919999999999e-05
iB00_272_v n1_609440_1412000 0 4.763311e-05
iB00_273_v n1_570528_1373088 0 3.222506e-05
iB00_274_v n1_570528_1336608 0 5.148451e-05
iB00_275_v n1_609440_1373088 0 5.2920699999999996e-05
iB00_276_v n1_609440_1336608 0 4.293303000000002e-05
iB00_277_v n1_570528_1297696 0 4.465984529999999e-05
iB00_278_v n1_570528_1261216 0 3.6427859999999974e-05
iB00_279_v n1_609440_1297696 0 4.443937469999998e-05
iB00_280_v n1_609440_1261216 0 4.483721200000001e-05
iB00_281_v n1_570528_1222304 0 4.9025970000000026e-05
iB00_282_v n1_570528_1183392 0 3.5256900000000005e-05
iB00_283_v n1_609440_1222304 0 3.590132000000001e-05
iB00_284_v n1_609440_1183392 0 4.0082070000000005e-05
iB00_285_v n1_570528_1146912 0 3.981901000000002e-05
iB00_286_v n1_570528_1108000 0 4.381134800000001e-05
iB00_287_v n1_609440_1146912 0 3.217339999999998e-05
iB00_288_v n1_609440_1108000 0 4.4364600000000005e-05
iB00_289_v n1_570528_1071520 0 2.3422181999999988e-05
iB00_290_v n1_570528_1032608 0 5.387368000000003e-05
iB00_291_v n1_609440_1071520 0 5.32378e-05
iB00_292_v n1_609440_1032608 0 3.110940000000003e-05
iB00_293_v n1_570528_993696 0 3.085299e-05
iB00_294_v n1_570528_957216 0 3.6361149999999956e-05
iB00_295_v n1_609440_993696 0 4.3423099999999954e-05
iB00_296_v n1_532832_918304 0 4.193840000000003e-05
iB00_297_v n1_609440_957216 0 4.526270000000004e-05
iB00_298_v n1_570528_918304 0 4.628120000000002e-05
iB00_299_v n1_570528_881824 0 3.2129299999999964e-05
iB00_300_v n1_609440_918304 0 3.663940000000001e-05
iB00_301_v n1_532832_881824 0 4.3309700000000023e-05
iB00_302_v n1_532832_842912 0 4.912740000000002e-05
iB00_303_v n1_493920_881824 0 1.0809399999999902e-05
iB00_304_v n1_474796_881824 0 -2.7999999999587057e-09
iB00_305_v n1_493920_842912 0 2.328130000000013e-05
iB00_306_v n1_474686_918304 0 0.0
iB00_307_v n1_474796_842912 0 2.099999999909737e-09
iB00_308_v n1_474686_881824 0 0.0
iB00_309_v n1_474796_804000 0 -1.3999999999793529e-09
iB00_310_v n1_474686_842912 0 0.0
iB00_311_v n1_493920_804000 0 1.1552799999999967e-05
iB00_312_v n1_493920_767520 0 2.0301399999999904e-05
iB00_313_v n1_532832_804000 0 3.937010000000005e-05
iB00_314_v n1_474686_804000 0 0.0
iB00_315_v n1_474796_767520 0 2.0999999999690293e-09
iB00_316_v n1_474796_728608 0 -3.5000000000076745e-09
iB00_317_v n1_474686_767520 0 0.0
iB00_318_v n1_532832_767520 0 3.583299999999998e-05
iB00_319_v n1_493920_728608 0 1.1995899999999985e-05
iB00_320_v n1_493920_692128 0 1.84555e-05
iB00_321_v n1_532832_728608 0 2.6358500000000015e-05
iB00_322_v n1_474686_728608 0 0.0
iB00_323_v n1_474796_692128 0 4.446922973085077e-20
iB00_324_v n1_474796_653216 0 0.0
iB00_325_v n1_474686_692128 0 0.0
iB00_326_v n1_532832_692128 0 4.370240000000002e-05
iB00_327_v n1_493920_653216 0 2.3363199999999987e-05
iB00_328_v n1_493920_614304 0 1.4662900000000022e-05
iB00_329_v n1_532832_653216 0 3.154339999999998e-05
iB00_330_v n1_474686_653216 0 0.0
iB00_331_v n1_474796_614304 0 0.0
iB00_332_v n1_474796_577824 0 -2.964615315390051e-20
iB00_333_v n1_474686_614304 0 0.0
iB00_334_v n1_532832_614304 0 3.725539999999999e-05
iB00_335_v n1_493920_577824 0 1.611190000000001e-05
iB00_336_v n1_493920_538912 0 1.611197e-05
iB00_337_v n1_532832_577824 0 4.417559999999999e-05
iB00_338_v n1_474686_577824 0 0.0
iB00_339_v n1_474796_538912 0 -6.999999999452072e-11
iB00_340_v n1_474796_502432 0 -3.499999999948382e-10
iB00_341_v n1_474686_538912 0 0.0
iB00_342_v n1_532832_538912 0 4.578322000000002e-05
iB00_343_v n1_493920_502432 0 1.015056e-05
iB00_344_v n1_493920_480880 0 4.900016696667027e-10
iB00_345_v n1_532832_502432 0 2.269127e-05
iB00_346_v n1_474686_502432 0 0.0
iB00_347_v n1_474796_480880 0 3.3393426912553537e-15
iB00_348_v n1_474796_480720 0 -3.339343e-15
iB00_349_v n1_474686_480880 0 0.0
iB00_350_v n1_532832_480880 0 -4.8999833032921e-10
iB00_351_v n1_493920_480720 0 -1.6696680000000001e-15
iB00_352_v n1_570528_480880 0 -6.999833033393227e-11
iB00_353_v n1_532832_480720 0 -1.6696680000000001e-15
iB00_354_v n1_570528_502432 0 2.9670689999999996e-05
iB00_355_v n1_609440_502432 0 2.199234099999999e-05
iB00_356_v n1_570528_538912 0 3.9905739999999996e-05
iB00_357_v n1_570528_577824 0 4.4729929999999995e-05
iB00_358_v n1_609440_538912 0 4.7988198999999986e-05
iB00_359_v n1_609440_577824 0 2.1325220000000032e-05
iB00_360_v n1_570528_614304 0 6.01615e-05
iB00_361_v n1_570528_653216 0 4.128389999999999e-05
iB00_362_v n1_609440_614304 0 4.180848000000001e-05
iB00_363_v n1_609440_653216 0 4.69777e-05
iB00_364_v n1_570528_692128 0 3.3966099999999986e-05
iB00_365_v n1_570528_728608 0 4.5147199999999994e-05
iB00_366_v n1_609440_692128 0 4.8392400000000015e-05
iB00_367_v n1_609440_728608 0 4.372269999999998e-05
iB00_368_v n1_570528_767520 0 4.19244e-05
iB00_369_v n1_570528_804000 0 4.881659999999998e-05
iB00_370_v n1_609440_767520 0 4.33797e-05
iB00_371_v n1_609440_804000 0 3.5371000000000004e-05
iB00_372_v n1_570528_842912 0 4.829650000000001e-05
iB00_373_v n1_609440_842912 0 4.189500000000002e-05
iB00_374_v n1_647136_842912 0 5.732229999999997e-05
iB00_375_v n1_609440_881824 0 4.8437900000000026e-05
iB00_376_v n1_647136_881824 0 4.0146399999999985e-05
iB00_377_v n1_686048_881824 0 3.3814899999999994e-05
iB00_378_v n1_647136_918304 0 3.791549999999998e-05
iB00_379_v n1_647136_957216 0 3.2778899999999985e-05
iB00_380_v n1_686048_918304 0 5.272820000000004e-05
iB00_381_v n1_686048_957216 0 4.8800500000000015e-05
iB00_382_v n1_647136_993696 0 4.239900000000001e-05
iB00_383_v n1_647136_1032608 0 4.487839999999999e-05
iB00_384_v n1_686048_993696 0 4.618879999999999e-05
iB00_385_v n1_686048_1032608 0 5.829642000000002e-05
iB00_386_v n1_647136_1071520 0 4.1230700000000005e-05
iB00_387_v n1_647136_1108000 0 5.194756000000002e-05
iB00_388_v n1_686048_1071520 0 4.694080999999995e-05
iB00_389_v n1_686048_1108000 0 5.286834000000003e-05
iB00_390_v n1_647136_1146912 0 4.669608999999996e-05
iB00_391_v n1_647136_1183392 0 4.915400000000002e-05
iB00_392_v n1_686048_1146912 0 5.0681189999999944e-05
iB00_393_v n1_686048_1183392 0 5.1744630000000035e-05
iB00_394_v n1_647136_1222304 0 3.328941000000003e-05
iB00_395_v n1_647136_1261216 0 3.881145799999996e-05
iB00_396_v n1_686048_1222304 0 5.239590999999999e-05
iB00_397_v n1_686048_1261216 0 2.591476999999997e-05
iB00_398_v n1_647136_1297696 0 3.930633000000002e-05
iB00_399_v n1_647136_1336608 0 3.960375999999995e-05
iB00_400_v n1_686048_1297696 0 4.844539000000001e-05
iB00_401_v n1_686048_1336608 0 5.831559999999997e-05
iB00_402_v n1_647136_1373088 0 4.542860000000001e-05
iB00_403_v n1_647136_1412000 0 4.97945e-05
iB00_404_v n1_686048_1373088 0 5.138840000000003e-05
iB00_405_v n1_686048_1412000 0 6.826679999999999e-05
iB00_406_v n1_647136_1448480 0 6.19465e-05
iB00_407_v n1_686048_1448480 0 4.4115400000000035e-05
iB00_408_v n1_723744_1448480 0 4.875640000000004e-05
iB00_409_v n1_761440_1448480 0 5.4891899999999975e-05
iB00_410_v n1_723744_1412000 0 4.4522099999999965e-05
iB00_411_v n1_761440_1412000 0 5.315590000000008e-05
iB00_412_v n1_800352_1448480 0 5.5338500000000026e-05
iB00_413_v n1_838048_1448480 0 6.31826999999999e-05
iB00_414_v n1_800352_1412000 0 4.4426900000000095e-05
iB00_415_v n1_838048_1412000 0 4.699379999999995e-05
iB00_416_v n1_876960_1448480 0 6.626269999999995e-05
iB00_417_v n1_914656_1448480 0 4.928139999999998e-05
iB00_418_v n1_876960_1412000 0 6.415219999999995e-05
iB00_419_v n1_914656_1412000 0 5.596149999999997e-05
iB00_420_v n1_952352_1448480 0 5.4530000000000035e-05
iB00_421_v n1_991264_1448480 0 4.098499999999997e-05
iB00_422_v n1_952352_1412000 0 5.190038000000002e-05
iB00_423_v n1_991264_1412000 0 4.88549599999998e-05
iB00_424_v n1_1028960_1448480 0 5.8321900000000144e-05
iB00_425_v n1_1067872_1448480 0 5.7075899999999844e-05
iB00_426_v n1_1028960_1412000 0 4.673255999999988e-05
iB00_427_v n1_1067872_1412000 0 4.526130000000006e-05
iB00_428_v n1_1105568_1448480 0 5.491150000000004e-05
iB00_429_v n1_1144480_1448480 0 4.183900000000007e-05
iB00_430_v n1_1105568_1412000 0 3.81338999999999e-05
iB00_431_v n1_1144480_1412000 0 6.04625e-05
iB00_432_v n1_1182176_1448480 0 4.9977899999999934e-05
iB00_433_v n1_1219872_1448480 0 8.171309999999996e-05
iB00_434_v n1_1182176_1412000 0 6.110929999999994e-05
iB00_435_v n1_1219872_1412000 0 6.0613699999999965e-05
iB00_436_v n1_1258784_1448480 0 6.242740000000002e-05
iB00_437_v n1_1296480_1448480 0 7.550550000000005e-05
iB00_438_v n1_1258784_1412000 0 4.9863099999999994e-05
iB00_439_v n1_1296480_1412000 0 6.093031000000003e-05
iB00_440_v n1_1335392_1448480 0 9.15936e-05
iB00_441_v n1_1373088_1448480 0 8.712444999999999e-05
iB00_442_v n1_1335392_1412000 0 5.7919890000000014e-05
iB00_443_v n1_1373088_1412000 0 6.3441e-05
iB00_444_v n1_1412000_1448480 0 5.5272349999999966e-05
iB00_445_v n1_1449696_1448480 0 7.842659999999999e-05
iB00_446_v n1_1412000_1412000 0 5.826449999999997e-05
iB00_447_v n1_1449696_1412000 0 6.82605e-05
iB00_448_v n1_1487392_1448480 0 5.7474199999999986e-05
iB00_449_v n1_1526304_1448480 0 5.8967299999999994e-05
iB00_450_v n1_1487392_1412000 0 8.365140000000002e-05
iB00_451_v n1_1526304_1412000 0 7.811790000000003e-05
iB00_452_v n1_1564000_1448480 0 6.921109999999999e-05
iB00_453_v n1_1602912_1448480 0 5.163760000000003e-05
iB00_454_v n1_1564000_1412000 0 6.695219999999999e-05
iB00_455_v n1_1641180_1487392 0 -6.29999999996638e-09
iB00_456_v n1_1602912_1412000 0 4.313400000000001e-05
iB00_457_v n1_1641180_1448480 0 7.000000000015349e-09
iB00_458_v n1_1641290_1448480 0 0.0
iB00_459_v n1_1641180_1412000 0 -2.800000000047644e-09
iB00_460_v n1_1641290_1487392 0 0.0
iB00_461_v n1_1641290_1526304 0 0.0
iB00_462_v n1_1641180_1373088 0 5.929230630780102e-20
iB00_463_v n1_1641290_1412000 0 0.0
iB00_464_v n1_1602912_1373088 0 5.790890000000001e-05
iB00_465_v n1_1602912_1336608 0 5.584109999999997e-05
iB00_466_v n1_1564000_1373088 0 5.2497900000000004e-05
iB00_467_v n1_1526304_1373088 0 7.16674e-05
iB00_468_v n1_1564000_1336608 0 8.09361e-05
iB00_469_v n1_1526304_1336608 0 5.8400999999999985e-05
iB00_470_v n1_1487392_1373088 0 7.451220000000001e-05
iB00_471_v n1_1449696_1373088 0 6.296780000000002e-05
iB00_472_v n1_1487392_1336608 0 5.21003e-05
iB00_473_v n1_1449696_1336608 0 7.102689999999998e-05
iB00_474_v n1_1412000_1373088 0 8.170211000000002e-05
iB00_475_v n1_1373088_1373088 0 8.541019900000002e-05
iB00_476_v n1_1412000_1336608 0 7.083657e-05
iB00_477_v n1_1373088_1336608 0 7.684397e-05
iB00_478_v n1_1335392_1373088 0 7.994919099999997e-05
iB00_479_v n1_1296480_1373088 0 7.583030000000003e-05
iB00_480_v n1_1335392_1336608 0 7.402744999999999e-05
iB00_481_v n1_1296480_1336608 0 5.520570999999999e-05
iB00_482_v n1_1258784_1373088 0 7.496090000000005e-05
iB00_483_v n1_1219872_1373088 0 6.540099999999995e-05
iB00_484_v n1_1258784_1336608 0 5.6578899999999954e-05
iB00_485_v n1_1219872_1336608 0 5.2726800000000005e-05
iB00_486_v n1_1182176_1373088 0 5.451880000000008e-05
iB00_487_v n1_1144480_1373088 0 3.508119999999995e-05
iB00_488_v n1_1182176_1336608 0 5.642910000000007e-05
iB00_489_v n1_1144480_1336608 0 5.9479699999999904e-05
iB00_490_v n1_1105568_1373088 0 5.160050000000014e-05
iB00_491_v n1_1067872_1373088 0 5.221369999999996e-05
iB00_492_v n1_1105568_1336608 0 4.645969999999991e-05
iB00_493_v n1_1067872_1336608 0 5.4415899999999995e-05
iB00_494_v n1_1028960_1373088 0 5.269872999999993e-05
iB00_495_v n1_991264_1373088 0 6.393400999999999e-05
iB00_496_v n1_1028960_1336608 0 4.842445999999998e-05
iB00_497_v n1_991264_1336608 0 4.8250299999999974e-05
iB00_498_v n1_952352_1373088 0 5.191745999999999e-05
iB00_499_v n1_914656_1373088 0 7.674380000000005e-05
iB00_500_v n1_952352_1336608 0 6.0540340000000085e-05
iB00_501_v n1_914656_1336608 0 3.8602200000000143e-05
iB00_502_v n1_876960_1373088 0 6.315820000000002e-05
iB00_503_v n1_838048_1373088 0 6.135149999999985e-05
iB00_504_v n1_876960_1336608 0 6.471500000000005e-05
iB00_505_v n1_838048_1336608 0 4.7154099999999895e-05
iB00_506_v n1_800352_1373088 0 5.007729999999995e-05
iB00_507_v n1_761440_1373088 0 5.964980000000004e-05
iB00_508_v n1_800352_1336608 0 5.157530000000006e-05
iB00_509_v n1_761440_1336608 0 6.0002599999999994e-05
iB00_510_v n1_723744_1373088 0 6.557039999999997e-05
iB00_511_v n1_723744_1336608 0 4.832520000000006e-05
iB00_512_v n1_723744_1297696 0 5.128970000000002e-05
iB00_513_v n1_723744_1261216 0 3.450482000000002e-05
iB00_514_v n1_761440_1297696 0 3.8832500000000005e-05
iB00_515_v n1_761440_1261216 0 5.338340000000005e-05
iB00_516_v n1_723744_1222304 0 3.953852000000002e-05
iB00_517_v n1_723744_1183392 0 4.616583999999998e-05
iB00_518_v n1_761440_1222304 0 5.339270999999996e-05
iB00_519_v n1_761440_1183392 0 4.648490000000006e-05
iB00_520_v n1_723744_1146912 0 3.2409230000000003e-05
iB00_521_v n1_723744_1108000 0 4.625606999999999e-05
iB00_522_v n1_761440_1146912 0 5.3160449999999956e-05
iB00_523_v n1_761440_1108000 0 4.584208999999998e-05
iB00_524_v n1_723744_1071520 0 4.50947e-05
iB00_525_v n1_723744_1032608 0 3.370304e-05
iB00_526_v n1_761440_1071520 0 4.655071400000004e-05
iB00_527_v n1_761440_1032608 0 5.014471e-05
iB00_528_v n1_723744_993696 0 4.256048999999997e-05
iB00_529_v n1_723744_957216 0 4.453512000000003e-05
iB00_530_v n1_761440_993696 0 4.693835999999996e-05
iB00_531_v n1_761440_957216 0 4.6499110000000065e-05
iB00_532_v n1_723744_918304 0 4.6890129999999996e-05
iB00_533_v n1_723744_881824 0 5.1385109999999984e-05
iB00_534_v n1_761440_918304 0 4.712077999999998e-05
iB00_535_v n1_686048_842912 0 3.826199999999999e-05
iB00_536_v n1_761440_881824 0 5.8042319999999986e-05
iB00_537_v n1_723744_842912 0 4.668867000000002e-05
iB00_538_v n1_723744_804000 0 4.625662999999999e-05
iB00_539_v n1_761440_842912 0 5.336870000000001e-05
iB00_540_v n1_686048_804000 0 4.328100000000001e-05
iB00_541_v n1_686048_767520 0 4.718000000000003e-05
iB00_542_v n1_647136_804000 0 4.255090000000001e-05
iB00_543_v n1_647136_767520 0 4.266710000000002e-05
iB00_544_v n1_647136_728608 0 3.360769999999999e-05
iB00_545_v n1_686048_728608 0 4.709949999999997e-05
iB00_546_v n1_647136_692128 0 3.902639999999999e-05
iB00_547_v n1_647136_653216 0 3.857027999999999e-05
iB00_548_v n1_686048_692128 0 3.507882e-05
iB00_549_v n1_686048_653216 0 4.2146509999999994e-05
iB00_550_v n1_647136_614304 0 2.874879000000001e-05
iB00_551_v n1_647136_577824 0 5.323808e-05
iB00_552_v n1_686048_614304 0 3.887561999999999e-05
iB00_553_v n1_686048_577824 0 3.925860399999999e-05
iB00_554_v n1_647136_538912 0 3.947474999999999e-05
iB00_555_v n1_647136_502432 0 2.2468809999999998e-05
iB00_556_v n1_686048_538912 0 5.136164600000001e-05
iB00_557_v n1_609440_480880 0 4.2000166966477047e-10
iB00_558_v n1_686048_502432 0 2.3708579999999997e-05
iB00_559_v n1_647136_480880 0 -4.1999833032542485e-10
iB00_560_v n1_647136_480720 0 -1.6696680000000001e-15
iB00_561_v n1_686048_480880 0 1.4000166967150438e-10
iB00_562_v n1_609440_480720 0 -1.6696680000000001e-15
iB00_563_v n1_570528_480720 0 -1.6696680000000001e-15
iB00_564_v n1_723744_480880 0 1.6696717057691444e-15
iB00_565_v n1_686048_480720 0 -1.6696680000000001e-15
iB00_566_v n1_723744_502432 0 2.0300839999999993e-05
iB00_567_v n1_761440_502432 0 1.6112319999999993e-05
iB00_568_v n1_723744_538912 0 4.426884000000001e-05
iB00_569_v n1_723744_577824 0 3.5939638e-05
iB00_570_v n1_761440_538912 0 3.887653e-05
iB00_571_v n1_761440_577824 0 4.8525553999999996e-05
iB00_572_v n1_723744_614304 0 5.3180232e-05
iB00_573_v n1_723744_653216 0 4.2090649999999997e-05
iB00_574_v n1_761440_614304 0 3.714951800000001e-05
iB00_575_v n1_761440_653216 0 3.659831000000001e-05
iB00_576_v n1_723744_692128 0 5.4741330000000006e-05
iB00_577_v n1_723744_728608 0 4.958653000000002e-05
iB00_578_v n1_761440_692128 0 4.1896329999999996e-05
iB00_579_v n1_761440_728608 0 4.930610999999999e-05
iB00_580_v n1_723744_767520 0 4.0920249999999985e-05
iB00_581_v n1_761440_767520 0 4.7573190000000007e-05
iB00_582_v n1_800352_767520 0 5.594637999999998e-05
iB00_583_v n1_761440_804000 0 4.3522989999999996e-05
iB00_584_v n1_800352_804000 0 3.94131773e-05
iB00_585_v n1_838048_804000 0 4.672630270000001e-05
iB00_586_v n1_800352_842912 0 3.5239596e-05
iB00_587_v n1_800352_881824 0 4.7815418000000006e-05
iB00_588_v n1_838048_842912 0 4.8451284e-05
iB00_589_v n1_838048_881824 0 3.7968531999999995e-05
iB00_590_v n1_800352_918304 0 3.7430042999999976e-05
iB00_591_v n1_800352_957216 0 4.3426236000000006e-05
iB00_592_v n1_838048_918304 0 4.994038700000002e-05
iB00_593_v n1_838048_957216 0 4.2101163999999964e-05
iB00_594_v n1_800352_993696 0 5.3261992000000004e-05
iB00_595_v n1_800352_1032608 0 4.256588000000001e-05
iB00_596_v n1_838048_993696 0 4.443497800000002e-05
iB00_597_v n1_838048_1032608 0 4.846842e-05
iB00_598_v n1_800352_1071520 0 5.3841606000000006e-05
iB00_599_v n1_800352_1108000 0 5.2305609999999956e-05
iB00_600_v n1_838048_1071520 0 3.782436000000004e-05
iB00_601_v n1_838048_1108000 0 3.3702689999999964e-05
iB00_602_v n1_800352_1146912 0 4.755092999999999e-05
iB00_603_v n1_800352_1183392 0 4.997320999999999e-05
iB00_604_v n1_838048_1146912 0 3.076989999999991e-05
iB00_605_v n1_838048_1183392 0 4.9470610000000055e-05
iB00_606_v n1_800352_1222304 0 4.4770600000000076e-05
iB00_607_v n1_800352_1261216 0 4.791919999999993e-05
iB00_608_v n1_838048_1222304 0 4.6006099999999925e-05
iB00_609_v n1_838048_1261216 0 5.28801e-05
iB00_610_v n1_800352_1297696 0 4.608240000000002e-05
iB00_611_v n1_838048_1297696 0 3.777970000000009e-05
iB00_612_v n1_876960_1297696 0 2.7235599999999977e-05
iB00_613_v n1_914656_1297696 0 5.087879999999996e-05
iB00_614_v n1_876960_1261216 0 4.881520000000006e-05
iB00_615_v n1_914656_1261216 0 4.676279999999997e-05
iB00_616_v n1_952352_1297696 0 4.990810999999983e-05
iB00_617_v n1_991264_1297696 0 5.0100259999999976e-05
iB00_618_v n1_952352_1261216 0 4.830448000000002e-05
iB00_619_v n1_991264_1261216 0 3.135246100000006e-05
iB00_620_v n1_1028960_1297696 0 7.167419000000014e-05
iB00_621_v n1_1067872_1297696 0 5.526724000000015e-05
iB00_622_v n1_1028960_1261216 0 8.726211899999996e-05
iB00_623_v n1_1067872_1261216 0 3.9796819999999945e-05
iB00_624_v n1_1105568_1297696 0 5.493529999999999e-05
iB00_625_v n1_1144480_1297696 0 5.870480000000003e-05
iB00_626_v n1_1105568_1261216 0 6.382726000000002e-05
iB00_627_v n1_1144480_1261216 0 4.6268179999999984e-05
iB00_628_v n1_1182176_1297696 0 4.033890000000002e-05
iB00_629_v n1_1219872_1297696 0 4.415684000000001e-05
iB00_630_v n1_1182176_1261216 0 7.872367999999994e-05
iB00_631_v n1_1219872_1261216 0 5.111827e-05
iB00_632_v n1_1258784_1297696 0 7.990856999999997e-05
iB00_633_v n1_1296480_1297696 0 7.018831400000002e-05
iB00_634_v n1_1258784_1261216 0 5.791877699999998e-05
iB00_635_v n1_1296480_1261216 0 5.8308452999999984e-05
iB00_636_v n1_1335392_1297696 0 6.899961600000003e-05
iB00_637_v n1_1373088_1297696 0 5.441268e-05
iB00_638_v n1_1335392_1261216 0 5.358800999999999e-05
iB00_639_v n1_1373088_1261216 0 4.9653589999999994e-05
iB00_640_v n1_1412000_1297696 0 6.321168000000001e-05
iB00_641_v n1_1449696_1297696 0 7.921725e-05
iB00_642_v n1_1412000_1261216 0 4.992778e-05
iB00_643_v n1_1449696_1261216 0 7.733859e-05
iB00_644_v n1_1487392_1297696 0 7.071323e-05
iB00_645_v n1_1526304_1297696 0 7.029365e-05
iB00_646_v n1_1487392_1261216 0 6.378757e-05
iB00_647_v n1_1526304_1261216 0 7.58197734e-05
iB00_648_v n1_1564000_1297696 0 6.288618e-05
iB00_649_v n1_1602912_1297696 0 7.800449999999999e-05
iB00_650_v n1_1564000_1261216 0 6.746845699999999e-05
iB00_651_v n1_1641180_1336608 0 -6.999999999896764e-10
iB00_652_v n1_1602912_1261216 0 6.181802900000002e-05
iB00_653_v n1_1641180_1297696 0 0.0
iB00_654_v n1_1641290_1297696 0 0.0
iB00_655_v n1_1641180_1261216 0 4.199999999819474e-10
iB00_656_v n1_1641290_1336608 0 0.0
iB00_657_v n1_1641290_1373088 0 0.0
iB00_658_v n1_1641180_1222304 0 -4.199999999671243e-10
iB00_659_v n1_1641290_1261216 0 0.0
iB00_660_v n1_1602912_1222304 0 5.8208730999999955e-05
iB00_661_v n1_1602912_1183392 0 6.700834000000006e-05
iB00_662_v n1_1564000_1222304 0 6.367815300000001e-05
iB00_663_v n1_1526304_1222304 0 5.92641966e-05
iB00_664_v n1_1564000_1183392 0 5.287750999999997e-05
iB00_665_v n1_1526304_1183392 0 8.765567999999998e-05
iB00_666_v n1_1487392_1222304 0 6.976326e-05
iB00_667_v n1_1449696_1222304 0 7.238987000000002e-05
iB00_668_v n1_1487392_1183392 0 6.626564e-05
iB00_669_v n1_1449696_1183392 0 7.249668999999999e-05
iB00_670_v n1_1412000_1222304 0 5.816423899999999e-05
iB00_671_v n1_1373088_1222304 0 4.930737000000001e-05
iB00_672_v n1_1412000_1183392 0 6.1039391e-05
iB00_673_v n1_1373088_1183392 0 5.415501699999999e-05
iB00_674_v n1_1335392_1222304 0 5.1206820000000014e-05
iB00_675_v n1_1296480_1222304 0 7.726628000000001e-05
iB00_676_v n1_1335392_1183392 0 6.16903e-05
iB00_677_v n1_1296480_1183392 0 5.042477999999999e-05
iB00_678_v n1_1258784_1222304 0 3.788973720000003e-05
iB00_679_v n1_1219872_1222304 0 4.911417279999997e-05
iB00_680_v n1_1258784_1183392 0 6.237308e-05
iB00_681_v n1_1219872_1183392 0 4.669735000000002e-05
iB00_682_v n1_1182176_1222304 0 4.8219570000000033e-05
iB00_683_v n1_1144480_1222304 0 4.141241999999996e-05
iB00_684_v n1_1182176_1183392 0 4.2441804999999964e-05
iB00_685_v n1_1144480_1183392 0 4.160156699999998e-05
iB00_686_v n1_1105568_1222304 0 6.468986999999998e-05
iB00_687_v n1_1067872_1222304 0 5.013760499999997e-05
iB00_688_v n1_1105568_1183392 0 5.031427800000006e-05
iB00_689_v n1_1067872_1183392 0 6.226115e-05
iB00_690_v n1_1028960_1222304 0 6.139444499999992e-05
iB00_691_v n1_991264_1222304 0 5.190521000000005e-05
iB00_692_v n1_1028960_1183392 0 4.621470000000008e-05
iB00_693_v n1_991264_1183392 0 5.262690999999999e-05
iB00_694_v n1_952352_1222304 0 5.984201999999995e-05
iB00_695_v n1_914656_1222304 0 4.195484999999995e-05
iB00_696_v n1_952352_1183392 0 3.492881000000002e-05
iB00_697_v n1_914656_1183392 0 4.915288000000001e-05
iB00_698_v n1_876960_1222304 0 5.2091200000000014e-05
iB00_699_v n1_876960_1183392 0 5.041463e-05
iB00_700_v n1_876960_1146912 0 4.939010999999998e-05
iB00_701_v n1_876960_1108000 0 5.237518999999998e-05
iB00_702_v n1_914656_1146912 0 4.716403999999996e-05
iB00_703_v n1_914656_1108000 0 4.918949000000011e-05
iB00_704_v n1_876960_1071520 0 4.0755960000000005e-05
iB00_705_v n1_876960_1032608 0 4.5985940000000026e-05
iB00_706_v n1_914656_1071520 0 4.5462899999999934e-05
iB00_707_v n1_914656_1032608 0 6.222664000000006e-05
iB00_708_v n1_876960_993696 0 4.502392999999997e-05
iB00_709_v n1_876960_957216 0 4.742752000000003e-05
iB00_710_v n1_914656_993696 0 4.887196999999999e-05
iB00_711_v n1_914656_957216 0 4.0334980000000005e-05
iB00_712_v n1_876960_918304 0 5.008184999999998e-05
iB00_713_v n1_876960_881824 0 4.618782000000001e-05
iB00_714_v n1_914656_918304 0 3.4174699999999976e-05
iB00_715_v n1_914656_881824 0 4.279380000000002e-05
iB00_716_v n1_876960_842912 0 5.270201999999999e-05
iB00_717_v n1_876960_804000 0 4.024769e-05
iB00_718_v n1_914656_842912 0 5.116565999999999e-05
iB00_719_v n1_838048_767520 0 3.756774e-05
iB00_720_v n1_914656_804000 0 5.449822e-05
iB00_721_v n1_876960_767520 0 4.300737000000002e-05
iB00_722_v n1_876960_728608 0 4.542832e-05
iB00_723_v n1_914656_767520 0 4.511787e-05
iB00_724_v n1_838048_728608 0 4.710075999999999e-05
iB00_725_v n1_838048_692128 0 5.162297e-05
iB00_726_v n1_800352_728608 0 3.8831170000000007e-05
iB00_727_v n1_800352_692128 0 6.780277e-05
iB00_728_v n1_800352_653216 0 4.8640879e-05
iB00_729_v n1_838048_653216 0 4.4769368000000005e-05
iB00_730_v n1_800352_614304 0 4.0450354e-05
iB00_731_v n1_800352_577824 0 3.4261394999999997e-05
iB00_732_v n1_838048_614304 0 4.308784199999999e-05
iB00_733_v n1_838048_577824 0 4.902618e-05
iB00_734_v n1_800352_538912 0 3.459701e-05
iB00_735_v n1_800352_502432 0 2.6182660000000003e-05
iB00_736_v n1_838048_538912 0 4.9336e-05
iB00_737_v n1_761440_480880 0 1.6696642942308559e-15
iB00_738_v n1_838048_502432 0 1.1238009999999994e-05
iB00_739_v n1_800352_480880 0 -6.999833033058663e-11
iB00_740_v n1_800352_480720 0 -1.6696680000000001e-15
iB00_741_v n1_838048_480880 0 1.4000166968262168e-10
iB00_742_v n1_761440_480720 0 -1.6696680000000001e-15
iB00_743_v n1_723744_480720 0 -1.6696680000000001e-15
iB00_744_v n1_876960_480880 0 -3.499983303564844e-10
iB00_745_v n1_838048_480720 0 -1.6696680000000001e-15
iB00_746_v n1_876960_502432 0 1.9213180000000006e-05
iB00_747_v n1_914656_502432 0 2.0300979999999996e-05
iB00_748_v n1_876960_538912 0 4.845757000000002e-05
iB00_749_v n1_876960_577824 0 3.4663579999999997e-05
iB00_750_v n1_914656_538912 0 3.945536e-05
iB00_751_v n1_914656_577824 0 4.094041000000001e-05
iB00_752_v n1_876960_614304 0 3.5328230000000014e-05
iB00_753_v n1_876960_653216 0 4.483752e-05
iB00_754_v n1_914656_614304 0 4.499866e-05
iB00_755_v n1_914656_653216 0 5.1673685e-05
iB00_756_v n1_876960_692128 0 4.907714e-05
iB00_757_v n1_914656_692128 0 4.521408500000001e-05
iB00_758_v n1_952352_692128 0 4.904241999999998e-05
iB00_759_v n1_914656_728608 0 3.745945000000001e-05
iB00_760_v n1_952352_728608 0 5.049176999999999e-05
iB00_761_v n1_991264_728608 0 3.9788467599999986e-05
iB00_762_v n1_952352_767520 0 4.127564e-05
iB00_763_v n1_952352_804000 0 4.8199270000000016e-05
iB00_764_v n1_991264_767520 0 4.829622e-05
iB00_765_v n1_991264_804000 0 5.030354e-05
iB00_766_v n1_952352_842912 0 4.565687000000001e-05
iB00_767_v n1_952352_881824 0 4.5959900000000014e-05
iB00_768_v n1_991264_842912 0 2.9572269999999996e-05
iB00_769_v n1_991264_881824 0 6.157689999999999e-05
iB00_770_v n1_952352_918304 0 4.858370999999999e-05
iB00_771_v n1_952352_957216 0 4.2983709999999994e-05
iB00_772_v n1_991264_918304 0 4.8536600000000006e-05
iB00_773_v n1_991264_957216 0 4.319336e-05
iB00_774_v n1_952352_993696 0 4.270532000000004e-05
iB00_775_v n1_952352_1032608 0 4.9632939999999986e-05
iB00_776_v n1_991264_993696 0 3.551484999999996e-05
iB00_777_v n1_991264_1032608 0 3.466294999999999e-05
iB00_778_v n1_952352_1071520 0 4.447904999999997e-05
iB00_779_v n1_952352_1108000 0 4.836475000000004e-05
iB00_780_v n1_991264_1071520 0 5.286645000000005e-05
iB00_781_v n1_991264_1108000 0 4.963181999999998e-05
iB00_782_v n1_952352_1146912 0 4.889402e-05
iB00_783_v n1_991264_1146912 0 4.574157000000004e-05
iB00_784_v n1_1028960_1146912 0 5.109664000000001e-05
iB00_785_v n1_1067872_1146912 0 3.512334e-05
iB00_786_v n1_1028960_1108000 0 3.336696999999996e-05
iB00_787_v n1_1067872_1108000 0 4.4375870000000035e-05
iB00_788_v n1_1105568_1146912 0 3.892986999999995e-05
iB00_789_v n1_1144480_1146912 0 5.076316000000004e-05
iB00_790_v n1_1105568_1108000 0 4.143006000000001e-05
iB00_791_v n1_1144480_1108000 0 4.53138e-05
iB00_792_v n1_1182176_1146912 0 5.2373090000000015e-05
iB00_793_v n1_1219872_1146912 0 3.831176999999999e-05
iB00_794_v n1_1182176_1108000 0 5.481588000000003e-05
iB00_795_v n1_1219872_1108000 0 6.199711000000003e-05
iB00_796_v n1_1258784_1146912 0 5.77619e-05
iB00_797_v n1_1296480_1146912 0 5.250468999999999e-05
iB00_798_v n1_1258784_1108000 0 7.184967999999998e-05
iB00_799_v n1_1296480_1108000 0 6.621461e-05
iB00_800_v n1_1335392_1146912 0 5.434869299999999e-05
iB00_801_v n1_1373088_1146912 0 8.056551300000001e-05
iB00_802_v n1_1335392_1108000 0 6.504995699999999e-05
iB00_803_v n1_1373088_1108000 0 5.504030000000001e-05
iB00_804_v n1_1412000_1146912 0 5.5684090000000004e-05
iB00_805_v n1_1449696_1146912 0 5.02768e-05
iB00_806_v n1_1412000_1108000 0 5.7855699999999996e-05
iB00_807_v n1_1449696_1108000 0 4.238009999999998e-05
iB00_808_v n1_1487392_1146912 0 9.526719999999998e-05
iB00_809_v n1_1526304_1146912 0 5.304950000000002e-05
iB00_810_v n1_1487392_1108000 0 5.20401e-05
iB00_811_v n1_1526304_1108000 0 5.3526900000000004e-05
iB00_812_v n1_1564000_1146912 0 5.200440000000002e-05
iB00_813_v n1_1602912_1146912 0 5.5373500000000015e-05
iB00_814_v n1_1564000_1108000 0 5.8233699999999964e-05
iB00_815_v n1_1641180_1183392 0 1.4823076576950256e-20
iB00_816_v n1_1602912_1108000 0 4.216729999999998e-05
iB00_817_v n1_1641180_1146912 0 0.0
iB00_818_v n1_1641290_1146912 0 0.0
iB00_819_v n1_1641180_1108000 0 0.0
iB00_820_v n1_1641290_1183392 0 0.0
iB00_821_v n1_1641290_1222304 0 0.0
iB00_822_v n1_1641180_1071520 0 3.49999999988909e-09
iB00_823_v n1_1641290_1108000 0 0.0
iB00_824_v n1_1602912_1071520 0 2.3790200000000035e-05
iB00_825_v n1_1602912_1032608 0 4.8183099999999955e-05
iB00_826_v n1_1564000_1071520 0 4.1757799999999995e-05
iB00_827_v n1_1526304_1071520 0 4.064479999999999e-05
iB00_828_v n1_1564000_1032608 0 4.522560000000002e-05
iB00_829_v n1_1526304_1032608 0 4.569810000000002e-05
iB00_830_v n1_1487392_1071520 0 4.6729200000000054e-05
iB00_831_v n1_1449696_1071520 0 5.746019999999998e-05
iB00_832_v n1_1487392_1032608 0 4.564280000000001e-05
iB00_833_v n1_1449696_1032608 0 4.630640000000006e-05
iB00_834_v n1_1412000_1071520 0 5.097960000000003e-05
iB00_835_v n1_1373088_1071520 0 4.145470000000002e-05
iB00_836_v n1_1412000_1032608 0 5.05323e-05
iB00_837_v n1_1373088_1032608 0 4.730529999999995e-05
iB00_838_v n1_1335392_1071520 0 4.544014999999998e-05
iB00_839_v n1_1296480_1071520 0 5.276320000000002e-05
iB00_840_v n1_1335392_1032608 0 4.935070000000002e-05
iB00_841_v n1_1296480_1032608 0 6.420057000000001e-05
iB00_842_v n1_1258784_1071520 0 5.414983e-05
iB00_843_v n1_1219872_1071520 0 3.69523e-05
iB00_844_v n1_1258784_1032608 0 5.3425449000000006e-05
iB00_845_v n1_1219872_1032608 0 4.6568899999999994e-05
iB00_846_v n1_1182176_1071520 0 5.716269999999999e-05
iB00_847_v n1_1144480_1071520 0 4.656631000000001e-05
iB00_848_v n1_1182176_1032608 0 4.581289999999999e-05
iB00_849_v n1_1144480_1032608 0 5.770029999999999e-05
iB00_850_v n1_1105568_1071520 0 4.342324000000002e-05
iB00_851_v n1_1067872_1071520 0 5.376055999999997e-05
iB00_852_v n1_1105568_1032608 0 4.2419299999999996e-05
iB00_853_v n1_1067872_1032608 0 4.479895000000002e-05
iB00_854_v n1_1028960_1071520 0 3.8780140000000015e-05
iB00_855_v n1_1028960_1032608 0 3.942280999999998e-05
iB00_856_v n1_1028960_993696 0 6.470611e-05
iB00_857_v n1_1028960_957216 0 4.8614999999999994e-05
iB00_858_v n1_1067872_993696 0 5.182939999999996e-05
iB00_859_v n1_1067872_957216 0 4.71058e-05
iB00_860_v n1_1028960_918304 0 4.5415299999999985e-05
iB00_861_v n1_1028960_881824 0 5.446581000000001e-05
iB00_862_v n1_1067872_918304 0 4.682370000000004e-05
iB00_863_v n1_1067872_881824 0 4.4603859999999985e-05
iB00_864_v n1_1028960_842912 0 4.011952e-05
iB00_865_v n1_1028960_804000 0 4.803351e-05
iB00_866_v n1_1067872_842912 0 4.8950440000000014e-05
iB00_867_v n1_1067872_804000 0 4.533791359999998e-05
iB00_868_v n1_1028960_767520 0 4.422520900000001e-05
iB00_869_v n1_1028960_728608 0 4.834916100000001e-05
iB00_870_v n1_1067872_767520 0 5.2157876399999985e-05
iB00_871_v n1_991264_692128 0 5.2453262400000024e-05
iB00_872_v n1_1067872_728608 0 4.354454999999997e-05
iB00_873_v n1_1028960_692128 0 4.6010509999999976e-05
iB00_874_v n1_1028960_653216 0 6.214124000000003e-05
iB00_875_v n1_1067872_692128 0 5.4223960000000005e-05
iB00_876_v n1_991264_653216 0 4.9948499999999964e-05
iB00_877_v n1_991264_614304 0 4.199034e-05
iB00_878_v n1_952352_653216 0 4.1094410000000005e-05
iB00_879_v n1_952352_614304 0 3.910927999999998e-05
iB00_880_v n1_952352_577824 0 2.3992289999999973e-05
iB00_881_v n1_991264_577824 0 4.7056170000000024e-05
iB00_882_v n1_952352_538912 0 5.602912000000003e-05
iB00_883_v n1_952352_502432 0 1.3775719999999989e-05
iB00_884_v n1_991264_538912 0 4.866182999999998e-05
iB00_885_v n1_914656_480880 0 1.400016696718645e-10
iB00_886_v n1_991264_502432 0 1.667553999999999e-05
iB00_887_v n1_952352_480880 0 2.800016696494285e-10
iB00_888_v n1_952352_480720 0 -1.6696680000000001e-15
iB00_889_v n1_991264_480880 0 -1.3999833028804966e-10
iB00_890_v n1_914656_480720 0 -1.6696680000000001e-15
iB00_891_v n1_876960_480720 0 -1.6696680000000001e-15
iB00_892_v n1_1028960_480880 0 7.000166962546302e-11
iB00_893_v n1_991264_480720 0 -1.6696680000000001e-15
iB00_894_v n1_1028960_502432 0 2.0300630000000002e-05
iB00_895_v n1_1067872_502432 0 2.7344799999999996e-05
iB00_896_v n1_1028960_538912 0 3.509800000000003e-05
iB00_897_v n1_1028960_577824 0 4.9795269999999985e-05
iB00_898_v n1_1067872_538912 0 3.638529999999996e-05
iB00_899_v n1_1067872_577824 0 4.291979999999997e-05
iB00_900_v n1_1028960_614304 0 2.9516969999999997e-05
iB00_901_v n1_1067872_614304 0 3.247860000000002e-05
iB00_902_v n1_1105568_614304 0 3.5163800000000004e-05
iB00_903_v n1_1067872_653216 0 5.624779999999999e-05
iB00_904_v n1_1105568_653216 0 6.088319999999997e-05
iB00_905_v n1_1144480_653216 0 5.591669999999998e-05
iB00_906_v n1_1105568_692128 0 3.8125360000000024e-05
iB00_907_v n1_1105568_728608 0 5.410818e-05
iB00_908_v n1_1144480_692128 0 3.66016e-05
iB00_909_v n1_1144480_728608 0 5.835620000000002e-05
iB00_910_v n1_1105568_767520 0 4.965092999999999e-05
iB00_911_v n1_1105568_804000 0 5.474798e-05
iB00_912_v n1_1144480_767520 0 4.066524000000005e-05
iB00_913_v n1_1144480_804000 0 5.582941000000002e-05
iB00_914_v n1_1105568_842912 0 7.170659999999998e-05
iB00_915_v n1_1105568_881824 0 5.739321000000002e-05
iB00_916_v n1_1144480_842912 0 5.2827362000000005e-05
iB00_917_v n1_1144480_881824 0 4.776235800000001e-05
iB00_918_v n1_1105568_918304 0 6.173033999999996e-05
iB00_919_v n1_1105568_957216 0 4.8641600000000026e-05
iB00_920_v n1_1144480_918304 0 5.4025020000000054e-05
iB00_921_v n1_1144480_957216 0 5.4997809999999984e-05
iB00_922_v n1_1105568_993696 0 4.567499999999998e-05
iB00_923_v n1_1144480_993696 0 4.6841200000000015e-05
iB00_924_v n1_1182176_993696 0 4.743228e-05
iB00_925_v n1_1219872_993696 0 4.780587000000001e-05
iB00_926_v n1_1182176_957216 0 5.5867350000000023e-05
iB00_927_v n1_1219872_957216 0 5.059215000000002e-05
iB00_928_v n1_1258784_993696 0 6.134102099999999e-05
iB00_929_v n1_1296480_993696 0 5.341412999999999e-05
iB00_930_v n1_1258784_957216 0 4.624172000000003e-05
iB00_931_v n1_1296480_957216 0 5.485759999999996e-05
iB00_932_v n1_1335392_993696 0 4.6284000000000026e-05
iB00_933_v n1_1373088_993696 0 6.035049999999999e-05
iB00_934_v n1_1335392_957216 0 4.2830899999999976e-05
iB00_935_v n1_1373088_957216 0 5.030550000000002e-05
iB00_936_v n1_1412000_993696 0 5.058339999999999e-05
iB00_937_v n1_1449696_993696 0 2.9116499999999927e-05
iB00_938_v n1_1412000_957216 0 5.1641799999999936e-05
iB00_939_v n1_1449696_957216 0 4.88999e-05
iB00_940_v n1_1487392_993696 0 5.405820000000006e-05
iB00_941_v n1_1526304_993696 0 4.794370000000002e-05
iB00_942_v n1_1487392_957216 0 3.7989699999999925e-05
iB00_943_v n1_1526304_957216 0 6.126610000000001e-05
iB00_944_v n1_1564000_993696 0 3.8190599999999986e-05
iB00_945_v n1_1602912_993696 0 4.3087100000000016e-05
iB00_946_v n1_1564000_957216 0 4.440029999999998e-05
iB00_947_v n1_1641180_1032608 0 1.1858461261560205e-19
iB00_948_v n1_1602912_957216 0 2.8725199999999946e-05
iB00_949_v n1_1641180_993696 0 -2.1000000001469062e-09
iB00_950_v n1_1641290_993696 0 0.0
iB00_951_v n1_1641180_957216 0 -4.200000000056643e-09
iB00_952_v n1_1641290_1032608 0 0.0
iB00_953_v n1_1641290_1071520 0 0.0
iB00_954_v n1_1641180_918304 0 4.200000000056643e-09
iB00_955_v n1_1641290_957216 0 0.0
iB00_956_v n1_1602912_918304 0 3.642660000000006e-05
iB00_957_v n1_1602912_881824 0 4.443880000000004e-05
iB00_958_v n1_1564000_918304 0 6.295589999999999e-05
iB00_959_v n1_1526304_918304 0 4.087789999999996e-05
iB00_960_v n1_1564000_881824 0 3.613539999999999e-05
iB00_961_v n1_1526304_881824 0 4.315989999999998e-05
iB00_962_v n1_1487392_918304 0 5.922000000000006e-05
iB00_963_v n1_1449696_918304 0 7.522339999999997e-05
iB00_964_v n1_1487392_881824 0 4.3437100000000045e-05
iB00_965_v n1_1449696_881824 0 3.738559999999994e-05
iB00_966_v n1_1412000_918304 0 3.632790000000006e-05
iB00_967_v n1_1373088_918304 0 4.453960000000003e-05
iB00_968_v n1_1412000_881824 0 4.992609999999998e-05
iB00_969_v n1_1373088_881824 0 3.592750000000004e-05
iB00_970_v n1_1335392_918304 0 5.71179e-05
iB00_971_v n1_1296480_918304 0 5.704090000000003e-05
iB00_972_v n1_1335392_881824 0 6.866580000000004e-05
iB00_973_v n1_1296480_881824 0 5.417999999999992e-05
iB00_974_v n1_1258784_918304 0 5.1144800000000005e-05
iB00_975_v n1_1219872_918304 0 6.130698000000001e-05
iB00_976_v n1_1258784_881824 0 6.950720000000001e-05
iB00_977_v n1_1219872_881824 0 6.40808e-05
iB00_978_v n1_1182176_918304 0 4.697559999999999e-05
iB00_979_v n1_1182176_881824 0 4.739615999999998e-05
iB00_980_v n1_1182176_842912 0 4.980941000000001e-05
iB00_981_v n1_1182176_804000 0 4.86094e-05
iB00_982_v n1_1219872_842912 0 6.797489999999999e-05
iB00_983_v n1_1219872_804000 0 6.610520000000003e-05
iB00_984_v n1_1182176_767520 0 5.615330000000002e-05
iB00_985_v n1_1182176_728608 0 2.376919999999999e-05
iB00_986_v n1_1219872_767520 0 4.455989999999997e-05
iB00_987_v n1_1219872_728608 0 3.829489999999999e-05
iB00_988_v n1_1182176_692128 0 3.8875200000000024e-05
iB00_989_v n1_1182176_653216 0 3.9475800000000006e-05
iB00_990_v n1_1219872_692128 0 5.342889999999994e-05
iB00_991_v n1_1144480_614304 0 3.5308699999999976e-05
iB00_992_v n1_1219872_653216 0 4.3417499999999975e-05
iB00_993_v n1_1182176_614304 0 4.421550000000001e-05
iB00_994_v n1_1182176_577824 0 4.4827999999999985e-05
iB00_995_v n1_1219872_614304 0 6.39723e-05
iB00_996_v n1_1144480_577824 0 6.158179999999998e-05
iB00_997_v n1_1144480_538912 0 4.54062e-05
iB00_998_v n1_1105568_577824 0 3.2417700000000006e-05
iB00_999_v n1_1105568_538912 0 5.1132900000000006e-05
iB00_1000_v n1_1105568_502432 0 2.7278999999999943e-05
iB00_1001_v n1_1067872_480880 0 -6.999983303809686e-10
iB00_1002_v n1_1144480_502432 0 1.1682300000000013e-05
iB00_1003_v n1_1105568_480880 0 7.000016697796067e-10
iB00_1004_v n1_1105568_480720 0 -1.6696680000000001e-15
iB00_1005_v n1_1144480_480880 0 -6.999983303924462e-10
iB00_1006_v n1_1067872_480720 0 -1.6696680000000001e-15
iB00_1007_v n1_1028960_480720 0 -1.6696680000000001e-15
iB00_1008_v n1_1182176_480880 0 2.1000016696963217e-09
iB00_1009_v n1_1144480_480720 0 -1.6696680000000001e-15
iB00_1010_v n1_1182176_502432 0 2.030139999999999e-05
iB00_1011_v n1_1219872_502432 0 1.887830000000005e-05
iB00_1012_v n1_1182176_538912 0 3.88367e-05
iB00_1013_v n1_1219872_538912 0 5.298019999999998e-05
iB00_1014_v n1_1258784_538912 0 4.451300000000007e-05
iB00_1015_v n1_1219872_577824 0 3.636780000000001e-05
iB00_1016_v n1_1258784_577824 0 5.285350000000004e-05
iB00_1017_v n1_1296480_577824 0 4.5877999999999976e-05
iB00_1018_v n1_1258784_614304 0 5.6725900000000026e-05
iB00_1019_v n1_1258784_653216 0 5.658520000000011e-05
iB00_1020_v n1_1296480_614304 0 4.3453200000000135e-05
iB00_1021_v n1_1296480_653216 0 3.694879999999992e-05
iB00_1022_v n1_1258784_692128 0 4.3192100000000043e-05
iB00_1023_v n1_1258784_728608 0 5.475890000000004e-05
iB00_1024_v n1_1296480_692128 0 5.806429999999991e-05
iB00_1025_v n1_1296480_728608 0 4.730740000000001e-05
iB00_1026_v n1_1258784_767520 0 5.839260000000005e-05
iB00_1027_v n1_1258784_804000 0 5.704509999999994e-05
iB00_1028_v n1_1296480_767520 0 4.360999999999996e-05
iB00_1029_v n1_1296480_804000 0 5.748680000000007e-05
iB00_1030_v n1_1258784_842912 0 5.48261e-05
iB00_1031_v n1_1296480_842912 0 6.263739999999998e-05
iB00_1032_v n1_1335392_842912 0 8.060569999999999e-05
iB00_1033_v n1_1373088_842912 0 6.08321e-05
iB00_1034_v n1_1335392_804000 0 5.034539999999997e-05
iB00_1035_v n1_1373088_804000 0 6.88051e-05
iB00_1036_v n1_1412000_842912 0 8.265319999999997e-05
iB00_1037_v n1_1449696_842912 0 4.199019999999998e-05
iB00_1038_v n1_1412000_804000 0 8.437589999999993e-05
iB00_1039_v n1_1449696_804000 0 4.736620000000003e-05
iB00_1040_v n1_1487392_842912 0 5.260919999999978e-05
iB00_1041_v n1_1526304_842912 0 6.15006000000001e-05
iB00_1042_v n1_1487392_804000 0 3.4022100000000096e-05
iB00_1043_v n1_1526304_804000 0 4.243820000000002e-05
iB00_1044_v n1_1564000_842912 0 3.5902999999999985e-05
iB00_1045_v n1_1602912_842912 0 4.7821900000000065e-05
iB00_1046_v n1_1564000_804000 0 5.77381000000001e-05
iB00_1047_v n1_1641180_881824 0 -3.5000000000076745e-09
iB00_1048_v n1_1602912_804000 0 5.1537500000000114e-05
iB00_1049_v n1_1641180_842912 0 2.7999999999587057e-09
iB00_1050_v n1_1641290_842912 0 0.0
iB00_1051_v n1_1641180_804000 0 -6.999999999303841e-10
iB00_1052_v n1_1641290_881824 0 0.0
iB00_1053_v n1_1641290_918304 0 0.0
iB00_1054_v n1_1641180_767520 0 2.800000000195875e-09
iB00_1055_v n1_1641290_804000 0 0.0
iB00_1056_v n1_1602912_767520 0 4.912389999999996e-05
iB00_1057_v n1_1602912_728608 0 3.809609999999972e-05
iB00_1058_v n1_1564000_767520 0 4.5446099999999944e-05
iB00_1059_v n1_1526304_767520 0 5.359480000000001e-05
iB00_1060_v n1_1564000_728608 0 5.02963999999998e-05
iB00_1061_v n1_1526304_728608 0 4.394950000000008e-05
iB00_1062_v n1_1487392_767520 0 3.262909999999994e-05
iB00_1063_v n1_1449696_767520 0 5.598389999999988e-05
iB00_1064_v n1_1487392_728608 0 4.344549999999998e-05
iB00_1065_v n1_1449696_728608 0 4.421199999999994e-05
iB00_1066_v n1_1412000_767520 0 4.400830000000004e-05
iB00_1067_v n1_1373088_767520 0 8.052030000000006e-05
iB00_1068_v n1_1412000_728608 0 4.198809999999995e-05
iB00_1069_v n1_1373088_728608 0 5.4139400000000046e-05
iB00_1070_v n1_1335392_767520 0 5.331130000000004e-05
iB00_1071_v n1_1335392_728608 0 6.719789999999998e-05
iB00_1072_v n1_1335392_692128 0 4.18803e-05
iB00_1073_v n1_1335392_653216 0 6.049469999999994e-05
iB00_1074_v n1_1373088_692128 0 4.9578899999999885e-05
iB00_1075_v n1_1373088_653216 0 5.880209999999988e-05
iB00_1076_v n1_1335392_614304 0 4.617620000000003e-05
iB00_1077_v n1_1335392_577824 0 3.056829999999992e-05
iB00_1078_v n1_1373088_614304 0 5.286190000000003e-05
iB00_1079_v n1_1296480_538912 0 3.902429999999999e-05
iB00_1080_v n1_1373088_577824 0 5.663139999999987e-05
iB00_1081_v n1_1335392_538912 0 5.802020000000003e-05
iB00_1082_v n1_1335392_502432 0 1.2950000000000172e-05
iB00_1083_v n1_1373088_538912 0 3.918459999999997e-05
iB00_1084_v n1_1296480_502432 0 2.338770000000004e-05
iB00_1085_v n1_1296480_480880 0 -2.099998330241737e-09
iB00_1086_v n1_1258784_502432 0 2.9029699999999933e-05
iB00_1087_v n1_1258784_480880 0 1.4000016696506985e-09
iB00_1088_v n1_1258784_480720 0 -1.6696680000000001e-15
iB00_1089_v n1_1219872_480880 0 -2.799998330435591e-09
iB00_1090_v n1_1219872_480720 0 -1.6696680000000001e-15
iB00_1091_v n1_1182176_480720 0 -1.6696680000000001e-15
iB00_1092_v n1_1335392_480880 0 3.5000016697383124e-09
iB00_1093_v n1_1296480_480720 0 -1.6696680000000001e-15
iB00_1094_v n1_1373088_480880 0 -6.999983306181379e-10
iB00_1095_v n1_1335392_480720 0 -1.6696680000000001e-15
iB00_1096_v n1_1373088_502432 0 2.1975799999999933e-05
iB00_1097_v n1_1412000_502432 0 2.1970200000000076e-05
iB00_1098_v n1_1412000_538912 0 6.704530000000004e-05
iB00_1099_v n1_1449696_538912 0 5.9749199999999906e-05
iB00_1100_v n1_1412000_577824 0 4.6015900000000076e-05
iB00_1101_v n1_1412000_614304 0 5.045319999999992e-05
iB00_1102_v n1_1449696_577824 0 4.48245000000001e-05
iB00_1103_v n1_1449696_614304 0 2.0675900000000013e-05
iB00_1104_v n1_1412000_653216 0 3.742410000000014e-05
iB00_1105_v n1_1412000_692128 0 6.49712000000001e-05
iB00_1106_v n1_1449696_653216 0 5.67532000000001e-05
iB00_1107_v n1_1449696_692128 0 4.093179999999994e-05
iB00_1108_v n1_1487392_692128 0 7.249060000000007e-05
iB00_1109_v n1_1526304_692128 0 4.56693999999998e-05
iB00_1110_v n1_1487392_653216 0 4.881240000000005e-05
iB00_1111_v n1_1526304_653216 0 5.775630000000007e-05
iB00_1112_v n1_1564000_692128 0 4.362330000000003e-05
iB00_1113_v n1_1602912_692128 0 4.596760000000008e-05
iB00_1114_v n1_1564000_653216 0 4.718769999999999e-05
iB00_1115_v n1_1641180_728608 0 -3.5000000002448437e-09
iB00_1116_v n1_1602912_653216 0 4.8215999999999946e-05
iB00_1117_v n1_1641180_692128 0 -2.7999999997215365e-09
iB00_1118_v n1_1641290_692128 0 0.0
iB00_1119_v n1_1641180_653216 0 7.000000000074641e-09
iB00_1120_v n1_1641290_728608 0 0.0
iB00_1121_v n1_1641290_767520 0 0.0
iB00_1122_v n1_1641180_614304 0 -1.4000000000979375e-09
iB00_1123_v n1_1641290_653216 0 0.0
iB00_1124_v n1_1602912_614304 0 5.136739999999996e-05
iB00_1125_v n1_1602912_577824 0 4.583879999999967e-05
iB00_1126_v n1_1564000_614304 0 4.972100000000016e-05
iB00_1127_v n1_1526304_614304 0 5.938099999999976e-05
iB00_1128_v n1_1564000_577824 0 4.6808999999999944e-05
iB00_1129_v n1_1526304_577824 0 3.563000000000021e-05
iB00_1130_v n1_1487392_614304 0 5.931099999999996e-05
iB00_1131_v n1_1487392_577824 0 4.34909999999999e-05
iB00_1132_v n1_1487392_538912 0 6.364399999999985e-05
iB00_1133_v n1_1487392_502432 0 3.081400000000021e-05
iB00_1134_v n1_1526304_538912 0 4.438000000000031e-05
iB00_1135_v n1_1449696_502432 0 1.0987200000000067e-05
iB00_1136_v n1_1449696_480880 0 3.500000834604505e-09
iB00_1137_v n1_1412000_480880 0 -2.0999983302383914e-09
iB00_1138_v n1_1412000_480720 0 -1.6696680000000001e-15
iB00_1139_v n1_1373088_480720 0 -1.6696680000000001e-15
iB00_1140_v n1_1487392_480880 0 8.351321343453774e-16
iB00_1141_v n1_1449696_480720 0 -8.348340000000001e-16
iB00_1142_v n1_1526304_480880 0 8.348340000000001e-16
iB00_1143_v n1_1487392_480720 0 -8.348340000000001e-16
iB00_1144_v n1_1526304_502432 0 3.599399999999995e-05
iB00_1145_v n1_1564000_502432 0 2.4507000000000137e-05
iB00_1146_v n1_1564000_538912 0 4.534599999999982e-05
iB00_1147_v n1_1602912_538912 0 3.572169999999987e-05
iB00_1148_v n1_1641180_577824 0 -2.800000000195875e-09
iB00_1149_v n1_1602912_502432 0 1.93556999999998e-05
iB00_1150_v n1_1641180_538912 0 -7.000000000489687e-10
iB00_1151_v n1_1641290_538912 0 0.0
iB00_1152_v n1_1641180_502432 0 -7.00000000286138e-10
iB00_1153_v n1_1641290_577824 0 0.0
iB00_1154_v n1_1641290_614304 0 0.0
iB00_1155_v n1_1641180_480880 0 1.6696680000000001e-15
iB00_1156_v n1_1641290_502432 0 0.0
iB00_1157_v n1_1602912_480880 0 8.338869959129136e-16
iB00_1158_v n1_1602912_480720 0 -8.348340000000001e-16
iB00_1159_v n1_1620161_480880 0 7.000000002387041e-09
iB00_1160_v n1_1564000_480880 0 8.348356728138384e-16
iB00_1161_v n1_1564000_480720 0 -8.348340000000001e-16
iB00_1162_v n1_1526304_480720 0 -8.348340000000001e-16
iB00_1163_v n1_1620161_300000 0 -0.006019860000000002
iB00_1164_v n1_1620161_481040 0 0.0
iB00_1165_v n1_1620161_295000 0 -0.00905254
iB00_1166_v n1_1641290_480880 0 0.0
iB00_1167_v n1_1641180_480720 0 -1.6696680000000001e-15
.op
.print tran v(n1_295000_940095) v(n1_300000_940095) v(n1_474796_940095) v(n1_474906_940095) v(n1_474796_918304) v(n1_474796_957216) v(n1_474796_993696) v(n1_493920_957216) v(n1_474686_957216) v(n1_532832_957216) v(n1_493920_918304) v(n1_493920_993696) v(n1_493920_1032608) v(n1_532832_993696) v(n1_474686_993696) v(n1_474796_1032608) v(n1_474796_1071520) v(n1_474686_1032608) v(n1_532832_1032608) v(n1_493920_1071520) v(n1_493920_1108000) v(n1_532832_1071520) v(n1_474686_1071520) v(n1_474796_1108000) v(n1_474796_1146912) v(n1_474686_1108000) v(n1_532832_1108000) v(n1_493920_1146912) v(n1_493920_1183392) v(n1_532832_1146912) v(n1_474686_1146912) v(n1_474796_1183392) v(n1_474796_1222304) v(n1_474686_1183392) v(n1_532832_1183392) v(n1_493920_1222304) v(n1_493920_1261216) v(n1_532832_1222304) v(n1_474686_1222304) v(n1_474796_1261216) v(n1_474796_1297696) v(n1_474686_1261216) v(n1_532832_1261216) v(n1_493920_1297696) v(n1_493920_1336608) v(n1_532832_1297696) v(n1_474686_1297696) v(n1_474796_1336608) v(n1_474796_1373088) v(n1_474686_1336608) v(n1_532832_1336608) v(n1_493920_1373088) v(n1_493920_1412000) v(n1_532832_1373088) v(n1_474686_1373088) v(n1_474796_1412000) v(n1_474796_1448480) v(n1_474686_1412000) v(n1_532832_1412000) v(n1_493920_1448480) v(n1_493920_1487392) v(n1_532832_1448480) v(n1_474686_1448480) v(n1_474796_1487392) v(n1_474796_1526304) v(n1_474686_1487392) v(n1_532832_1487392) v(n1_493920_1526304) v(n1_493920_1562784) v(n1_532832_1526304) v(n1_474686_1526304) v(n1_474796_1562784) v(n1_474796_1601696) v(n1_474686_1562784) v(n1_532832_1562784) v(n1_493920_1601696) v(n1_493920_1641130) v(n1_532832_1601696) v(n1_474686_1601696) v(n1_474796_1641130) v(n1_474796_1641290) v(n1_474686_1641130) v(n1_532832_1641130) v(n1_493920_1641290) v(n1_570528_1641130) v(n1_532832_1641290) v(n1_570528_1601696) v(n1_609440_1601696) v(n1_570528_1562784) v(n1_570528_1641290) v(n1_609440_1641130) v(n1_647136_1641130) v(n1_609440_1641290) v(n1_609440_1562784) v(n1_647136_1601696) v(n1_686048_1601696) v(n1_647136_1562784) v(n1_647136_1641290) v(n1_686048_1641130) v(n1_723744_1641130) v(n1_686048_1641290) v(n1_686048_1562784) v(n1_723744_1601696) v(n1_761440_1601696) v(n1_723744_1562784) v(n1_723744_1641290) v(n1_761440_1641130) v(n1_800352_1641130) v(n1_761440_1641290) v(n1_761440_1562784) v(n1_800352_1601696) v(n1_838048_1601696) v(n1_800352_1562784) v(n1_800352_1641290) v(n1_838048_1641130) v(n1_876960_1641130) v(n1_838048_1641290) v(n1_838048_1562784) v(n1_876960_1601696) v(n1_914656_1601696) v(n1_876960_1562784) v(n1_876960_1641290) v(n1_914656_1641130) v(n1_952352_1641130) v(n1_914656_1641290) v(n1_914656_1562784) v(n1_952352_1601696) v(n1_991264_1601696) v(n1_952352_1562784) v(n1_952352_1641290) v(n1_979937_1641130) v(n1_991264_1641130) v(n1_979937_1640970) v(n1_979937_1820000) v(n1_979937_1825000) v(n1_1028960_1641130) v(n1_991264_1641290) v(n1_991264_1562784) v(n1_1028960_1601696) v(n1_1067872_1601696) v(n1_1028960_1562784) v(n1_1028960_1641290) v(n1_1067872_1641130) v(n1_1105568_1641130) v(n1_1067872_1641290) v(n1_1067872_1562784) v(n1_1105568_1601696) v(n1_1144480_1601696) v(n1_1105568_1562784) v(n1_1105568_1641290) v(n1_1144480_1641130) v(n1_1182176_1641130) v(n1_1144480_1641290) v(n1_1144480_1562784) v(n1_1182176_1601696) v(n1_1219872_1601696) v(n1_1182176_1562784) v(n1_1182176_1641290) v(n1_1219872_1641130) v(n1_1258784_1641130) v(n1_1219872_1641290) v(n1_1219872_1562784) v(n1_1258784_1601696) v(n1_1296480_1601696) v(n1_1258784_1562784) v(n1_1258784_1641290) v(n1_1296480_1641130) v(n1_1335392_1641130) v(n1_1296480_1641290) v(n1_1296480_1562784) v(n1_1335392_1601696) v(n1_1373088_1601696) v(n1_1335392_1562784) v(n1_1335392_1641290) v(n1_1373088_1641130) v(n1_1412000_1641130) v(n1_1373088_1641290) v(n1_1373088_1562784) v(n1_1412000_1601696) v(n1_1449696_1601696) v(n1_1412000_1562784) v(n1_1412000_1641290) v(n1_1449696_1641130) v(n1_1487392_1641130) v(n1_1449696_1641290) v(n1_1449696_1562784) v(n1_1487392_1601696) v(n1_1526304_1601696) v(n1_1487392_1562784) v(n1_1487392_1641290) v(n1_1526304_1641130) v(n1_1564000_1641130) v(n1_1526304_1641290) v(n1_1526304_1562784) v(n1_1564000_1601696) v(n1_1602912_1601696) v(n1_1564000_1562784) v(n1_1564000_1641290) v(n1_1602912_1641130) v(n1_1641180_1641130) v(n1_1602912_1641290) v(n1_1602912_1562784) v(n1_1641180_1601696) v(n1_1641290_1601696) v(n1_1641180_1562784) v(n1_1641180_1619905) v(n1_1820088_1619905) v(n1_1641070_1619905) v(n1_1825088_1619905) v(n1_1641180_1641290) v(n1_1641290_1641130) v(n1_1641180_1526304) v(n1_1641290_1562784) v(n1_1602912_1526304) v(n1_1602912_1487392) v(n1_1564000_1526304) v(n1_1526304_1526304) v(n1_1564000_1487392) v(n1_1526304_1487392) v(n1_1487392_1526304) v(n1_1449696_1526304) v(n1_1487392_1487392) v(n1_1449696_1487392) v(n1_1412000_1526304) v(n1_1373088_1526304) v(n1_1412000_1487392) v(n1_1373088_1487392) v(n1_1335392_1526304) v(n1_1296480_1526304) v(n1_1335392_1487392) v(n1_1296480_1487392) v(n1_1258784_1526304) v(n1_1219872_1526304) v(n1_1258784_1487392) v(n1_1219872_1487392) v(n1_1182176_1526304) v(n1_1144480_1526304) v(n1_1182176_1487392) v(n1_1144480_1487392) v(n1_1105568_1526304) v(n1_1067872_1526304) v(n1_1105568_1487392) v(n1_1067872_1487392) v(n1_1028960_1526304) v(n1_991264_1526304) v(n1_1028960_1487392) v(n1_991264_1487392) v(n1_952352_1526304) v(n1_914656_1526304) v(n1_952352_1487392) v(n1_914656_1487392) v(n1_876960_1526304) v(n1_838048_1526304) v(n1_876960_1487392) v(n1_838048_1487392) v(n1_800352_1526304) v(n1_761440_1526304) v(n1_800352_1487392) v(n1_761440_1487392) v(n1_723744_1526304) v(n1_686048_1526304) v(n1_723744_1487392) v(n1_686048_1487392) v(n1_647136_1526304) v(n1_609440_1526304) v(n1_647136_1487392) v(n1_609440_1487392) v(n1_570528_1526304) v(n1_570528_1487392) v(n1_570528_1448480) v(n1_570528_1412000) v(n1_609440_1448480) v(n1_609440_1412000) v(n1_570528_1373088) v(n1_570528_1336608) v(n1_609440_1373088) v(n1_609440_1336608) v(n1_570528_1297696) v(n1_570528_1261216) v(n1_609440_1297696) v(n1_609440_1261216) v(n1_570528_1222304) v(n1_570528_1183392) v(n1_609440_1222304) v(n1_609440_1183392) v(n1_570528_1146912) v(n1_570528_1108000) v(n1_609440_1146912) v(n1_609440_1108000) v(n1_570528_1071520) v(n1_570528_1032608) v(n1_609440_1071520) v(n1_609440_1032608) v(n1_570528_993696) v(n1_570528_957216) v(n1_609440_993696) v(n1_532832_918304) v(n1_609440_957216) v(n1_570528_918304) v(n1_570528_881824) v(n1_609440_918304) v(n1_532832_881824) v(n1_532832_842912) v(n1_493920_881824) v(n1_474796_881824) v(n1_493920_842912) v(n1_474686_918304) v(n1_474796_842912) v(n1_474686_881824) v(n1_474796_804000) v(n1_474686_842912) v(n1_493920_804000) v(n1_493920_767520) v(n1_532832_804000) v(n1_474686_804000) v(n1_474796_767520) v(n1_474796_728608) v(n1_474686_767520) v(n1_532832_767520) v(n1_493920_728608) v(n1_493920_692128) v(n1_532832_728608) v(n1_474686_728608) v(n1_474796_692128) v(n1_474796_653216) v(n1_474686_692128) v(n1_532832_692128) v(n1_493920_653216) v(n1_493920_614304) v(n1_532832_653216) v(n1_474686_653216) v(n1_474796_614304) v(n1_474796_577824) v(n1_474686_614304) v(n1_532832_614304) v(n1_493920_577824) v(n1_493920_538912) v(n1_532832_577824) v(n1_474686_577824) v(n1_474796_538912) v(n1_474796_502432) v(n1_474686_538912) v(n1_532832_538912) v(n1_493920_502432) v(n1_493920_480880) v(n1_532832_502432) v(n1_474686_502432) v(n1_474796_480880) v(n1_474796_480720) v(n1_474686_480880) v(n1_532832_480880) v(n1_493920_480720) v(n1_570528_480880) v(n1_532832_480720) v(n1_570528_502432) v(n1_609440_502432) v(n1_570528_538912) v(n1_570528_577824) v(n1_609440_538912) v(n1_609440_577824) v(n1_570528_614304) v(n1_570528_653216) v(n1_609440_614304) v(n1_609440_653216) v(n1_570528_692128) v(n1_570528_728608) v(n1_609440_692128) v(n1_609440_728608) v(n1_570528_767520) v(n1_570528_804000) v(n1_609440_767520) v(n1_609440_804000) v(n1_570528_842912) v(n1_609440_842912) v(n1_647136_842912) v(n1_609440_881824) v(n1_647136_881824) v(n1_686048_881824) v(n1_647136_918304) v(n1_647136_957216) v(n1_686048_918304) v(n1_686048_957216) v(n1_647136_993696) v(n1_647136_1032608) v(n1_686048_993696) v(n1_686048_1032608) v(n1_647136_1071520) v(n1_647136_1108000) v(n1_686048_1071520) v(n1_686048_1108000) v(n1_647136_1146912) v(n1_647136_1183392) v(n1_686048_1146912) v(n1_686048_1183392) v(n1_647136_1222304) v(n1_647136_1261216) v(n1_686048_1222304) v(n1_686048_1261216) v(n1_647136_1297696) v(n1_647136_1336608) v(n1_686048_1297696) v(n1_686048_1336608) v(n1_647136_1373088) v(n1_647136_1412000) v(n1_686048_1373088) v(n1_686048_1412000) v(n1_647136_1448480) v(n1_686048_1448480) v(n1_723744_1448480) v(n1_761440_1448480) v(n1_723744_1412000) v(n1_761440_1412000) v(n1_800352_1448480) v(n1_838048_1448480) v(n1_800352_1412000) v(n1_838048_1412000) v(n1_876960_1448480) v(n1_914656_1448480) v(n1_876960_1412000) v(n1_914656_1412000) v(n1_952352_1448480) v(n1_991264_1448480) v(n1_952352_1412000) v(n1_991264_1412000) v(n1_1028960_1448480) v(n1_1067872_1448480) v(n1_1028960_1412000) v(n1_1067872_1412000) v(n1_1105568_1448480) v(n1_1144480_1448480) v(n1_1105568_1412000) v(n1_1144480_1412000) v(n1_1182176_1448480) v(n1_1219872_1448480) v(n1_1182176_1412000) v(n1_1219872_1412000) v(n1_1258784_1448480) v(n1_1296480_1448480) v(n1_1258784_1412000) v(n1_1296480_1412000) v(n1_1335392_1448480) v(n1_1373088_1448480) v(n1_1335392_1412000) v(n1_1373088_1412000) v(n1_1412000_1448480) v(n1_1449696_1448480) v(n1_1412000_1412000) v(n1_1449696_1412000) v(n1_1487392_1448480) v(n1_1526304_1448480) v(n1_1487392_1412000) v(n1_1526304_1412000) v(n1_1564000_1448480) v(n1_1602912_1448480) v(n1_1564000_1412000) v(n1_1641180_1487392) v(n1_1602912_1412000) v(n1_1641180_1448480) v(n1_1641290_1448480) v(n1_1641180_1412000) v(n1_1641290_1487392) v(n1_1641290_1526304) v(n1_1641180_1373088) v(n1_1641290_1412000) v(n1_1602912_1373088) v(n1_1602912_1336608) v(n1_1564000_1373088) v(n1_1526304_1373088) v(n1_1564000_1336608) v(n1_1526304_1336608) v(n1_1487392_1373088) v(n1_1449696_1373088) v(n1_1487392_1336608) v(n1_1449696_1336608) v(n1_1412000_1373088) v(n1_1373088_1373088) v(n1_1412000_1336608) v(n1_1373088_1336608) v(n1_1335392_1373088) v(n1_1296480_1373088) v(n1_1335392_1336608) v(n1_1296480_1336608) v(n1_1258784_1373088) v(n1_1219872_1373088) v(n1_1258784_1336608) v(n1_1219872_1336608) v(n1_1182176_1373088) v(n1_1144480_1373088) v(n1_1182176_1336608) v(n1_1144480_1336608) v(n1_1105568_1373088) v(n1_1067872_1373088) v(n1_1105568_1336608) v(n1_1067872_1336608) v(n1_1028960_1373088) v(n1_991264_1373088) v(n1_1028960_1336608) v(n1_991264_1336608) v(n1_952352_1373088) v(n1_914656_1373088) v(n1_952352_1336608) v(n1_914656_1336608) v(n1_876960_1373088) v(n1_838048_1373088) v(n1_876960_1336608) v(n1_838048_1336608) v(n1_800352_1373088) v(n1_761440_1373088) v(n1_800352_1336608) v(n1_761440_1336608) v(n1_723744_1373088) v(n1_723744_1336608) v(n1_723744_1297696) v(n1_723744_1261216) v(n1_761440_1297696) v(n1_761440_1261216) v(n1_723744_1222304) v(n1_723744_1183392) v(n1_761440_1222304) v(n1_761440_1183392) v(n1_723744_1146912) v(n1_723744_1108000) v(n1_761440_1146912) v(n1_761440_1108000) v(n1_723744_1071520) v(n1_723744_1032608) v(n1_761440_1071520) v(n1_761440_1032608) v(n1_723744_993696) v(n1_723744_957216) v(n1_761440_993696) v(n1_761440_957216) v(n1_723744_918304) v(n1_723744_881824) v(n1_761440_918304) v(n1_686048_842912) v(n1_761440_881824) v(n1_723744_842912) v(n1_723744_804000) v(n1_761440_842912) v(n1_686048_804000) v(n1_686048_767520) v(n1_647136_804000) v(n1_647136_767520) v(n1_647136_728608) v(n1_686048_728608) v(n1_647136_692128) v(n1_647136_653216) v(n1_686048_692128) v(n1_686048_653216) v(n1_647136_614304) v(n1_647136_577824) v(n1_686048_614304) v(n1_686048_577824) v(n1_647136_538912) v(n1_647136_502432) v(n1_686048_538912) v(n1_609440_480880) v(n1_686048_502432) v(n1_647136_480880) v(n1_647136_480720) v(n1_686048_480880) v(n1_609440_480720) v(n1_570528_480720) v(n1_723744_480880) v(n1_686048_480720) v(n1_723744_502432) v(n1_761440_502432) v(n1_723744_538912) v(n1_723744_577824) v(n1_761440_538912) v(n1_761440_577824) v(n1_723744_614304) v(n1_723744_653216) v(n1_761440_614304) v(n1_761440_653216) v(n1_723744_692128) v(n1_723744_728608) v(n1_761440_692128) v(n1_761440_728608) v(n1_723744_767520) v(n1_761440_767520) v(n1_800352_767520) v(n1_761440_804000) v(n1_800352_804000) v(n1_838048_804000) v(n1_800352_842912) v(n1_800352_881824) v(n1_838048_842912) v(n1_838048_881824) v(n1_800352_918304) v(n1_800352_957216) v(n1_838048_918304) v(n1_838048_957216) v(n1_800352_993696) v(n1_800352_1032608) v(n1_838048_993696) v(n1_838048_1032608) v(n1_800352_1071520) v(n1_800352_1108000) v(n1_838048_1071520) v(n1_838048_1108000) v(n1_800352_1146912) v(n1_800352_1183392) v(n1_838048_1146912) v(n1_838048_1183392) v(n1_800352_1222304) v(n1_800352_1261216) v(n1_838048_1222304) v(n1_838048_1261216) v(n1_800352_1297696) v(n1_838048_1297696) v(n1_876960_1297696) v(n1_914656_1297696) v(n1_876960_1261216) v(n1_914656_1261216) v(n1_952352_1297696) v(n1_991264_1297696) v(n1_952352_1261216) v(n1_991264_1261216) v(n1_1028960_1297696) v(n1_1067872_1297696) v(n1_1028960_1261216) v(n1_1067872_1261216) v(n1_1105568_1297696) v(n1_1144480_1297696) v(n1_1105568_1261216) v(n1_1144480_1261216) v(n1_1182176_1297696) v(n1_1219872_1297696) v(n1_1182176_1261216) v(n1_1219872_1261216) v(n1_1258784_1297696) v(n1_1296480_1297696) v(n1_1258784_1261216) v(n1_1296480_1261216) v(n1_1335392_1297696) v(n1_1373088_1297696) v(n1_1335392_1261216) v(n1_1373088_1261216) v(n1_1412000_1297696) v(n1_1449696_1297696) v(n1_1412000_1261216) v(n1_1449696_1261216) v(n1_1487392_1297696) v(n1_1526304_1297696) v(n1_1487392_1261216) v(n1_1526304_1261216) v(n1_1564000_1297696) v(n1_1602912_1297696) v(n1_1564000_1261216) v(n1_1641180_1336608) v(n1_1602912_1261216) v(n1_1641180_1297696) v(n1_1641290_1297696) v(n1_1641180_1261216) v(n1_1641290_1336608) v(n1_1641290_1373088) v(n1_1641180_1222304) v(n1_1641290_1261216) v(n1_1602912_1222304) v(n1_1602912_1183392) v(n1_1564000_1222304) v(n1_1526304_1222304) v(n1_1564000_1183392) v(n1_1526304_1183392) v(n1_1487392_1222304) v(n1_1449696_1222304) v(n1_1487392_1183392) v(n1_1449696_1183392) v(n1_1412000_1222304) v(n1_1373088_1222304) v(n1_1412000_1183392) v(n1_1373088_1183392) v(n1_1335392_1222304) v(n1_1296480_1222304) v(n1_1335392_1183392) v(n1_1296480_1183392) v(n1_1258784_1222304) v(n1_1219872_1222304) v(n1_1258784_1183392) v(n1_1219872_1183392) v(n1_1182176_1222304) v(n1_1144480_1222304) v(n1_1182176_1183392) v(n1_1144480_1183392) v(n1_1105568_1222304) v(n1_1067872_1222304) v(n1_1105568_1183392) v(n1_1067872_1183392) v(n1_1028960_1222304) v(n1_991264_1222304) v(n1_1028960_1183392) v(n1_991264_1183392) v(n1_952352_1222304) v(n1_914656_1222304) v(n1_952352_1183392) v(n1_914656_1183392) v(n1_876960_1222304) v(n1_876960_1183392) v(n1_876960_1146912) v(n1_876960_1108000) v(n1_914656_1146912) v(n1_914656_1108000) v(n1_876960_1071520) v(n1_876960_1032608) v(n1_914656_1071520) v(n1_914656_1032608) v(n1_876960_993696) v(n1_876960_957216) v(n1_914656_993696) v(n1_914656_957216) v(n1_876960_918304) v(n1_876960_881824) v(n1_914656_918304) v(n1_914656_881824) v(n1_876960_842912) v(n1_876960_804000) v(n1_914656_842912) v(n1_838048_767520) v(n1_914656_804000) v(n1_876960_767520) v(n1_876960_728608) v(n1_914656_767520) v(n1_838048_728608) v(n1_838048_692128) v(n1_800352_728608) v(n1_800352_692128) v(n1_800352_653216) v(n1_838048_653216) v(n1_800352_614304) v(n1_800352_577824) v(n1_838048_614304) v(n1_838048_577824) v(n1_800352_538912) v(n1_800352_502432) v(n1_838048_538912) v(n1_761440_480880) v(n1_838048_502432) v(n1_800352_480880) v(n1_800352_480720) v(n1_838048_480880) v(n1_761440_480720) v(n1_723744_480720) v(n1_876960_480880) v(n1_838048_480720) v(n1_876960_502432) v(n1_914656_502432) v(n1_876960_538912) v(n1_876960_577824) v(n1_914656_538912) v(n1_914656_577824) v(n1_876960_614304) v(n1_876960_653216) v(n1_914656_614304) v(n1_914656_653216) v(n1_876960_692128) v(n1_914656_692128) v(n1_952352_692128) v(n1_914656_728608) v(n1_952352_728608) v(n1_991264_728608) v(n1_952352_767520) v(n1_952352_804000) v(n1_991264_767520) v(n1_991264_804000) v(n1_952352_842912) v(n1_952352_881824) v(n1_991264_842912) v(n1_991264_881824) v(n1_952352_918304) v(n1_952352_957216) v(n1_991264_918304) v(n1_991264_957216) v(n1_952352_993696) v(n1_952352_1032608) v(n1_991264_993696) v(n1_991264_1032608) v(n1_952352_1071520) v(n1_952352_1108000) v(n1_991264_1071520) v(n1_991264_1108000) v(n1_952352_1146912) v(n1_991264_1146912) v(n1_1028960_1146912) v(n1_1067872_1146912) v(n1_1028960_1108000) v(n1_1067872_1108000) v(n1_1105568_1146912) v(n1_1144480_1146912) v(n1_1105568_1108000) v(n1_1144480_1108000) v(n1_1182176_1146912) v(n1_1219872_1146912) v(n1_1182176_1108000) v(n1_1219872_1108000) v(n1_1258784_1146912) v(n1_1296480_1146912) v(n1_1258784_1108000) v(n1_1296480_1108000) v(n1_1335392_1146912) v(n1_1373088_1146912) v(n1_1335392_1108000) v(n1_1373088_1108000) v(n1_1412000_1146912) v(n1_1449696_1146912) v(n1_1412000_1108000) v(n1_1449696_1108000) v(n1_1487392_1146912) v(n1_1526304_1146912) v(n1_1487392_1108000) v(n1_1526304_1108000) v(n1_1564000_1146912) v(n1_1602912_1146912) v(n1_1564000_1108000) v(n1_1641180_1183392) v(n1_1602912_1108000) v(n1_1641180_1146912) v(n1_1641290_1146912) v(n1_1641180_1108000) v(n1_1641290_1183392) v(n1_1641290_1222304) v(n1_1641180_1071520) v(n1_1641290_1108000) v(n1_1602912_1071520) v(n1_1602912_1032608) v(n1_1564000_1071520) v(n1_1526304_1071520) v(n1_1564000_1032608) v(n1_1526304_1032608) v(n1_1487392_1071520) v(n1_1449696_1071520) v(n1_1487392_1032608) v(n1_1449696_1032608) v(n1_1412000_1071520) v(n1_1373088_1071520) v(n1_1412000_1032608) v(n1_1373088_1032608) v(n1_1335392_1071520) v(n1_1296480_1071520) v(n1_1335392_1032608) v(n1_1296480_1032608) v(n1_1258784_1071520) v(n1_1219872_1071520) v(n1_1258784_1032608) v(n1_1219872_1032608) v(n1_1182176_1071520) v(n1_1144480_1071520) v(n1_1182176_1032608) v(n1_1144480_1032608) v(n1_1105568_1071520) v(n1_1067872_1071520) v(n1_1105568_1032608) v(n1_1067872_1032608) v(n1_1028960_1071520) v(n1_1028960_1032608) v(n1_1028960_993696) v(n1_1028960_957216) v(n1_1067872_993696) v(n1_1067872_957216) v(n1_1028960_918304) v(n1_1028960_881824) v(n1_1067872_918304) v(n1_1067872_881824) v(n1_1028960_842912) v(n1_1028960_804000) v(n1_1067872_842912) v(n1_1067872_804000) v(n1_1028960_767520) v(n1_1028960_728608) v(n1_1067872_767520) v(n1_991264_692128) v(n1_1067872_728608) v(n1_1028960_692128) v(n1_1028960_653216) v(n1_1067872_692128) v(n1_991264_653216) v(n1_991264_614304) v(n1_952352_653216) v(n1_952352_614304) v(n1_952352_577824) v(n1_991264_577824) v(n1_952352_538912) v(n1_952352_502432) v(n1_991264_538912) v(n1_914656_480880) v(n1_991264_502432) v(n1_952352_480880) v(n1_952352_480720) v(n1_991264_480880) v(n1_914656_480720) v(n1_876960_480720) v(n1_1028960_480880) v(n1_991264_480720) v(n1_1028960_502432) v(n1_1067872_502432) v(n1_1028960_538912) v(n1_1028960_577824) v(n1_1067872_538912) v(n1_1067872_577824) v(n1_1028960_614304) v(n1_1067872_614304) v(n1_1105568_614304) v(n1_1067872_653216) v(n1_1105568_653216) v(n1_1144480_653216) v(n1_1105568_692128) v(n1_1105568_728608) v(n1_1144480_692128) v(n1_1144480_728608) v(n1_1105568_767520) v(n1_1105568_804000) v(n1_1144480_767520) v(n1_1144480_804000) v(n1_1105568_842912) v(n1_1105568_881824) v(n1_1144480_842912) v(n1_1144480_881824) v(n1_1105568_918304) v(n1_1105568_957216) v(n1_1144480_918304) v(n1_1144480_957216) v(n1_1105568_993696) v(n1_1144480_993696) v(n1_1182176_993696) v(n1_1219872_993696) v(n1_1182176_957216) v(n1_1219872_957216) v(n1_1258784_993696) v(n1_1296480_993696) v(n1_1258784_957216) v(n1_1296480_957216) v(n1_1335392_993696) v(n1_1373088_993696) v(n1_1335392_957216) v(n1_1373088_957216) v(n1_1412000_993696) v(n1_1449696_993696) v(n1_1412000_957216) v(n1_1449696_957216) v(n1_1487392_993696) v(n1_1526304_993696) v(n1_1487392_957216) v(n1_1526304_957216) v(n1_1564000_993696) v(n1_1602912_993696) v(n1_1564000_957216) v(n1_1641180_1032608) v(n1_1602912_957216) v(n1_1641180_993696) v(n1_1641290_993696) v(n1_1641180_957216) v(n1_1641290_1032608) v(n1_1641290_1071520) v(n1_1641180_918304) v(n1_1641290_957216) v(n1_1602912_918304) v(n1_1602912_881824) v(n1_1564000_918304) v(n1_1526304_918304) v(n1_1564000_881824) v(n1_1526304_881824) v(n1_1487392_918304) v(n1_1449696_918304) v(n1_1487392_881824) v(n1_1449696_881824) v(n1_1412000_918304) v(n1_1373088_918304) v(n1_1412000_881824) v(n1_1373088_881824) v(n1_1335392_918304) v(n1_1296480_918304) v(n1_1335392_881824) v(n1_1296480_881824) v(n1_1258784_918304) v(n1_1219872_918304) v(n1_1258784_881824) v(n1_1219872_881824) v(n1_1182176_918304) v(n1_1182176_881824) v(n1_1182176_842912) v(n1_1182176_804000) v(n1_1219872_842912) v(n1_1219872_804000) v(n1_1182176_767520) v(n1_1182176_728608) v(n1_1219872_767520) v(n1_1219872_728608) v(n1_1182176_692128) v(n1_1182176_653216) v(n1_1219872_692128) v(n1_1144480_614304) v(n1_1219872_653216) v(n1_1182176_614304) v(n1_1182176_577824) v(n1_1219872_614304) v(n1_1144480_577824) v(n1_1144480_538912) v(n1_1105568_577824) v(n1_1105568_538912) v(n1_1105568_502432) v(n1_1067872_480880) v(n1_1144480_502432) v(n1_1105568_480880) v(n1_1105568_480720) v(n1_1144480_480880) v(n1_1067872_480720) v(n1_1028960_480720) v(n1_1182176_480880) v(n1_1144480_480720) v(n1_1182176_502432) v(n1_1219872_502432) v(n1_1182176_538912) v(n1_1219872_538912) v(n1_1258784_538912) v(n1_1219872_577824) v(n1_1258784_577824) v(n1_1296480_577824) v(n1_1258784_614304) v(n1_1258784_653216) v(n1_1296480_614304) v(n1_1296480_653216) v(n1_1258784_692128) v(n1_1258784_728608) v(n1_1296480_692128) v(n1_1296480_728608) v(n1_1258784_767520) v(n1_1258784_804000) v(n1_1296480_767520) v(n1_1296480_804000) v(n1_1258784_842912) v(n1_1296480_842912) v(n1_1335392_842912) v(n1_1373088_842912) v(n1_1335392_804000) v(n1_1373088_804000) v(n1_1412000_842912) v(n1_1449696_842912) v(n1_1412000_804000) v(n1_1449696_804000) v(n1_1487392_842912) v(n1_1526304_842912) v(n1_1487392_804000) v(n1_1526304_804000) v(n1_1564000_842912) v(n1_1602912_842912) v(n1_1564000_804000) v(n1_1641180_881824) v(n1_1602912_804000) v(n1_1641180_842912) v(n1_1641290_842912) v(n1_1641180_804000) v(n1_1641290_881824) v(n1_1641290_918304) v(n1_1641180_767520) v(n1_1641290_804000) v(n1_1602912_767520) v(n1_1602912_728608) v(n1_1564000_767520) v(n1_1526304_767520) v(n1_1564000_728608) v(n1_1526304_728608) v(n1_1487392_767520) v(n1_1449696_767520) v(n1_1487392_728608) v(n1_1449696_728608) v(n1_1412000_767520) v(n1_1373088_767520) v(n1_1412000_728608) v(n1_1373088_728608) v(n1_1335392_767520) v(n1_1335392_728608) v(n1_1335392_692128) v(n1_1335392_653216) v(n1_1373088_692128) v(n1_1373088_653216) v(n1_1335392_614304) v(n1_1335392_577824) v(n1_1373088_614304) v(n1_1296480_538912) v(n1_1373088_577824) v(n1_1335392_538912) v(n1_1335392_502432) v(n1_1373088_538912) v(n1_1296480_502432) v(n1_1296480_480880) v(n1_1258784_502432) v(n1_1258784_480880) v(n1_1258784_480720) v(n1_1219872_480880) v(n1_1219872_480720) v(n1_1182176_480720) v(n1_1335392_480880) v(n1_1296480_480720) v(n1_1373088_480880) v(n1_1335392_480720) v(n1_1373088_502432) v(n1_1412000_502432) v(n1_1412000_538912) v(n1_1449696_538912) v(n1_1412000_577824) v(n1_1412000_614304) v(n1_1449696_577824) v(n1_1449696_614304) v(n1_1412000_653216) v(n1_1412000_692128) v(n1_1449696_653216) v(n1_1449696_692128) v(n1_1487392_692128) v(n1_1526304_692128) v(n1_1487392_653216) v(n1_1526304_653216) v(n1_1564000_692128) v(n1_1602912_692128) v(n1_1564000_653216) v(n1_1641180_728608) v(n1_1602912_653216) v(n1_1641180_692128) v(n1_1641290_692128) v(n1_1641180_653216) v(n1_1641290_728608) v(n1_1641290_767520) v(n1_1641180_614304) v(n1_1641290_653216) v(n1_1602912_614304) v(n1_1602912_577824) v(n1_1564000_614304) v(n1_1526304_614304) v(n1_1564000_577824) v(n1_1526304_577824) v(n1_1487392_614304) v(n1_1487392_577824) v(n1_1487392_538912) v(n1_1487392_502432) v(n1_1526304_538912) v(n1_1449696_502432) v(n1_1449696_480880) v(n1_1412000_480880) v(n1_1412000_480720) v(n1_1373088_480720) v(n1_1487392_480880) v(n1_1449696_480720) v(n1_1526304_480880) v(n1_1487392_480720) v(n1_1526304_502432) v(n1_1564000_502432) v(n1_1564000_538912) v(n1_1602912_538912) v(n1_1641180_577824) v(n1_1602912_502432) v(n1_1641180_538912) v(n1_1641290_538912) v(n1_1641180_502432) v(n1_1641290_577824) v(n1_1641290_614304) v(n1_1641180_480880) v(n1_1641290_502432) v(n1_1602912_480880) v(n1_1602912_480720) v(n1_1620161_480880) v(n1_1564000_480880) v(n1_1564000_480720) v(n1_1526304_480720) v(n1_1620161_300000) v(n1_1620161_481040) v(n1_1620161_295000) v(n1_1641290_480880) v(n1_1641180_480720)
.end
