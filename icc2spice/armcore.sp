v0 n_979937_1820000 0 1.8
v1 n_1620161_300000 0 1.8
R27_0_0 n27_295000_940095 n27_300000_940095 0.0073684200000000005
R27_0_1 n27_300000_940095 n27_474796_940095 0.257594
R27_0_2 n27_474796_940095 n27_474906_940095 0.000162105
R27_1_0 n27_474686_957216 n27_474796_957216 0.00019250000000000002
R27_1_1 n27_474796_957216 n27_493920_957216 0.033467
R27_1_2 n27_493920_957216 n27_532832_957216 0.068096
R27_1_3 n27_532832_957216 n27_570528_957216 0.065968
R27_1_4 n27_570528_957216 n27_609440_957216 0.068096
R27_1_5 n27_609440_957216 n27_647136_957216 0.065968
R27_1_6 n27_647136_957216 n27_686048_957216 0.068096
R27_1_7 n27_686048_957216 n27_723744_957216 0.065968
R27_1_8 n27_723744_957216 n27_761440_957216 0.065968
R27_1_9 n27_761440_957216 n27_800352_957216 0.068096
R27_1_10 n27_800352_957216 n27_838048_957216 0.065968
R27_1_11 n27_838048_957216 n27_876960_957216 0.068096
R27_1_12 n27_876960_957216 n27_914656_957216 0.065968
R27_1_13 n27_914656_957216 n27_952352_957216 0.065968
R27_1_14 n27_952352_957216 n27_991264_957216 0.068096
R27_1_15 n27_991264_957216 n27_1028960_957216 0.065968
R27_1_16 n27_1028960_957216 n27_1067872_957216 0.068096
R27_1_17 n27_1067872_957216 n27_1105568_957216 0.065968
R27_1_18 n27_1105568_957216 n27_1144480_957216 0.068096
R27_1_19 n27_1144480_957216 n27_1182176_957216 0.065968
R27_1_20 n27_1182176_957216 n27_1219872_957216 0.065968
R27_1_21 n27_1219872_957216 n27_1258784_957216 0.068096
R27_1_22 n27_1258784_957216 n27_1296480_957216 0.065968
R27_1_23 n27_1296480_957216 n27_1335392_957216 0.068096
R27_1_24 n27_1335392_957216 n27_1373088_957216 0.065968
R27_1_25 n27_1373088_957216 n27_1412000_957216 0.068096
R27_1_26 n27_1412000_957216 n27_1449696_957216 0.065968
R27_1_27 n27_1449696_957216 n27_1487392_957216 0.065968
R27_1_28 n27_1487392_957216 n27_1526304_957216 0.068096
R27_1_29 n27_1526304_957216 n27_1564000_957216 0.065968
R27_1_30 n27_1564000_957216 n27_1602912_957216 0.068096
R27_1_31 n27_1602912_957216 n27_1641180_957216 0.066969
R27_1_32 n27_1641180_957216 n27_1641290_957216 0.00019250000000000002
R27_2_0 n27_474686_993696 n27_474796_993696 0.00019250000000000002
R27_2_1 n27_474796_993696 n27_493920_993696 0.033467
R27_2_2 n27_493920_993696 n27_532832_993696 0.068096
R27_2_3 n27_532832_993696 n27_570528_993696 0.065968
R27_2_4 n27_570528_993696 n27_609440_993696 0.068096
R27_2_5 n27_609440_993696 n27_647136_993696 0.065968
R27_2_6 n27_647136_993696 n27_686048_993696 0.068096
R27_2_7 n27_686048_993696 n27_723744_993696 0.065968
R27_2_8 n27_723744_993696 n27_761440_993696 0.065968
R27_2_9 n27_761440_993696 n27_800352_993696 0.068096
R27_2_10 n27_800352_993696 n27_838048_993696 0.065968
R27_2_11 n27_838048_993696 n27_876960_993696 0.068096
R27_2_12 n27_876960_993696 n27_914656_993696 0.065968
R27_2_13 n27_914656_993696 n27_952352_993696 0.065968
R27_2_14 n27_952352_993696 n27_991264_993696 0.068096
R27_2_15 n27_991264_993696 n27_1028960_993696 0.065968
R27_2_16 n27_1028960_993696 n27_1067872_993696 0.068096
R27_2_17 n27_1067872_993696 n27_1105568_993696 0.065968
R27_2_18 n27_1105568_993696 n27_1144480_993696 0.068096
R27_2_19 n27_1144480_993696 n27_1182176_993696 0.065968
R27_2_20 n27_1182176_993696 n27_1219872_993696 0.065968
R27_2_21 n27_1219872_993696 n27_1258784_993696 0.068096
R27_2_22 n27_1258784_993696 n27_1296480_993696 0.065968
R27_2_23 n27_1296480_993696 n27_1335392_993696 0.068096
R27_2_24 n27_1335392_993696 n27_1373088_993696 0.065968
R27_2_25 n27_1373088_993696 n27_1412000_993696 0.068096
R27_2_26 n27_1412000_993696 n27_1449696_993696 0.065968
R27_2_27 n27_1449696_993696 n27_1487392_993696 0.065968
R27_2_28 n27_1487392_993696 n27_1526304_993696 0.068096
R27_2_29 n27_1526304_993696 n27_1564000_993696 0.065968
R27_2_30 n27_1564000_993696 n27_1602912_993696 0.068096
R27_2_31 n27_1602912_993696 n27_1641180_993696 0.066969
R27_2_32 n27_1641180_993696 n27_1641290_993696 0.00019250000000000002
R27_3_0 n27_474686_1032608 n27_474796_1032608 0.00019250000000000002
R27_3_1 n27_474796_1032608 n27_493920_1032608 0.033467
R27_3_2 n27_493920_1032608 n27_532832_1032608 0.068096
R27_3_3 n27_532832_1032608 n27_570528_1032608 0.065968
R27_3_4 n27_570528_1032608 n27_609440_1032608 0.068096
R27_3_5 n27_609440_1032608 n27_647136_1032608 0.065968
R27_3_6 n27_647136_1032608 n27_686048_1032608 0.068096
R27_3_7 n27_686048_1032608 n27_723744_1032608 0.065968
R27_3_8 n27_723744_1032608 n27_761440_1032608 0.065968
R27_3_9 n27_761440_1032608 n27_800352_1032608 0.068096
R27_3_10 n27_800352_1032608 n27_838048_1032608 0.065968
R27_3_11 n27_838048_1032608 n27_876960_1032608 0.068096
R27_3_12 n27_876960_1032608 n27_914656_1032608 0.065968
R27_3_13 n27_914656_1032608 n27_952352_1032608 0.065968
R27_3_14 n27_952352_1032608 n27_991264_1032608 0.068096
R27_3_15 n27_991264_1032608 n27_1028960_1032608 0.065968
R27_3_16 n27_1028960_1032608 n27_1067872_1032608 0.068096
R27_3_17 n27_1067872_1032608 n27_1105568_1032608 0.065968
R27_3_18 n27_1105568_1032608 n27_1144480_1032608 0.068096
R27_3_19 n27_1144480_1032608 n27_1182176_1032608 0.065968
R27_3_20 n27_1182176_1032608 n27_1219872_1032608 0.065968
R27_3_21 n27_1219872_1032608 n27_1258784_1032608 0.068096
R27_3_22 n27_1258784_1032608 n27_1296480_1032608 0.065968
R27_3_23 n27_1296480_1032608 n27_1335392_1032608 0.068096
R27_3_24 n27_1335392_1032608 n27_1373088_1032608 0.065968
R27_3_25 n27_1373088_1032608 n27_1412000_1032608 0.068096
R27_3_26 n27_1412000_1032608 n27_1449696_1032608 0.065968
R27_3_27 n27_1449696_1032608 n27_1487392_1032608 0.065968
R27_3_28 n27_1487392_1032608 n27_1526304_1032608 0.068096
R27_3_29 n27_1526304_1032608 n27_1564000_1032608 0.065968
R27_3_30 n27_1564000_1032608 n27_1602912_1032608 0.068096
R27_3_31 n27_1602912_1032608 n27_1641180_1032608 0.066969
R27_3_32 n27_1641180_1032608 n27_1641290_1032608 0.00019250000000000002
R27_4_0 n27_474686_1071520 n27_474796_1071520 0.00019250000000000002
R27_4_1 n27_474796_1071520 n27_493920_1071520 0.033467
R27_4_2 n27_493920_1071520 n27_532832_1071520 0.068096
R27_4_3 n27_532832_1071520 n27_570528_1071520 0.065968
R27_4_4 n27_570528_1071520 n27_609440_1071520 0.068096
R27_4_5 n27_609440_1071520 n27_647136_1071520 0.065968
R27_4_6 n27_647136_1071520 n27_686048_1071520 0.068096
R27_4_7 n27_686048_1071520 n27_723744_1071520 0.065968
R27_4_8 n27_723744_1071520 n27_761440_1071520 0.065968
R27_4_9 n27_761440_1071520 n27_800352_1071520 0.068096
R27_4_10 n27_800352_1071520 n27_838048_1071520 0.065968
R27_4_11 n27_838048_1071520 n27_876960_1071520 0.068096
R27_4_12 n27_876960_1071520 n27_914656_1071520 0.065968
R27_4_13 n27_914656_1071520 n27_952352_1071520 0.065968
R27_4_14 n27_952352_1071520 n27_991264_1071520 0.068096
R27_4_15 n27_991264_1071520 n27_1028960_1071520 0.065968
R27_4_16 n27_1028960_1071520 n27_1067872_1071520 0.068096
R27_4_17 n27_1067872_1071520 n27_1105568_1071520 0.065968
R27_4_18 n27_1105568_1071520 n27_1144480_1071520 0.068096
R27_4_19 n27_1144480_1071520 n27_1182176_1071520 0.065968
R27_4_20 n27_1182176_1071520 n27_1219872_1071520 0.065968
R27_4_21 n27_1219872_1071520 n27_1258784_1071520 0.068096
R27_4_22 n27_1258784_1071520 n27_1296480_1071520 0.065968
R27_4_23 n27_1296480_1071520 n27_1335392_1071520 0.068096
R27_4_24 n27_1335392_1071520 n27_1373088_1071520 0.065968
R27_4_25 n27_1373088_1071520 n27_1412000_1071520 0.068096
R27_4_26 n27_1412000_1071520 n27_1449696_1071520 0.065968
R27_4_27 n27_1449696_1071520 n27_1487392_1071520 0.065968
R27_4_28 n27_1487392_1071520 n27_1526304_1071520 0.068096
R27_4_29 n27_1526304_1071520 n27_1564000_1071520 0.065968
R27_4_30 n27_1564000_1071520 n27_1602912_1071520 0.068096
R27_4_31 n27_1602912_1071520 n27_1641180_1071520 0.066969
R27_4_32 n27_1641180_1071520 n27_1641290_1071520 0.00019250000000000002
R27_5_0 n27_474686_1108000 n27_474796_1108000 0.00019250000000000002
R27_5_1 n27_474796_1108000 n27_493920_1108000 0.033467
R27_5_2 n27_493920_1108000 n27_532832_1108000 0.068096
R27_5_3 n27_532832_1108000 n27_570528_1108000 0.065968
R27_5_4 n27_570528_1108000 n27_609440_1108000 0.068096
R27_5_5 n27_609440_1108000 n27_647136_1108000 0.065968
R27_5_6 n27_647136_1108000 n27_686048_1108000 0.068096
R27_5_7 n27_686048_1108000 n27_723744_1108000 0.065968
R27_5_8 n27_723744_1108000 n27_761440_1108000 0.065968
R27_5_9 n27_761440_1108000 n27_800352_1108000 0.068096
R27_5_10 n27_800352_1108000 n27_838048_1108000 0.065968
R27_5_11 n27_838048_1108000 n27_876960_1108000 0.068096
R27_5_12 n27_876960_1108000 n27_914656_1108000 0.065968
R27_5_13 n27_914656_1108000 n27_952352_1108000 0.065968
R27_5_14 n27_952352_1108000 n27_991264_1108000 0.068096
R27_5_15 n27_991264_1108000 n27_1028960_1108000 0.065968
R27_5_16 n27_1028960_1108000 n27_1067872_1108000 0.068096
R27_5_17 n27_1067872_1108000 n27_1105568_1108000 0.065968
R27_5_18 n27_1105568_1108000 n27_1144480_1108000 0.068096
R27_5_19 n27_1144480_1108000 n27_1182176_1108000 0.065968
R27_5_20 n27_1182176_1108000 n27_1219872_1108000 0.065968
R27_5_21 n27_1219872_1108000 n27_1258784_1108000 0.068096
R27_5_22 n27_1258784_1108000 n27_1296480_1108000 0.065968
R27_5_23 n27_1296480_1108000 n27_1335392_1108000 0.068096
R27_5_24 n27_1335392_1108000 n27_1373088_1108000 0.065968
R27_5_25 n27_1373088_1108000 n27_1412000_1108000 0.068096
R27_5_26 n27_1412000_1108000 n27_1449696_1108000 0.065968
R27_5_27 n27_1449696_1108000 n27_1487392_1108000 0.065968
R27_5_28 n27_1487392_1108000 n27_1526304_1108000 0.068096
R27_5_29 n27_1526304_1108000 n27_1564000_1108000 0.065968
R27_5_30 n27_1564000_1108000 n27_1602912_1108000 0.068096
R27_5_31 n27_1602912_1108000 n27_1641180_1108000 0.066969
R27_5_32 n27_1641180_1108000 n27_1641290_1108000 0.00019250000000000002
R27_6_0 n27_474686_1146912 n27_474796_1146912 0.00019250000000000002
R27_6_1 n27_474796_1146912 n27_493920_1146912 0.033467
R27_6_2 n27_493920_1146912 n27_532832_1146912 0.068096
R27_6_3 n27_532832_1146912 n27_570528_1146912 0.065968
R27_6_4 n27_570528_1146912 n27_609440_1146912 0.068096
R27_6_5 n27_609440_1146912 n27_647136_1146912 0.065968
R27_6_6 n27_647136_1146912 n27_686048_1146912 0.068096
R27_6_7 n27_686048_1146912 n27_723744_1146912 0.065968
R27_6_8 n27_723744_1146912 n27_761440_1146912 0.065968
R27_6_9 n27_761440_1146912 n27_800352_1146912 0.068096
R27_6_10 n27_800352_1146912 n27_838048_1146912 0.065968
R27_6_11 n27_838048_1146912 n27_876960_1146912 0.068096
R27_6_12 n27_876960_1146912 n27_914656_1146912 0.065968
R27_6_13 n27_914656_1146912 n27_952352_1146912 0.065968
R27_6_14 n27_952352_1146912 n27_991264_1146912 0.068096
R27_6_15 n27_991264_1146912 n27_1028960_1146912 0.065968
R27_6_16 n27_1028960_1146912 n27_1067872_1146912 0.068096
R27_6_17 n27_1067872_1146912 n27_1105568_1146912 0.065968
R27_6_18 n27_1105568_1146912 n27_1144480_1146912 0.068096
R27_6_19 n27_1144480_1146912 n27_1182176_1146912 0.065968
R27_6_20 n27_1182176_1146912 n27_1219872_1146912 0.065968
R27_6_21 n27_1219872_1146912 n27_1258784_1146912 0.068096
R27_6_22 n27_1258784_1146912 n27_1296480_1146912 0.065968
R27_6_23 n27_1296480_1146912 n27_1335392_1146912 0.068096
R27_6_24 n27_1335392_1146912 n27_1373088_1146912 0.065968
R27_6_25 n27_1373088_1146912 n27_1412000_1146912 0.068096
R27_6_26 n27_1412000_1146912 n27_1449696_1146912 0.065968
R27_6_27 n27_1449696_1146912 n27_1487392_1146912 0.065968
R27_6_28 n27_1487392_1146912 n27_1526304_1146912 0.068096
R27_6_29 n27_1526304_1146912 n27_1564000_1146912 0.065968
R27_6_30 n27_1564000_1146912 n27_1602912_1146912 0.068096
R27_6_31 n27_1602912_1146912 n27_1641180_1146912 0.066969
R27_6_32 n27_1641180_1146912 n27_1641290_1146912 0.00019250000000000002
R27_7_0 n27_474686_1183392 n27_474796_1183392 0.00019250000000000002
R27_7_1 n27_474796_1183392 n27_493920_1183392 0.033467
R27_7_2 n27_493920_1183392 n27_532832_1183392 0.068096
R27_7_3 n27_532832_1183392 n27_570528_1183392 0.065968
R27_7_4 n27_570528_1183392 n27_609440_1183392 0.068096
R27_7_5 n27_609440_1183392 n27_647136_1183392 0.065968
R27_7_6 n27_647136_1183392 n27_686048_1183392 0.068096
R27_7_7 n27_686048_1183392 n27_723744_1183392 0.065968
R27_7_8 n27_723744_1183392 n27_761440_1183392 0.065968
R27_7_9 n27_761440_1183392 n27_800352_1183392 0.068096
R27_7_10 n27_800352_1183392 n27_838048_1183392 0.065968
R27_7_11 n27_838048_1183392 n27_876960_1183392 0.068096
R27_7_12 n27_876960_1183392 n27_914656_1183392 0.065968
R27_7_13 n27_914656_1183392 n27_952352_1183392 0.065968
R27_7_14 n27_952352_1183392 n27_991264_1183392 0.068096
R27_7_15 n27_991264_1183392 n27_1028960_1183392 0.065968
R27_7_16 n27_1028960_1183392 n27_1067872_1183392 0.068096
R27_7_17 n27_1067872_1183392 n27_1105568_1183392 0.065968
R27_7_18 n27_1105568_1183392 n27_1144480_1183392 0.068096
R27_7_19 n27_1144480_1183392 n27_1182176_1183392 0.065968
R27_7_20 n27_1182176_1183392 n27_1219872_1183392 0.065968
R27_7_21 n27_1219872_1183392 n27_1258784_1183392 0.068096
R27_7_22 n27_1258784_1183392 n27_1296480_1183392 0.065968
R27_7_23 n27_1296480_1183392 n27_1335392_1183392 0.068096
R27_7_24 n27_1335392_1183392 n27_1373088_1183392 0.065968
R27_7_25 n27_1373088_1183392 n27_1412000_1183392 0.068096
R27_7_26 n27_1412000_1183392 n27_1449696_1183392 0.065968
R27_7_27 n27_1449696_1183392 n27_1487392_1183392 0.065968
R27_7_28 n27_1487392_1183392 n27_1526304_1183392 0.068096
R27_7_29 n27_1526304_1183392 n27_1564000_1183392 0.065968
R27_7_30 n27_1564000_1183392 n27_1602912_1183392 0.068096
R27_7_31 n27_1602912_1183392 n27_1641180_1183392 0.066969
R27_7_32 n27_1641180_1183392 n27_1641290_1183392 0.00019250000000000002
R27_8_0 n27_474686_1222304 n27_474796_1222304 0.00019250000000000002
R27_8_1 n27_474796_1222304 n27_493920_1222304 0.033467
R27_8_2 n27_493920_1222304 n27_532832_1222304 0.068096
R27_8_3 n27_532832_1222304 n27_570528_1222304 0.065968
R27_8_4 n27_570528_1222304 n27_609440_1222304 0.068096
R27_8_5 n27_609440_1222304 n27_647136_1222304 0.065968
R27_8_6 n27_647136_1222304 n27_686048_1222304 0.068096
R27_8_7 n27_686048_1222304 n27_723744_1222304 0.065968
R27_8_8 n27_723744_1222304 n27_761440_1222304 0.065968
R27_8_9 n27_761440_1222304 n27_800352_1222304 0.068096
R27_8_10 n27_800352_1222304 n27_838048_1222304 0.065968
R27_8_11 n27_838048_1222304 n27_876960_1222304 0.068096
R27_8_12 n27_876960_1222304 n27_914656_1222304 0.065968
R27_8_13 n27_914656_1222304 n27_952352_1222304 0.065968
R27_8_14 n27_952352_1222304 n27_991264_1222304 0.068096
R27_8_15 n27_991264_1222304 n27_1028960_1222304 0.065968
R27_8_16 n27_1028960_1222304 n27_1067872_1222304 0.068096
R27_8_17 n27_1067872_1222304 n27_1105568_1222304 0.065968
R27_8_18 n27_1105568_1222304 n27_1144480_1222304 0.068096
R27_8_19 n27_1144480_1222304 n27_1182176_1222304 0.065968
R27_8_20 n27_1182176_1222304 n27_1219872_1222304 0.065968
R27_8_21 n27_1219872_1222304 n27_1258784_1222304 0.068096
R27_8_22 n27_1258784_1222304 n27_1296480_1222304 0.065968
R27_8_23 n27_1296480_1222304 n27_1335392_1222304 0.068096
R27_8_24 n27_1335392_1222304 n27_1373088_1222304 0.065968
R27_8_25 n27_1373088_1222304 n27_1412000_1222304 0.068096
R27_8_26 n27_1412000_1222304 n27_1449696_1222304 0.065968
R27_8_27 n27_1449696_1222304 n27_1487392_1222304 0.065968
R27_8_28 n27_1487392_1222304 n27_1526304_1222304 0.068096
R27_8_29 n27_1526304_1222304 n27_1564000_1222304 0.065968
R27_8_30 n27_1564000_1222304 n27_1602912_1222304 0.068096
R27_8_31 n27_1602912_1222304 n27_1641180_1222304 0.066969
R27_8_32 n27_1641180_1222304 n27_1641290_1222304 0.00019250000000000002
R27_9_0 n27_474686_1261216 n27_474796_1261216 0.00019250000000000002
R27_9_1 n27_474796_1261216 n27_493920_1261216 0.033467
R27_9_2 n27_493920_1261216 n27_532832_1261216 0.068096
R27_9_3 n27_532832_1261216 n27_570528_1261216 0.065968
R27_9_4 n27_570528_1261216 n27_609440_1261216 0.068096
R27_9_5 n27_609440_1261216 n27_647136_1261216 0.065968
R27_9_6 n27_647136_1261216 n27_686048_1261216 0.068096
R27_9_7 n27_686048_1261216 n27_723744_1261216 0.065968
R27_9_8 n27_723744_1261216 n27_761440_1261216 0.065968
R27_9_9 n27_761440_1261216 n27_800352_1261216 0.068096
R27_9_10 n27_800352_1261216 n27_838048_1261216 0.065968
R27_9_11 n27_838048_1261216 n27_876960_1261216 0.068096
R27_9_12 n27_876960_1261216 n27_914656_1261216 0.065968
R27_9_13 n27_914656_1261216 n27_952352_1261216 0.065968
R27_9_14 n27_952352_1261216 n27_991264_1261216 0.068096
R27_9_15 n27_991264_1261216 n27_1028960_1261216 0.065968
R27_9_16 n27_1028960_1261216 n27_1067872_1261216 0.068096
R27_9_17 n27_1067872_1261216 n27_1105568_1261216 0.065968
R27_9_18 n27_1105568_1261216 n27_1144480_1261216 0.068096
R27_9_19 n27_1144480_1261216 n27_1182176_1261216 0.065968
R27_9_20 n27_1182176_1261216 n27_1219872_1261216 0.065968
R27_9_21 n27_1219872_1261216 n27_1258784_1261216 0.068096
R27_9_22 n27_1258784_1261216 n27_1296480_1261216 0.065968
R27_9_23 n27_1296480_1261216 n27_1335392_1261216 0.068096
R27_9_24 n27_1335392_1261216 n27_1373088_1261216 0.065968
R27_9_25 n27_1373088_1261216 n27_1412000_1261216 0.068096
R27_9_26 n27_1412000_1261216 n27_1449696_1261216 0.065968
R27_9_27 n27_1449696_1261216 n27_1487392_1261216 0.065968
R27_9_28 n27_1487392_1261216 n27_1526304_1261216 0.068096
R27_9_29 n27_1526304_1261216 n27_1564000_1261216 0.065968
R27_9_30 n27_1564000_1261216 n27_1602912_1261216 0.068096
R27_9_31 n27_1602912_1261216 n27_1641180_1261216 0.066969
R27_9_32 n27_1641180_1261216 n27_1641290_1261216 0.00019250000000000002
R27_10_0 n27_474686_1297696 n27_474796_1297696 0.00019250000000000002
R27_10_1 n27_474796_1297696 n27_493920_1297696 0.033467
R27_10_2 n27_493920_1297696 n27_532832_1297696 0.068096
R27_10_3 n27_532832_1297696 n27_570528_1297696 0.065968
R27_10_4 n27_570528_1297696 n27_609440_1297696 0.068096
R27_10_5 n27_609440_1297696 n27_647136_1297696 0.065968
R27_10_6 n27_647136_1297696 n27_686048_1297696 0.068096
R27_10_7 n27_686048_1297696 n27_723744_1297696 0.065968
R27_10_8 n27_723744_1297696 n27_761440_1297696 0.065968
R27_10_9 n27_761440_1297696 n27_800352_1297696 0.068096
R27_10_10 n27_800352_1297696 n27_838048_1297696 0.065968
R27_10_11 n27_838048_1297696 n27_876960_1297696 0.068096
R27_10_12 n27_876960_1297696 n27_914656_1297696 0.065968
R27_10_13 n27_914656_1297696 n27_952352_1297696 0.065968
R27_10_14 n27_952352_1297696 n27_991264_1297696 0.068096
R27_10_15 n27_991264_1297696 n27_1028960_1297696 0.065968
R27_10_16 n27_1028960_1297696 n27_1067872_1297696 0.068096
R27_10_17 n27_1067872_1297696 n27_1105568_1297696 0.065968
R27_10_18 n27_1105568_1297696 n27_1144480_1297696 0.068096
R27_10_19 n27_1144480_1297696 n27_1182176_1297696 0.065968
R27_10_20 n27_1182176_1297696 n27_1219872_1297696 0.065968
R27_10_21 n27_1219872_1297696 n27_1258784_1297696 0.068096
R27_10_22 n27_1258784_1297696 n27_1296480_1297696 0.065968
R27_10_23 n27_1296480_1297696 n27_1335392_1297696 0.068096
R27_10_24 n27_1335392_1297696 n27_1373088_1297696 0.065968
R27_10_25 n27_1373088_1297696 n27_1412000_1297696 0.068096
R27_10_26 n27_1412000_1297696 n27_1449696_1297696 0.065968
R27_10_27 n27_1449696_1297696 n27_1487392_1297696 0.065968
R27_10_28 n27_1487392_1297696 n27_1526304_1297696 0.068096
R27_10_29 n27_1526304_1297696 n27_1564000_1297696 0.065968
R27_10_30 n27_1564000_1297696 n27_1602912_1297696 0.068096
R27_10_31 n27_1602912_1297696 n27_1641180_1297696 0.066969
R27_10_32 n27_1641180_1297696 n27_1641290_1297696 0.00019250000000000002
R27_11_0 n27_474686_1336608 n27_474796_1336608 0.00019250000000000002
R27_11_1 n27_474796_1336608 n27_493920_1336608 0.033467
R27_11_2 n27_493920_1336608 n27_532832_1336608 0.068096
R27_11_3 n27_532832_1336608 n27_570528_1336608 0.065968
R27_11_4 n27_570528_1336608 n27_609440_1336608 0.068096
R27_11_5 n27_609440_1336608 n27_647136_1336608 0.065968
R27_11_6 n27_647136_1336608 n27_686048_1336608 0.068096
R27_11_7 n27_686048_1336608 n27_723744_1336608 0.065968
R27_11_8 n27_723744_1336608 n27_761440_1336608 0.065968
R27_11_9 n27_761440_1336608 n27_800352_1336608 0.068096
R27_11_10 n27_800352_1336608 n27_838048_1336608 0.065968
R27_11_11 n27_838048_1336608 n27_876960_1336608 0.068096
R27_11_12 n27_876960_1336608 n27_914656_1336608 0.065968
R27_11_13 n27_914656_1336608 n27_952352_1336608 0.065968
R27_11_14 n27_952352_1336608 n27_991264_1336608 0.068096
R27_11_15 n27_991264_1336608 n27_1028960_1336608 0.065968
R27_11_16 n27_1028960_1336608 n27_1067872_1336608 0.068096
R27_11_17 n27_1067872_1336608 n27_1105568_1336608 0.065968
R27_11_18 n27_1105568_1336608 n27_1144480_1336608 0.068096
R27_11_19 n27_1144480_1336608 n27_1182176_1336608 0.065968
R27_11_20 n27_1182176_1336608 n27_1219872_1336608 0.065968
R27_11_21 n27_1219872_1336608 n27_1258784_1336608 0.068096
R27_11_22 n27_1258784_1336608 n27_1296480_1336608 0.065968
R27_11_23 n27_1296480_1336608 n27_1335392_1336608 0.068096
R27_11_24 n27_1335392_1336608 n27_1373088_1336608 0.065968
R27_11_25 n27_1373088_1336608 n27_1412000_1336608 0.068096
R27_11_26 n27_1412000_1336608 n27_1449696_1336608 0.065968
R27_11_27 n27_1449696_1336608 n27_1487392_1336608 0.065968
R27_11_28 n27_1487392_1336608 n27_1526304_1336608 0.068096
R27_11_29 n27_1526304_1336608 n27_1564000_1336608 0.065968
R27_11_30 n27_1564000_1336608 n27_1602912_1336608 0.068096
R27_11_31 n27_1602912_1336608 n27_1641180_1336608 0.066969
R27_11_32 n27_1641180_1336608 n27_1641290_1336608 0.00019250000000000002
R27_12_0 n27_474686_1373088 n27_474796_1373088 0.00019250000000000002
R27_12_1 n27_474796_1373088 n27_493920_1373088 0.033467
R27_12_2 n27_493920_1373088 n27_532832_1373088 0.068096
R27_12_3 n27_532832_1373088 n27_570528_1373088 0.065968
R27_12_4 n27_570528_1373088 n27_609440_1373088 0.068096
R27_12_5 n27_609440_1373088 n27_647136_1373088 0.065968
R27_12_6 n27_647136_1373088 n27_686048_1373088 0.068096
R27_12_7 n27_686048_1373088 n27_723744_1373088 0.065968
R27_12_8 n27_723744_1373088 n27_761440_1373088 0.065968
R27_12_9 n27_761440_1373088 n27_800352_1373088 0.068096
R27_12_10 n27_800352_1373088 n27_838048_1373088 0.065968
R27_12_11 n27_838048_1373088 n27_876960_1373088 0.068096
R27_12_12 n27_876960_1373088 n27_914656_1373088 0.065968
R27_12_13 n27_914656_1373088 n27_952352_1373088 0.065968
R27_12_14 n27_952352_1373088 n27_991264_1373088 0.068096
R27_12_15 n27_991264_1373088 n27_1028960_1373088 0.065968
R27_12_16 n27_1028960_1373088 n27_1067872_1373088 0.068096
R27_12_17 n27_1067872_1373088 n27_1105568_1373088 0.065968
R27_12_18 n27_1105568_1373088 n27_1144480_1373088 0.068096
R27_12_19 n27_1144480_1373088 n27_1182176_1373088 0.065968
R27_12_20 n27_1182176_1373088 n27_1219872_1373088 0.065968
R27_12_21 n27_1219872_1373088 n27_1258784_1373088 0.068096
R27_12_22 n27_1258784_1373088 n27_1296480_1373088 0.065968
R27_12_23 n27_1296480_1373088 n27_1335392_1373088 0.068096
R27_12_24 n27_1335392_1373088 n27_1373088_1373088 0.065968
R27_12_25 n27_1373088_1373088 n27_1412000_1373088 0.068096
R27_12_26 n27_1412000_1373088 n27_1449696_1373088 0.065968
R27_12_27 n27_1449696_1373088 n27_1487392_1373088 0.065968
R27_12_28 n27_1487392_1373088 n27_1526304_1373088 0.068096
R27_12_29 n27_1526304_1373088 n27_1564000_1373088 0.065968
R27_12_30 n27_1564000_1373088 n27_1602912_1373088 0.068096
R27_12_31 n27_1602912_1373088 n27_1641180_1373088 0.066969
R27_12_32 n27_1641180_1373088 n27_1641290_1373088 0.00019250000000000002
R27_13_0 n27_474686_1412000 n27_474796_1412000 0.00019250000000000002
R27_13_1 n27_474796_1412000 n27_493920_1412000 0.033467
R27_13_2 n27_493920_1412000 n27_532832_1412000 0.068096
R27_13_3 n27_532832_1412000 n27_570528_1412000 0.065968
R27_13_4 n27_570528_1412000 n27_609440_1412000 0.068096
R27_13_5 n27_609440_1412000 n27_647136_1412000 0.065968
R27_13_6 n27_647136_1412000 n27_686048_1412000 0.068096
R27_13_7 n27_686048_1412000 n27_723744_1412000 0.065968
R27_13_8 n27_723744_1412000 n27_761440_1412000 0.065968
R27_13_9 n27_761440_1412000 n27_800352_1412000 0.068096
R27_13_10 n27_800352_1412000 n27_838048_1412000 0.065968
R27_13_11 n27_838048_1412000 n27_876960_1412000 0.068096
R27_13_12 n27_876960_1412000 n27_914656_1412000 0.065968
R27_13_13 n27_914656_1412000 n27_952352_1412000 0.065968
R27_13_14 n27_952352_1412000 n27_991264_1412000 0.068096
R27_13_15 n27_991264_1412000 n27_1028960_1412000 0.065968
R27_13_16 n27_1028960_1412000 n27_1067872_1412000 0.068096
R27_13_17 n27_1067872_1412000 n27_1105568_1412000 0.065968
R27_13_18 n27_1105568_1412000 n27_1144480_1412000 0.068096
R27_13_19 n27_1144480_1412000 n27_1182176_1412000 0.065968
R27_13_20 n27_1182176_1412000 n27_1219872_1412000 0.065968
R27_13_21 n27_1219872_1412000 n27_1258784_1412000 0.068096
R27_13_22 n27_1258784_1412000 n27_1296480_1412000 0.065968
R27_13_23 n27_1296480_1412000 n27_1335392_1412000 0.068096
R27_13_24 n27_1335392_1412000 n27_1373088_1412000 0.065968
R27_13_25 n27_1373088_1412000 n27_1412000_1412000 0.068096
R27_13_26 n27_1412000_1412000 n27_1449696_1412000 0.065968
R27_13_27 n27_1449696_1412000 n27_1487392_1412000 0.065968
R27_13_28 n27_1487392_1412000 n27_1526304_1412000 0.068096
R27_13_29 n27_1526304_1412000 n27_1564000_1412000 0.065968
R27_13_30 n27_1564000_1412000 n27_1602912_1412000 0.068096
R27_13_31 n27_1602912_1412000 n27_1641180_1412000 0.066969
R27_13_32 n27_1641180_1412000 n27_1641290_1412000 0.00019250000000000002
R27_14_0 n27_474686_1448480 n27_474796_1448480 0.00019250000000000002
R27_14_1 n27_474796_1448480 n27_493920_1448480 0.033467
R27_14_2 n27_493920_1448480 n27_532832_1448480 0.068096
R27_14_3 n27_532832_1448480 n27_570528_1448480 0.065968
R27_14_4 n27_570528_1448480 n27_609440_1448480 0.068096
R27_14_5 n27_609440_1448480 n27_647136_1448480 0.065968
R27_14_6 n27_647136_1448480 n27_686048_1448480 0.068096
R27_14_7 n27_686048_1448480 n27_723744_1448480 0.065968
R27_14_8 n27_723744_1448480 n27_761440_1448480 0.065968
R27_14_9 n27_761440_1448480 n27_800352_1448480 0.068096
R27_14_10 n27_800352_1448480 n27_838048_1448480 0.065968
R27_14_11 n27_838048_1448480 n27_876960_1448480 0.068096
R27_14_12 n27_876960_1448480 n27_914656_1448480 0.065968
R27_14_13 n27_914656_1448480 n27_952352_1448480 0.065968
R27_14_14 n27_952352_1448480 n27_991264_1448480 0.068096
R27_14_15 n27_991264_1448480 n27_1028960_1448480 0.065968
R27_14_16 n27_1028960_1448480 n27_1067872_1448480 0.068096
R27_14_17 n27_1067872_1448480 n27_1105568_1448480 0.065968
R27_14_18 n27_1105568_1448480 n27_1144480_1448480 0.068096
R27_14_19 n27_1144480_1448480 n27_1182176_1448480 0.065968
R27_14_20 n27_1182176_1448480 n27_1219872_1448480 0.065968
R27_14_21 n27_1219872_1448480 n27_1258784_1448480 0.068096
R27_14_22 n27_1258784_1448480 n27_1296480_1448480 0.065968
R27_14_23 n27_1296480_1448480 n27_1335392_1448480 0.068096
R27_14_24 n27_1335392_1448480 n27_1373088_1448480 0.065968
R27_14_25 n27_1373088_1448480 n27_1412000_1448480 0.068096
R27_14_26 n27_1412000_1448480 n27_1449696_1448480 0.065968
R27_14_27 n27_1449696_1448480 n27_1487392_1448480 0.065968
R27_14_28 n27_1487392_1448480 n27_1526304_1448480 0.068096
R27_14_29 n27_1526304_1448480 n27_1564000_1448480 0.065968
R27_14_30 n27_1564000_1448480 n27_1602912_1448480 0.068096
R27_14_31 n27_1602912_1448480 n27_1641180_1448480 0.066969
R27_14_32 n27_1641180_1448480 n27_1641290_1448480 0.00019250000000000002
R27_15_0 n27_474686_1487392 n27_474796_1487392 0.00019250000000000002
R27_15_1 n27_474796_1487392 n27_493920_1487392 0.033467
R27_15_2 n27_493920_1487392 n27_532832_1487392 0.068096
R27_15_3 n27_532832_1487392 n27_570528_1487392 0.065968
R27_15_4 n27_570528_1487392 n27_609440_1487392 0.068096
R27_15_5 n27_609440_1487392 n27_647136_1487392 0.065968
R27_15_6 n27_647136_1487392 n27_686048_1487392 0.068096
R27_15_7 n27_686048_1487392 n27_723744_1487392 0.065968
R27_15_8 n27_723744_1487392 n27_761440_1487392 0.065968
R27_15_9 n27_761440_1487392 n27_800352_1487392 0.068096
R27_15_10 n27_800352_1487392 n27_838048_1487392 0.065968
R27_15_11 n27_838048_1487392 n27_876960_1487392 0.068096
R27_15_12 n27_876960_1487392 n27_914656_1487392 0.065968
R27_15_13 n27_914656_1487392 n27_952352_1487392 0.065968
R27_15_14 n27_952352_1487392 n27_991264_1487392 0.068096
R27_15_15 n27_991264_1487392 n27_1028960_1487392 0.065968
R27_15_16 n27_1028960_1487392 n27_1067872_1487392 0.068096
R27_15_17 n27_1067872_1487392 n27_1105568_1487392 0.065968
R27_15_18 n27_1105568_1487392 n27_1144480_1487392 0.068096
R27_15_19 n27_1144480_1487392 n27_1182176_1487392 0.065968
R27_15_20 n27_1182176_1487392 n27_1219872_1487392 0.065968
R27_15_21 n27_1219872_1487392 n27_1258784_1487392 0.068096
R27_15_22 n27_1258784_1487392 n27_1296480_1487392 0.065968
R27_15_23 n27_1296480_1487392 n27_1335392_1487392 0.068096
R27_15_24 n27_1335392_1487392 n27_1373088_1487392 0.065968
R27_15_25 n27_1373088_1487392 n27_1412000_1487392 0.068096
R27_15_26 n27_1412000_1487392 n27_1449696_1487392 0.065968
R27_15_27 n27_1449696_1487392 n27_1487392_1487392 0.065968
R27_15_28 n27_1487392_1487392 n27_1526304_1487392 0.068096
R27_15_29 n27_1526304_1487392 n27_1564000_1487392 0.065968
R27_15_30 n27_1564000_1487392 n27_1602912_1487392 0.068096
R27_15_31 n27_1602912_1487392 n27_1641180_1487392 0.066969
R27_15_32 n27_1641180_1487392 n27_1641290_1487392 0.00019250000000000002
R27_16_0 n27_474686_1526304 n27_474796_1526304 0.00019250000000000002
R27_16_1 n27_474796_1526304 n27_493920_1526304 0.033467
R27_16_2 n27_493920_1526304 n27_532832_1526304 0.068096
R27_16_3 n27_532832_1526304 n27_570528_1526304 0.065968
R27_16_4 n27_570528_1526304 n27_609440_1526304 0.068096
R27_16_5 n27_609440_1526304 n27_647136_1526304 0.065968
R27_16_6 n27_647136_1526304 n27_686048_1526304 0.068096
R27_16_7 n27_686048_1526304 n27_723744_1526304 0.065968
R27_16_8 n27_723744_1526304 n27_761440_1526304 0.065968
R27_16_9 n27_761440_1526304 n27_800352_1526304 0.068096
R27_16_10 n27_800352_1526304 n27_838048_1526304 0.065968
R27_16_11 n27_838048_1526304 n27_876960_1526304 0.068096
R27_16_12 n27_876960_1526304 n27_914656_1526304 0.065968
R27_16_13 n27_914656_1526304 n27_952352_1526304 0.065968
R27_16_14 n27_952352_1526304 n27_991264_1526304 0.068096
R27_16_15 n27_991264_1526304 n27_1028960_1526304 0.065968
R27_16_16 n27_1028960_1526304 n27_1067872_1526304 0.068096
R27_16_17 n27_1067872_1526304 n27_1105568_1526304 0.065968
R27_16_18 n27_1105568_1526304 n27_1144480_1526304 0.068096
R27_16_19 n27_1144480_1526304 n27_1182176_1526304 0.065968
R27_16_20 n27_1182176_1526304 n27_1219872_1526304 0.065968
R27_16_21 n27_1219872_1526304 n27_1258784_1526304 0.068096
R27_16_22 n27_1258784_1526304 n27_1296480_1526304 0.065968
R27_16_23 n27_1296480_1526304 n27_1335392_1526304 0.068096
R27_16_24 n27_1335392_1526304 n27_1373088_1526304 0.065968
R27_16_25 n27_1373088_1526304 n27_1412000_1526304 0.068096
R27_16_26 n27_1412000_1526304 n27_1449696_1526304 0.065968
R27_16_27 n27_1449696_1526304 n27_1487392_1526304 0.065968
R27_16_28 n27_1487392_1526304 n27_1526304_1526304 0.068096
R27_16_29 n27_1526304_1526304 n27_1564000_1526304 0.065968
R27_16_30 n27_1564000_1526304 n27_1602912_1526304 0.068096
R27_16_31 n27_1602912_1526304 n27_1641180_1526304 0.066969
R27_16_32 n27_1641180_1526304 n27_1641290_1526304 0.00019250000000000002
R27_17_0 n27_474686_1562784 n27_474796_1562784 0.00019250000000000002
R27_17_1 n27_474796_1562784 n27_493920_1562784 0.033467
R27_17_2 n27_493920_1562784 n27_532832_1562784 0.068096
R27_17_3 n27_532832_1562784 n27_570528_1562784 0.065968
R27_17_4 n27_570528_1562784 n27_609440_1562784 0.068096
R27_17_5 n27_609440_1562784 n27_647136_1562784 0.065968
R27_17_6 n27_647136_1562784 n27_686048_1562784 0.068096
R27_17_7 n27_686048_1562784 n27_723744_1562784 0.065968
R27_17_8 n27_723744_1562784 n27_761440_1562784 0.065968
R27_17_9 n27_761440_1562784 n27_800352_1562784 0.068096
R27_17_10 n27_800352_1562784 n27_838048_1562784 0.065968
R27_17_11 n27_838048_1562784 n27_876960_1562784 0.068096
R27_17_12 n27_876960_1562784 n27_914656_1562784 0.065968
R27_17_13 n27_914656_1562784 n27_952352_1562784 0.065968
R27_17_14 n27_952352_1562784 n27_991264_1562784 0.068096
R27_17_15 n27_991264_1562784 n27_1028960_1562784 0.065968
R27_17_16 n27_1028960_1562784 n27_1067872_1562784 0.068096
R27_17_17 n27_1067872_1562784 n27_1105568_1562784 0.065968
R27_17_18 n27_1105568_1562784 n27_1144480_1562784 0.068096
R27_17_19 n27_1144480_1562784 n27_1182176_1562784 0.065968
R27_17_20 n27_1182176_1562784 n27_1219872_1562784 0.065968
R27_17_21 n27_1219872_1562784 n27_1258784_1562784 0.068096
R27_17_22 n27_1258784_1562784 n27_1296480_1562784 0.065968
R27_17_23 n27_1296480_1562784 n27_1335392_1562784 0.068096
R27_17_24 n27_1335392_1562784 n27_1373088_1562784 0.065968
R27_17_25 n27_1373088_1562784 n27_1412000_1562784 0.068096
R27_17_26 n27_1412000_1562784 n27_1449696_1562784 0.065968
R27_17_27 n27_1449696_1562784 n27_1487392_1562784 0.065968
R27_17_28 n27_1487392_1562784 n27_1526304_1562784 0.068096
R27_17_29 n27_1526304_1562784 n27_1564000_1562784 0.065968
R27_17_30 n27_1564000_1562784 n27_1602912_1562784 0.068096
R27_17_31 n27_1602912_1562784 n27_1641180_1562784 0.066969
R27_17_32 n27_1641180_1562784 n27_1641290_1562784 0.00019250000000000002
R27_18_0 n27_474686_1601696 n27_474796_1601696 0.00019250000000000002
R27_18_1 n27_474796_1601696 n27_493920_1601696 0.033467
R27_18_2 n27_493920_1601696 n27_532832_1601696 0.068096
R27_18_3 n27_532832_1601696 n27_570528_1601696 0.065968
R27_18_4 n27_570528_1601696 n27_609440_1601696 0.068096
R27_18_5 n27_609440_1601696 n27_647136_1601696 0.065968
R27_18_6 n27_647136_1601696 n27_686048_1601696 0.068096
R27_18_7 n27_686048_1601696 n27_723744_1601696 0.065968
R27_18_8 n27_723744_1601696 n27_761440_1601696 0.065968
R27_18_9 n27_761440_1601696 n27_800352_1601696 0.068096
R27_18_10 n27_800352_1601696 n27_838048_1601696 0.065968
R27_18_11 n27_838048_1601696 n27_876960_1601696 0.068096
R27_18_12 n27_876960_1601696 n27_914656_1601696 0.065968
R27_18_13 n27_914656_1601696 n27_952352_1601696 0.065968
R27_18_14 n27_952352_1601696 n27_991264_1601696 0.068096
R27_18_15 n27_991264_1601696 n27_1028960_1601696 0.065968
R27_18_16 n27_1028960_1601696 n27_1067872_1601696 0.068096
R27_18_17 n27_1067872_1601696 n27_1105568_1601696 0.065968
R27_18_18 n27_1105568_1601696 n27_1144480_1601696 0.068096
R27_18_19 n27_1144480_1601696 n27_1182176_1601696 0.065968
R27_18_20 n27_1182176_1601696 n27_1219872_1601696 0.065968
R27_18_21 n27_1219872_1601696 n27_1258784_1601696 0.068096
R27_18_22 n27_1258784_1601696 n27_1296480_1601696 0.065968
R27_18_23 n27_1296480_1601696 n27_1335392_1601696 0.068096
R27_18_24 n27_1335392_1601696 n27_1373088_1601696 0.065968
R27_18_25 n27_1373088_1601696 n27_1412000_1601696 0.068096
R27_18_26 n27_1412000_1601696 n27_1449696_1601696 0.065968
R27_18_27 n27_1449696_1601696 n27_1487392_1601696 0.065968
R27_18_28 n27_1487392_1601696 n27_1526304_1601696 0.068096
R27_18_29 n27_1526304_1601696 n27_1564000_1601696 0.065968
R27_18_30 n27_1564000_1601696 n27_1602912_1601696 0.068096
R27_18_31 n27_1602912_1601696 n27_1641180_1601696 0.066969
R27_18_32 n27_1641180_1601696 n27_1641290_1601696 0.00019250000000000002
R27_19_0 n27_474686_1641130 n27_474796_1641130 9.625000000000001e-05
R27_19_1 n27_474796_1641130 n27_493920_1641130 0.0167335
R27_19_2 n27_493920_1641130 n27_532832_1641130 0.034048
R27_19_3 n27_532832_1641130 n27_570528_1641130 0.032984
R27_19_4 n27_570528_1641130 n27_609440_1641130 0.034048
R27_19_5 n27_609440_1641130 n27_647136_1641130 0.032984
R27_19_6 n27_647136_1641130 n27_686048_1641130 0.034048
R27_19_7 n27_686048_1641130 n27_723744_1641130 0.032984
R27_19_8 n27_723744_1641130 n27_761440_1641130 0.032984
R27_19_9 n27_761440_1641130 n27_800352_1641130 0.034048
R27_19_10 n27_800352_1641130 n27_838048_1641130 0.032984
R27_19_11 n27_838048_1641130 n27_876960_1641130 0.034048
R27_19_12 n27_876960_1641130 n27_914656_1641130 0.032984
R27_19_13 n27_914656_1641130 n27_952352_1641130 0.032984
R27_19_14 n27_952352_1641130 n27_979937_1641130 0.0241369
R27_19_15 n27_979937_1641130 n27_991264_1641130 0.00991113
R27_19_16 n27_991264_1641130 n27_1028960_1641130 0.032984
R27_19_17 n27_1028960_1641130 n27_1067872_1641130 0.034048
R27_19_18 n27_1067872_1641130 n27_1105568_1641130 0.032984
R27_19_19 n27_1105568_1641130 n27_1144480_1641130 0.034048
R27_19_20 n27_1144480_1641130 n27_1182176_1641130 0.032984
R27_19_21 n27_1182176_1641130 n27_1219872_1641130 0.032984
R27_19_22 n27_1219872_1641130 n27_1258784_1641130 0.034048
R27_19_23 n27_1258784_1641130 n27_1296480_1641130 0.032984
R27_19_24 n27_1296480_1641130 n27_1335392_1641130 0.034048
R27_19_25 n27_1335392_1641130 n27_1373088_1641130 0.032984
R27_19_26 n27_1373088_1641130 n27_1412000_1641130 0.034048
R27_19_27 n27_1412000_1641130 n27_1449696_1641130 0.032984
R27_19_28 n27_1449696_1641130 n27_1487392_1641130 0.032984
R27_19_29 n27_1487392_1641130 n27_1526304_1641130 0.034048
R27_19_30 n27_1526304_1641130 n27_1564000_1641130 0.032984
R27_19_31 n27_1564000_1641130 n27_1602912_1641130 0.034048
R27_19_32 n27_1602912_1641130 n27_1641180_1641130 0.0334845
R27_19_33 n27_1641180_1641130 n27_1641290_1641130 9.625000000000001e-05
R27_20_0 n27_1641070_1619905 n27_1641180_1619905 0.000162105
R27_20_1 n27_1641180_1619905 n27_1820088_1619905 0.263654
R27_20_2 n27_1820088_1619905 n27_1825088_1619905 0.0073684200000000005
R27_21_0 n27_474686_918304 n27_474796_918304 0.00019250000000000002
R27_21_1 n27_474796_918304 n27_493920_918304 0.033467
R27_21_2 n27_493920_918304 n27_532832_918304 0.068096
R27_21_3 n27_532832_918304 n27_570528_918304 0.065968
R27_21_4 n27_570528_918304 n27_609440_918304 0.068096
R27_21_5 n27_609440_918304 n27_647136_918304 0.065968
R27_21_6 n27_647136_918304 n27_686048_918304 0.068096
R27_21_7 n27_686048_918304 n27_723744_918304 0.065968
R27_21_8 n27_723744_918304 n27_761440_918304 0.065968
R27_21_9 n27_761440_918304 n27_800352_918304 0.068096
R27_21_10 n27_800352_918304 n27_838048_918304 0.065968
R27_21_11 n27_838048_918304 n27_876960_918304 0.068096
R27_21_12 n27_876960_918304 n27_914656_918304 0.065968
R27_21_13 n27_914656_918304 n27_952352_918304 0.065968
R27_21_14 n27_952352_918304 n27_991264_918304 0.068096
R27_21_15 n27_991264_918304 n27_1028960_918304 0.065968
R27_21_16 n27_1028960_918304 n27_1067872_918304 0.068096
R27_21_17 n27_1067872_918304 n27_1105568_918304 0.065968
R27_21_18 n27_1105568_918304 n27_1144480_918304 0.068096
R27_21_19 n27_1144480_918304 n27_1182176_918304 0.065968
R27_21_20 n27_1182176_918304 n27_1219872_918304 0.065968
R27_21_21 n27_1219872_918304 n27_1258784_918304 0.068096
R27_21_22 n27_1258784_918304 n27_1296480_918304 0.065968
R27_21_23 n27_1296480_918304 n27_1335392_918304 0.068096
R27_21_24 n27_1335392_918304 n27_1373088_918304 0.065968
R27_21_25 n27_1373088_918304 n27_1412000_918304 0.068096
R27_21_26 n27_1412000_918304 n27_1449696_918304 0.065968
R27_21_27 n27_1449696_918304 n27_1487392_918304 0.065968
R27_21_28 n27_1487392_918304 n27_1526304_918304 0.068096
R27_21_29 n27_1526304_918304 n27_1564000_918304 0.065968
R27_21_30 n27_1564000_918304 n27_1602912_918304 0.068096
R27_21_31 n27_1602912_918304 n27_1641180_918304 0.066969
R27_21_32 n27_1641180_918304 n27_1641290_918304 0.00019250000000000002
R27_22_0 n27_474686_881824 n27_474796_881824 0.00019250000000000002
R27_22_1 n27_474796_881824 n27_493920_881824 0.033467
R27_22_2 n27_493920_881824 n27_532832_881824 0.068096
R27_22_3 n27_532832_881824 n27_570528_881824 0.065968
R27_22_4 n27_570528_881824 n27_609440_881824 0.068096
R27_22_5 n27_609440_881824 n27_647136_881824 0.065968
R27_22_6 n27_647136_881824 n27_686048_881824 0.068096
R27_22_7 n27_686048_881824 n27_723744_881824 0.065968
R27_22_8 n27_723744_881824 n27_761440_881824 0.065968
R27_22_9 n27_761440_881824 n27_800352_881824 0.068096
R27_22_10 n27_800352_881824 n27_838048_881824 0.065968
R27_22_11 n27_838048_881824 n27_876960_881824 0.068096
R27_22_12 n27_876960_881824 n27_914656_881824 0.065968
R27_22_13 n27_914656_881824 n27_952352_881824 0.065968
R27_22_14 n27_952352_881824 n27_991264_881824 0.068096
R27_22_15 n27_991264_881824 n27_1028960_881824 0.065968
R27_22_16 n27_1028960_881824 n27_1067872_881824 0.068096
R27_22_17 n27_1067872_881824 n27_1105568_881824 0.065968
R27_22_18 n27_1105568_881824 n27_1144480_881824 0.068096
R27_22_19 n27_1144480_881824 n27_1182176_881824 0.065968
R27_22_20 n27_1182176_881824 n27_1219872_881824 0.065968
R27_22_21 n27_1219872_881824 n27_1258784_881824 0.068096
R27_22_22 n27_1258784_881824 n27_1296480_881824 0.065968
R27_22_23 n27_1296480_881824 n27_1335392_881824 0.068096
R27_22_24 n27_1335392_881824 n27_1373088_881824 0.065968
R27_22_25 n27_1373088_881824 n27_1412000_881824 0.068096
R27_22_26 n27_1412000_881824 n27_1449696_881824 0.065968
R27_22_27 n27_1449696_881824 n27_1487392_881824 0.065968
R27_22_28 n27_1487392_881824 n27_1526304_881824 0.068096
R27_22_29 n27_1526304_881824 n27_1564000_881824 0.065968
R27_22_30 n27_1564000_881824 n27_1602912_881824 0.068096
R27_22_31 n27_1602912_881824 n27_1641180_881824 0.066969
R27_22_32 n27_1641180_881824 n27_1641290_881824 0.00019250000000000002
R27_23_0 n27_474686_842912 n27_474796_842912 0.00019250000000000002
R27_23_1 n27_474796_842912 n27_493920_842912 0.033467
R27_23_2 n27_493920_842912 n27_532832_842912 0.068096
R27_23_3 n27_532832_842912 n27_570528_842912 0.065968
R27_23_4 n27_570528_842912 n27_609440_842912 0.068096
R27_23_5 n27_609440_842912 n27_647136_842912 0.065968
R27_23_6 n27_647136_842912 n27_686048_842912 0.068096
R27_23_7 n27_686048_842912 n27_723744_842912 0.065968
R27_23_8 n27_723744_842912 n27_761440_842912 0.065968
R27_23_9 n27_761440_842912 n27_800352_842912 0.068096
R27_23_10 n27_800352_842912 n27_838048_842912 0.065968
R27_23_11 n27_838048_842912 n27_876960_842912 0.068096
R27_23_12 n27_876960_842912 n27_914656_842912 0.065968
R27_23_13 n27_914656_842912 n27_952352_842912 0.065968
R27_23_14 n27_952352_842912 n27_991264_842912 0.068096
R27_23_15 n27_991264_842912 n27_1028960_842912 0.065968
R27_23_16 n27_1028960_842912 n27_1067872_842912 0.068096
R27_23_17 n27_1067872_842912 n27_1105568_842912 0.065968
R27_23_18 n27_1105568_842912 n27_1144480_842912 0.068096
R27_23_19 n27_1144480_842912 n27_1182176_842912 0.065968
R27_23_20 n27_1182176_842912 n27_1219872_842912 0.065968
R27_23_21 n27_1219872_842912 n27_1258784_842912 0.068096
R27_23_22 n27_1258784_842912 n27_1296480_842912 0.065968
R27_23_23 n27_1296480_842912 n27_1335392_842912 0.068096
R27_23_24 n27_1335392_842912 n27_1373088_842912 0.065968
R27_23_25 n27_1373088_842912 n27_1412000_842912 0.068096
R27_23_26 n27_1412000_842912 n27_1449696_842912 0.065968
R27_23_27 n27_1449696_842912 n27_1487392_842912 0.065968
R27_23_28 n27_1487392_842912 n27_1526304_842912 0.068096
R27_23_29 n27_1526304_842912 n27_1564000_842912 0.065968
R27_23_30 n27_1564000_842912 n27_1602912_842912 0.068096
R27_23_31 n27_1602912_842912 n27_1641180_842912 0.066969
R27_23_32 n27_1641180_842912 n27_1641290_842912 0.00019250000000000002
R27_24_0 n27_474686_804000 n27_474796_804000 0.00019250000000000002
R27_24_1 n27_474796_804000 n27_493920_804000 0.033467
R27_24_2 n27_493920_804000 n27_532832_804000 0.068096
R27_24_3 n27_532832_804000 n27_570528_804000 0.065968
R27_24_4 n27_570528_804000 n27_609440_804000 0.068096
R27_24_5 n27_609440_804000 n27_647136_804000 0.065968
R27_24_6 n27_647136_804000 n27_686048_804000 0.068096
R27_24_7 n27_686048_804000 n27_723744_804000 0.065968
R27_24_8 n27_723744_804000 n27_761440_804000 0.065968
R27_24_9 n27_761440_804000 n27_800352_804000 0.068096
R27_24_10 n27_800352_804000 n27_838048_804000 0.065968
R27_24_11 n27_838048_804000 n27_876960_804000 0.068096
R27_24_12 n27_876960_804000 n27_914656_804000 0.065968
R27_24_13 n27_914656_804000 n27_952352_804000 0.065968
R27_24_14 n27_952352_804000 n27_991264_804000 0.068096
R27_24_15 n27_991264_804000 n27_1028960_804000 0.065968
R27_24_16 n27_1028960_804000 n27_1067872_804000 0.068096
R27_24_17 n27_1067872_804000 n27_1105568_804000 0.065968
R27_24_18 n27_1105568_804000 n27_1144480_804000 0.068096
R27_24_19 n27_1144480_804000 n27_1182176_804000 0.065968
R27_24_20 n27_1182176_804000 n27_1219872_804000 0.065968
R27_24_21 n27_1219872_804000 n27_1258784_804000 0.068096
R27_24_22 n27_1258784_804000 n27_1296480_804000 0.065968
R27_24_23 n27_1296480_804000 n27_1335392_804000 0.068096
R27_24_24 n27_1335392_804000 n27_1373088_804000 0.065968
R27_24_25 n27_1373088_804000 n27_1412000_804000 0.068096
R27_24_26 n27_1412000_804000 n27_1449696_804000 0.065968
R27_24_27 n27_1449696_804000 n27_1487392_804000 0.065968
R27_24_28 n27_1487392_804000 n27_1526304_804000 0.068096
R27_24_29 n27_1526304_804000 n27_1564000_804000 0.065968
R27_24_30 n27_1564000_804000 n27_1602912_804000 0.068096
R27_24_31 n27_1602912_804000 n27_1641180_804000 0.066969
R27_24_32 n27_1641180_804000 n27_1641290_804000 0.00019250000000000002
R27_25_0 n27_474686_767520 n27_474796_767520 0.00019250000000000002
R27_25_1 n27_474796_767520 n27_493920_767520 0.033467
R27_25_2 n27_493920_767520 n27_532832_767520 0.068096
R27_25_3 n27_532832_767520 n27_570528_767520 0.065968
R27_25_4 n27_570528_767520 n27_609440_767520 0.068096
R27_25_5 n27_609440_767520 n27_647136_767520 0.065968
R27_25_6 n27_647136_767520 n27_686048_767520 0.068096
R27_25_7 n27_686048_767520 n27_723744_767520 0.065968
R27_25_8 n27_723744_767520 n27_761440_767520 0.065968
R27_25_9 n27_761440_767520 n27_800352_767520 0.068096
R27_25_10 n27_800352_767520 n27_838048_767520 0.065968
R27_25_11 n27_838048_767520 n27_876960_767520 0.068096
R27_25_12 n27_876960_767520 n27_914656_767520 0.065968
R27_25_13 n27_914656_767520 n27_952352_767520 0.065968
R27_25_14 n27_952352_767520 n27_991264_767520 0.068096
R27_25_15 n27_991264_767520 n27_1028960_767520 0.065968
R27_25_16 n27_1028960_767520 n27_1067872_767520 0.068096
R27_25_17 n27_1067872_767520 n27_1105568_767520 0.065968
R27_25_18 n27_1105568_767520 n27_1144480_767520 0.068096
R27_25_19 n27_1144480_767520 n27_1182176_767520 0.065968
R27_25_20 n27_1182176_767520 n27_1219872_767520 0.065968
R27_25_21 n27_1219872_767520 n27_1258784_767520 0.068096
R27_25_22 n27_1258784_767520 n27_1296480_767520 0.065968
R27_25_23 n27_1296480_767520 n27_1335392_767520 0.068096
R27_25_24 n27_1335392_767520 n27_1373088_767520 0.065968
R27_25_25 n27_1373088_767520 n27_1412000_767520 0.068096
R27_25_26 n27_1412000_767520 n27_1449696_767520 0.065968
R27_25_27 n27_1449696_767520 n27_1487392_767520 0.065968
R27_25_28 n27_1487392_767520 n27_1526304_767520 0.068096
R27_25_29 n27_1526304_767520 n27_1564000_767520 0.065968
R27_25_30 n27_1564000_767520 n27_1602912_767520 0.068096
R27_25_31 n27_1602912_767520 n27_1641180_767520 0.066969
R27_25_32 n27_1641180_767520 n27_1641290_767520 0.00019250000000000002
R27_26_0 n27_474686_728608 n27_474796_728608 0.00019250000000000002
R27_26_1 n27_474796_728608 n27_493920_728608 0.033467
R27_26_2 n27_493920_728608 n27_532832_728608 0.068096
R27_26_3 n27_532832_728608 n27_570528_728608 0.065968
R27_26_4 n27_570528_728608 n27_609440_728608 0.068096
R27_26_5 n27_609440_728608 n27_647136_728608 0.065968
R27_26_6 n27_647136_728608 n27_686048_728608 0.068096
R27_26_7 n27_686048_728608 n27_723744_728608 0.065968
R27_26_8 n27_723744_728608 n27_761440_728608 0.065968
R27_26_9 n27_761440_728608 n27_800352_728608 0.068096
R27_26_10 n27_800352_728608 n27_838048_728608 0.065968
R27_26_11 n27_838048_728608 n27_876960_728608 0.068096
R27_26_12 n27_876960_728608 n27_914656_728608 0.065968
R27_26_13 n27_914656_728608 n27_952352_728608 0.065968
R27_26_14 n27_952352_728608 n27_991264_728608 0.068096
R27_26_15 n27_991264_728608 n27_1028960_728608 0.065968
R27_26_16 n27_1028960_728608 n27_1067872_728608 0.068096
R27_26_17 n27_1067872_728608 n27_1105568_728608 0.065968
R27_26_18 n27_1105568_728608 n27_1144480_728608 0.068096
R27_26_19 n27_1144480_728608 n27_1182176_728608 0.065968
R27_26_20 n27_1182176_728608 n27_1219872_728608 0.065968
R27_26_21 n27_1219872_728608 n27_1258784_728608 0.068096
R27_26_22 n27_1258784_728608 n27_1296480_728608 0.065968
R27_26_23 n27_1296480_728608 n27_1335392_728608 0.068096
R27_26_24 n27_1335392_728608 n27_1373088_728608 0.065968
R27_26_25 n27_1373088_728608 n27_1412000_728608 0.068096
R27_26_26 n27_1412000_728608 n27_1449696_728608 0.065968
R27_26_27 n27_1449696_728608 n27_1487392_728608 0.065968
R27_26_28 n27_1487392_728608 n27_1526304_728608 0.068096
R27_26_29 n27_1526304_728608 n27_1564000_728608 0.065968
R27_26_30 n27_1564000_728608 n27_1602912_728608 0.068096
R27_26_31 n27_1602912_728608 n27_1641180_728608 0.066969
R27_26_32 n27_1641180_728608 n27_1641290_728608 0.00019250000000000002
R27_27_0 n27_474686_692128 n27_474796_692128 0.00019250000000000002
R27_27_1 n27_474796_692128 n27_493920_692128 0.033467
R27_27_2 n27_493920_692128 n27_532832_692128 0.068096
R27_27_3 n27_532832_692128 n27_570528_692128 0.065968
R27_27_4 n27_570528_692128 n27_609440_692128 0.068096
R27_27_5 n27_609440_692128 n27_647136_692128 0.065968
R27_27_6 n27_647136_692128 n27_686048_692128 0.068096
R27_27_7 n27_686048_692128 n27_723744_692128 0.065968
R27_27_8 n27_723744_692128 n27_761440_692128 0.065968
R27_27_9 n27_761440_692128 n27_800352_692128 0.068096
R27_27_10 n27_800352_692128 n27_838048_692128 0.065968
R27_27_11 n27_838048_692128 n27_876960_692128 0.068096
R27_27_12 n27_876960_692128 n27_914656_692128 0.065968
R27_27_13 n27_914656_692128 n27_952352_692128 0.065968
R27_27_14 n27_952352_692128 n27_991264_692128 0.068096
R27_27_15 n27_991264_692128 n27_1028960_692128 0.065968
R27_27_16 n27_1028960_692128 n27_1067872_692128 0.068096
R27_27_17 n27_1067872_692128 n27_1105568_692128 0.065968
R27_27_18 n27_1105568_692128 n27_1144480_692128 0.068096
R27_27_19 n27_1144480_692128 n27_1182176_692128 0.065968
R27_27_20 n27_1182176_692128 n27_1219872_692128 0.065968
R27_27_21 n27_1219872_692128 n27_1258784_692128 0.068096
R27_27_22 n27_1258784_692128 n27_1296480_692128 0.065968
R27_27_23 n27_1296480_692128 n27_1335392_692128 0.068096
R27_27_24 n27_1335392_692128 n27_1373088_692128 0.065968
R27_27_25 n27_1373088_692128 n27_1412000_692128 0.068096
R27_27_26 n27_1412000_692128 n27_1449696_692128 0.065968
R27_27_27 n27_1449696_692128 n27_1487392_692128 0.065968
R27_27_28 n27_1487392_692128 n27_1526304_692128 0.068096
R27_27_29 n27_1526304_692128 n27_1564000_692128 0.065968
R27_27_30 n27_1564000_692128 n27_1602912_692128 0.068096
R27_27_31 n27_1602912_692128 n27_1641180_692128 0.066969
R27_27_32 n27_1641180_692128 n27_1641290_692128 0.00019250000000000002
R27_28_0 n27_474686_653216 n27_474796_653216 0.00019250000000000002
R27_28_1 n27_474796_653216 n27_493920_653216 0.033467
R27_28_2 n27_493920_653216 n27_532832_653216 0.068096
R27_28_3 n27_532832_653216 n27_570528_653216 0.065968
R27_28_4 n27_570528_653216 n27_609440_653216 0.068096
R27_28_5 n27_609440_653216 n27_647136_653216 0.065968
R27_28_6 n27_647136_653216 n27_686048_653216 0.068096
R27_28_7 n27_686048_653216 n27_723744_653216 0.065968
R27_28_8 n27_723744_653216 n27_761440_653216 0.065968
R27_28_9 n27_761440_653216 n27_800352_653216 0.068096
R27_28_10 n27_800352_653216 n27_838048_653216 0.065968
R27_28_11 n27_838048_653216 n27_876960_653216 0.068096
R27_28_12 n27_876960_653216 n27_914656_653216 0.065968
R27_28_13 n27_914656_653216 n27_952352_653216 0.065968
R27_28_14 n27_952352_653216 n27_991264_653216 0.068096
R27_28_15 n27_991264_653216 n27_1028960_653216 0.065968
R27_28_16 n27_1028960_653216 n27_1067872_653216 0.068096
R27_28_17 n27_1067872_653216 n27_1105568_653216 0.065968
R27_28_18 n27_1105568_653216 n27_1144480_653216 0.068096
R27_28_19 n27_1144480_653216 n27_1182176_653216 0.065968
R27_28_20 n27_1182176_653216 n27_1219872_653216 0.065968
R27_28_21 n27_1219872_653216 n27_1258784_653216 0.068096
R27_28_22 n27_1258784_653216 n27_1296480_653216 0.065968
R27_28_23 n27_1296480_653216 n27_1335392_653216 0.068096
R27_28_24 n27_1335392_653216 n27_1373088_653216 0.065968
R27_28_25 n27_1373088_653216 n27_1412000_653216 0.068096
R27_28_26 n27_1412000_653216 n27_1449696_653216 0.065968
R27_28_27 n27_1449696_653216 n27_1487392_653216 0.065968
R27_28_28 n27_1487392_653216 n27_1526304_653216 0.068096
R27_28_29 n27_1526304_653216 n27_1564000_653216 0.065968
R27_28_30 n27_1564000_653216 n27_1602912_653216 0.068096
R27_28_31 n27_1602912_653216 n27_1641180_653216 0.066969
R27_28_32 n27_1641180_653216 n27_1641290_653216 0.00019250000000000002
R27_29_0 n27_474686_614304 n27_474796_614304 0.00019250000000000002
R27_29_1 n27_474796_614304 n27_493920_614304 0.033467
R27_29_2 n27_493920_614304 n27_532832_614304 0.068096
R27_29_3 n27_532832_614304 n27_570528_614304 0.065968
R27_29_4 n27_570528_614304 n27_609440_614304 0.068096
R27_29_5 n27_609440_614304 n27_647136_614304 0.065968
R27_29_6 n27_647136_614304 n27_686048_614304 0.068096
R27_29_7 n27_686048_614304 n27_723744_614304 0.065968
R27_29_8 n27_723744_614304 n27_761440_614304 0.065968
R27_29_9 n27_761440_614304 n27_800352_614304 0.068096
R27_29_10 n27_800352_614304 n27_838048_614304 0.065968
R27_29_11 n27_838048_614304 n27_876960_614304 0.068096
R27_29_12 n27_876960_614304 n27_914656_614304 0.065968
R27_29_13 n27_914656_614304 n27_952352_614304 0.065968
R27_29_14 n27_952352_614304 n27_991264_614304 0.068096
R27_29_15 n27_991264_614304 n27_1028960_614304 0.065968
R27_29_16 n27_1028960_614304 n27_1067872_614304 0.068096
R27_29_17 n27_1067872_614304 n27_1105568_614304 0.065968
R27_29_18 n27_1105568_614304 n27_1144480_614304 0.068096
R27_29_19 n27_1144480_614304 n27_1182176_614304 0.065968
R27_29_20 n27_1182176_614304 n27_1219872_614304 0.065968
R27_29_21 n27_1219872_614304 n27_1258784_614304 0.068096
R27_29_22 n27_1258784_614304 n27_1296480_614304 0.065968
R27_29_23 n27_1296480_614304 n27_1335392_614304 0.068096
R27_29_24 n27_1335392_614304 n27_1373088_614304 0.065968
R27_29_25 n27_1373088_614304 n27_1412000_614304 0.068096
R27_29_26 n27_1412000_614304 n27_1449696_614304 0.065968
R27_29_27 n27_1449696_614304 n27_1487392_614304 0.065968
R27_29_28 n27_1487392_614304 n27_1526304_614304 0.068096
R27_29_29 n27_1526304_614304 n27_1564000_614304 0.065968
R27_29_30 n27_1564000_614304 n27_1602912_614304 0.068096
R27_29_31 n27_1602912_614304 n27_1641180_614304 0.066969
R27_29_32 n27_1641180_614304 n27_1641290_614304 0.00019250000000000002
R27_30_0 n27_474686_577824 n27_474796_577824 0.00019250000000000002
R27_30_1 n27_474796_577824 n27_493920_577824 0.033467
R27_30_2 n27_493920_577824 n27_532832_577824 0.068096
R27_30_3 n27_532832_577824 n27_570528_577824 0.065968
R27_30_4 n27_570528_577824 n27_609440_577824 0.068096
R27_30_5 n27_609440_577824 n27_647136_577824 0.065968
R27_30_6 n27_647136_577824 n27_686048_577824 0.068096
R27_30_7 n27_686048_577824 n27_723744_577824 0.065968
R27_30_8 n27_723744_577824 n27_761440_577824 0.065968
R27_30_9 n27_761440_577824 n27_800352_577824 0.068096
R27_30_10 n27_800352_577824 n27_838048_577824 0.065968
R27_30_11 n27_838048_577824 n27_876960_577824 0.068096
R27_30_12 n27_876960_577824 n27_914656_577824 0.065968
R27_30_13 n27_914656_577824 n27_952352_577824 0.065968
R27_30_14 n27_952352_577824 n27_991264_577824 0.068096
R27_30_15 n27_991264_577824 n27_1028960_577824 0.065968
R27_30_16 n27_1028960_577824 n27_1067872_577824 0.068096
R27_30_17 n27_1067872_577824 n27_1105568_577824 0.065968
R27_30_18 n27_1105568_577824 n27_1144480_577824 0.068096
R27_30_19 n27_1144480_577824 n27_1182176_577824 0.065968
R27_30_20 n27_1182176_577824 n27_1219872_577824 0.065968
R27_30_21 n27_1219872_577824 n27_1258784_577824 0.068096
R27_30_22 n27_1258784_577824 n27_1296480_577824 0.065968
R27_30_23 n27_1296480_577824 n27_1335392_577824 0.068096
R27_30_24 n27_1335392_577824 n27_1373088_577824 0.065968
R27_30_25 n27_1373088_577824 n27_1412000_577824 0.068096
R27_30_26 n27_1412000_577824 n27_1449696_577824 0.065968
R27_30_27 n27_1449696_577824 n27_1487392_577824 0.065968
R27_30_28 n27_1487392_577824 n27_1526304_577824 0.068096
R27_30_29 n27_1526304_577824 n27_1564000_577824 0.065968
R27_30_30 n27_1564000_577824 n27_1602912_577824 0.068096
R27_30_31 n27_1602912_577824 n27_1641180_577824 0.066969
R27_30_32 n27_1641180_577824 n27_1641290_577824 0.00019250000000000002
R27_31_0 n27_474686_538912 n27_474796_538912 0.00019250000000000002
R27_31_1 n27_474796_538912 n27_493920_538912 0.033467
R27_31_2 n27_493920_538912 n27_532832_538912 0.068096
R27_31_3 n27_532832_538912 n27_570528_538912 0.065968
R27_31_4 n27_570528_538912 n27_609440_538912 0.068096
R27_31_5 n27_609440_538912 n27_647136_538912 0.065968
R27_31_6 n27_647136_538912 n27_686048_538912 0.068096
R27_31_7 n27_686048_538912 n27_723744_538912 0.065968
R27_31_8 n27_723744_538912 n27_761440_538912 0.065968
R27_31_9 n27_761440_538912 n27_800352_538912 0.068096
R27_31_10 n27_800352_538912 n27_838048_538912 0.065968
R27_31_11 n27_838048_538912 n27_876960_538912 0.068096
R27_31_12 n27_876960_538912 n27_914656_538912 0.065968
R27_31_13 n27_914656_538912 n27_952352_538912 0.065968
R27_31_14 n27_952352_538912 n27_991264_538912 0.068096
R27_31_15 n27_991264_538912 n27_1028960_538912 0.065968
R27_31_16 n27_1028960_538912 n27_1067872_538912 0.068096
R27_31_17 n27_1067872_538912 n27_1105568_538912 0.065968
R27_31_18 n27_1105568_538912 n27_1144480_538912 0.068096
R27_31_19 n27_1144480_538912 n27_1182176_538912 0.065968
R27_31_20 n27_1182176_538912 n27_1219872_538912 0.065968
R27_31_21 n27_1219872_538912 n27_1258784_538912 0.068096
R27_31_22 n27_1258784_538912 n27_1296480_538912 0.065968
R27_31_23 n27_1296480_538912 n27_1335392_538912 0.068096
R27_31_24 n27_1335392_538912 n27_1373088_538912 0.065968
R27_31_25 n27_1373088_538912 n27_1412000_538912 0.068096
R27_31_26 n27_1412000_538912 n27_1449696_538912 0.065968
R27_31_27 n27_1449696_538912 n27_1487392_538912 0.065968
R27_31_28 n27_1487392_538912 n27_1526304_538912 0.068096
R27_31_29 n27_1526304_538912 n27_1564000_538912 0.065968
R27_31_30 n27_1564000_538912 n27_1602912_538912 0.068096
R27_31_31 n27_1602912_538912 n27_1641180_538912 0.066969
R27_31_32 n27_1641180_538912 n27_1641290_538912 0.00019250000000000002
R27_32_0 n27_474686_502432 n27_474796_502432 0.00019250000000000002
R27_32_1 n27_474796_502432 n27_493920_502432 0.033467
R27_32_2 n27_493920_502432 n27_532832_502432 0.068096
R27_32_3 n27_532832_502432 n27_570528_502432 0.065968
R27_32_4 n27_570528_502432 n27_609440_502432 0.068096
R27_32_5 n27_609440_502432 n27_647136_502432 0.065968
R27_32_6 n27_647136_502432 n27_686048_502432 0.068096
R27_32_7 n27_686048_502432 n27_723744_502432 0.065968
R27_32_8 n27_723744_502432 n27_761440_502432 0.065968
R27_32_9 n27_761440_502432 n27_800352_502432 0.068096
R27_32_10 n27_800352_502432 n27_838048_502432 0.065968
R27_32_11 n27_838048_502432 n27_876960_502432 0.068096
R27_32_12 n27_876960_502432 n27_914656_502432 0.065968
R27_32_13 n27_914656_502432 n27_952352_502432 0.065968
R27_32_14 n27_952352_502432 n27_991264_502432 0.068096
R27_32_15 n27_991264_502432 n27_1028960_502432 0.065968
R27_32_16 n27_1028960_502432 n27_1067872_502432 0.068096
R27_32_17 n27_1067872_502432 n27_1105568_502432 0.065968
R27_32_18 n27_1105568_502432 n27_1144480_502432 0.068096
R27_32_19 n27_1144480_502432 n27_1182176_502432 0.065968
R27_32_20 n27_1182176_502432 n27_1219872_502432 0.065968
R27_32_21 n27_1219872_502432 n27_1258784_502432 0.068096
R27_32_22 n27_1258784_502432 n27_1296480_502432 0.065968
R27_32_23 n27_1296480_502432 n27_1335392_502432 0.068096
R27_32_24 n27_1335392_502432 n27_1373088_502432 0.065968
R27_32_25 n27_1373088_502432 n27_1412000_502432 0.068096
R27_32_26 n27_1412000_502432 n27_1449696_502432 0.065968
R27_32_27 n27_1449696_502432 n27_1487392_502432 0.065968
R27_32_28 n27_1487392_502432 n27_1526304_502432 0.068096
R27_32_29 n27_1526304_502432 n27_1564000_502432 0.065968
R27_32_30 n27_1564000_502432 n27_1602912_502432 0.068096
R27_32_31 n27_1602912_502432 n27_1641180_502432 0.066969
R27_32_32 n27_1641180_502432 n27_1641290_502432 0.00019250000000000002
R27_33_0 n27_474686_480880 n27_474796_480880 9.625000000000001e-05
R27_33_1 n27_474796_480880 n27_493920_480880 0.0167335
R27_33_2 n27_493920_480880 n27_532832_480880 0.034048
R27_33_3 n27_532832_480880 n27_570528_480880 0.032984
R27_33_4 n27_570528_480880 n27_609440_480880 0.034048
R27_33_5 n27_609440_480880 n27_647136_480880 0.032984
R27_33_6 n27_647136_480880 n27_686048_480880 0.034048
R27_33_7 n27_686048_480880 n27_723744_480880 0.032984
R27_33_8 n27_723744_480880 n27_761440_480880 0.032984
R27_33_9 n27_761440_480880 n27_800352_480880 0.034048
R27_33_10 n27_800352_480880 n27_838048_480880 0.032984
R27_33_11 n27_838048_480880 n27_876960_480880 0.034048
R27_33_12 n27_876960_480880 n27_914656_480880 0.032984
R27_33_13 n27_914656_480880 n27_952352_480880 0.032984
R27_33_14 n27_952352_480880 n27_991264_480880 0.034048
R27_33_15 n27_991264_480880 n27_1028960_480880 0.032984
R27_33_16 n27_1028960_480880 n27_1067872_480880 0.034048
R27_33_17 n27_1067872_480880 n27_1105568_480880 0.032984
R27_33_18 n27_1105568_480880 n27_1144480_480880 0.034048
R27_33_19 n27_1144480_480880 n27_1182176_480880 0.032984
R27_33_20 n27_1182176_480880 n27_1219872_480880 0.032984
R27_33_21 n27_1219872_480880 n27_1258784_480880 0.034048
R27_33_22 n27_1258784_480880 n27_1296480_480880 0.032984
R27_33_23 n27_1296480_480880 n27_1335392_480880 0.034048
R27_33_24 n27_1335392_480880 n27_1373088_480880 0.032984
R27_33_25 n27_1373088_480880 n27_1412000_480880 0.034048
R27_33_26 n27_1412000_480880 n27_1449696_480880 0.032984
R27_33_27 n27_1449696_480880 n27_1487392_480880 0.032984
R27_33_28 n27_1487392_480880 n27_1526304_480880 0.034048
R27_33_29 n27_1526304_480880 n27_1564000_480880 0.032984
R27_33_30 n27_1564000_480880 n27_1602912_480880 0.034048
R27_33_31 n27_1602912_480880 n27_1620161_480880 0.0150929
R27_33_32 n27_1620161_480880 n27_1641180_480880 0.0183916
R27_33_33 n27_1641180_480880 n27_1641290_480880 9.625000000000001e-05
R25_0_0 n25_474796_480880 n25_474796_480720 7.272729999999999e-05
R25_0_1 n25_474796_502432 n25_474796_480880 0.00979636
R25_0_2 n25_474796_538912 n25_474796_502432 0.0165818
R25_0_3 n25_474796_577824 n25_474796_538912 0.0176873
R25_0_4 n25_474796_614304 n25_474796_577824 0.0165818
R25_0_5 n25_474796_653216 n25_474796_614304 0.0176873
R25_0_6 n25_474796_692128 n25_474796_653216 0.0176873
R25_0_7 n25_474796_728608 n25_474796_692128 0.0165818
R25_0_8 n25_474796_767520 n25_474796_728608 0.0176873
R25_0_9 n25_474796_804000 n25_474796_767520 0.0165818
R25_0_10 n25_474796_842912 n25_474796_804000 0.0176873
R25_0_11 n25_474796_881824 n25_474796_842912 0.0176873
R25_0_12 n25_474796_918304 n25_474796_881824 0.0165818
R25_0_13 n25_474796_940095 n25_474796_918304 0.009904999999999999
R25_0_14 n25_474796_957216 n25_474796_940095 0.00778227
R25_0_15 n25_474796_993696 n25_474796_957216 0.0165818
R25_0_16 n25_474796_1032608 n25_474796_993696 0.0176873
R25_0_17 n25_474796_1071520 n25_474796_1032608 0.0176873
R25_0_18 n25_474796_1108000 n25_474796_1071520 0.0165818
R25_0_19 n25_474796_1146912 n25_474796_1108000 0.0176873
R25_0_20 n25_474796_1183392 n25_474796_1146912 0.0165818
R25_0_21 n25_474796_1222304 n25_474796_1183392 0.0176873
R25_0_22 n25_474796_1261216 n25_474796_1222304 0.0176873
R25_0_23 n25_474796_1297696 n25_474796_1261216 0.0165818
R25_0_24 n25_474796_1336608 n25_474796_1297696 0.0176873
R25_0_25 n25_474796_1373088 n25_474796_1336608 0.0165818
R25_0_26 n25_474796_1412000 n25_474796_1373088 0.0176873
R25_0_27 n25_474796_1448480 n25_474796_1412000 0.0165818
R25_0_28 n25_474796_1487392 n25_474796_1448480 0.0176873
R25_0_29 n25_474796_1526304 n25_474796_1487392 0.0176873
R25_0_30 n25_474796_1562784 n25_474796_1526304 0.0165818
R25_0_31 n25_474796_1601696 n25_474796_1562784 0.0176873
R25_0_32 n25_474796_1641130 n25_474796_1601696 0.0179245
R25_0_33 n25_474796_1641290 n25_474796_1641130 7.272729999999999e-05
R25_1_0 n25_493920_480880 n25_493920_480720 0.000145455
R25_1_1 n25_493920_502432 n25_493920_480880 0.0195927
R25_1_2 n25_493920_538912 n25_493920_502432 0.0331636
R25_1_3 n25_493920_577824 n25_493920_538912 0.035374499999999996
R25_1_4 n25_493920_614304 n25_493920_577824 0.0331636
R25_1_5 n25_493920_653216 n25_493920_614304 0.035374499999999996
R25_1_6 n25_493920_692128 n25_493920_653216 0.035374499999999996
R25_1_7 n25_493920_728608 n25_493920_692128 0.0331636
R25_1_8 n25_493920_767520 n25_493920_728608 0.035374499999999996
R25_1_9 n25_493920_804000 n25_493920_767520 0.0331636
R25_1_10 n25_493920_842912 n25_493920_804000 0.035374499999999996
R25_1_11 n25_493920_881824 n25_493920_842912 0.035374499999999996
R25_1_12 n25_493920_918304 n25_493920_881824 0.0331636
R25_1_13 n25_493920_957216 n25_493920_918304 0.035374499999999996
R25_1_14 n25_493920_993696 n25_493920_957216 0.0331636
R25_1_15 n25_493920_1032608 n25_493920_993696 0.035374499999999996
R25_1_16 n25_493920_1071520 n25_493920_1032608 0.035374499999999996
R25_1_17 n25_493920_1108000 n25_493920_1071520 0.0331636
R25_1_18 n25_493920_1146912 n25_493920_1108000 0.035374499999999996
R25_1_19 n25_493920_1183392 n25_493920_1146912 0.0331636
R25_1_20 n25_493920_1222304 n25_493920_1183392 0.035374499999999996
R25_1_21 n25_493920_1261216 n25_493920_1222304 0.035374499999999996
R25_1_22 n25_493920_1297696 n25_493920_1261216 0.0331636
R25_1_23 n25_493920_1336608 n25_493920_1297696 0.035374499999999996
R25_1_24 n25_493920_1373088 n25_493920_1336608 0.0331636
R25_1_25 n25_493920_1412000 n25_493920_1373088 0.035374499999999996
R25_1_26 n25_493920_1448480 n25_493920_1412000 0.0331636
R25_1_27 n25_493920_1487392 n25_493920_1448480 0.035374499999999996
R25_1_28 n25_493920_1526304 n25_493920_1487392 0.035374499999999996
R25_1_29 n25_493920_1562784 n25_493920_1526304 0.0331636
R25_1_30 n25_493920_1601696 n25_493920_1562784 0.035374499999999996
R25_1_31 n25_493920_1641130 n25_493920_1601696 0.0358491
R25_1_32 n25_493920_1641290 n25_493920_1641130 0.000145455
R25_2_0 n25_532832_480880 n25_532832_480720 0.000145455
R25_2_1 n25_532832_502432 n25_532832_480880 0.0195927
R25_2_2 n25_532832_538912 n25_532832_502432 0.0331636
R25_2_3 n25_532832_577824 n25_532832_538912 0.035374499999999996
R25_2_4 n25_532832_614304 n25_532832_577824 0.0331636
R25_2_5 n25_532832_653216 n25_532832_614304 0.035374499999999996
R25_2_6 n25_532832_692128 n25_532832_653216 0.035374499999999996
R25_2_7 n25_532832_728608 n25_532832_692128 0.0331636
R25_2_8 n25_532832_767520 n25_532832_728608 0.035374499999999996
R25_2_9 n25_532832_804000 n25_532832_767520 0.0331636
R25_2_10 n25_532832_842912 n25_532832_804000 0.035374499999999996
R25_2_11 n25_532832_881824 n25_532832_842912 0.035374499999999996
R25_2_12 n25_532832_918304 n25_532832_881824 0.0331636
R25_2_13 n25_532832_957216 n25_532832_918304 0.035374499999999996
R25_2_14 n25_532832_993696 n25_532832_957216 0.0331636
R25_2_15 n25_532832_1032608 n25_532832_993696 0.035374499999999996
R25_2_16 n25_532832_1071520 n25_532832_1032608 0.035374499999999996
R25_2_17 n25_532832_1108000 n25_532832_1071520 0.0331636
R25_2_18 n25_532832_1146912 n25_532832_1108000 0.035374499999999996
R25_2_19 n25_532832_1183392 n25_532832_1146912 0.0331636
R25_2_20 n25_532832_1222304 n25_532832_1183392 0.035374499999999996
R25_2_21 n25_532832_1261216 n25_532832_1222304 0.035374499999999996
R25_2_22 n25_532832_1297696 n25_532832_1261216 0.0331636
R25_2_23 n25_532832_1336608 n25_532832_1297696 0.035374499999999996
R25_2_24 n25_532832_1373088 n25_532832_1336608 0.0331636
R25_2_25 n25_532832_1412000 n25_532832_1373088 0.035374499999999996
R25_2_26 n25_532832_1448480 n25_532832_1412000 0.0331636
R25_2_27 n25_532832_1487392 n25_532832_1448480 0.035374499999999996
R25_2_28 n25_532832_1526304 n25_532832_1487392 0.035374499999999996
R25_2_29 n25_532832_1562784 n25_532832_1526304 0.0331636
R25_2_30 n25_532832_1601696 n25_532832_1562784 0.035374499999999996
R25_2_31 n25_532832_1641130 n25_532832_1601696 0.0358491
R25_2_32 n25_532832_1641290 n25_532832_1641130 0.000145455
R25_3_0 n25_570528_480880 n25_570528_480720 0.000145455
R25_3_1 n25_570528_502432 n25_570528_480880 0.0195927
R25_3_2 n25_570528_538912 n25_570528_502432 0.0331636
R25_3_3 n25_570528_577824 n25_570528_538912 0.035374499999999996
R25_3_4 n25_570528_614304 n25_570528_577824 0.0331636
R25_3_5 n25_570528_653216 n25_570528_614304 0.035374499999999996
R25_3_6 n25_570528_692128 n25_570528_653216 0.035374499999999996
R25_3_7 n25_570528_728608 n25_570528_692128 0.0331636
R25_3_8 n25_570528_767520 n25_570528_728608 0.035374499999999996
R25_3_9 n25_570528_804000 n25_570528_767520 0.0331636
R25_3_10 n25_570528_842912 n25_570528_804000 0.035374499999999996
R25_3_11 n25_570528_881824 n25_570528_842912 0.035374499999999996
R25_3_12 n25_570528_918304 n25_570528_881824 0.0331636
R25_3_13 n25_570528_957216 n25_570528_918304 0.035374499999999996
R25_3_14 n25_570528_993696 n25_570528_957216 0.0331636
R25_3_15 n25_570528_1032608 n25_570528_993696 0.035374499999999996
R25_3_16 n25_570528_1071520 n25_570528_1032608 0.035374499999999996
R25_3_17 n25_570528_1108000 n25_570528_1071520 0.0331636
R25_3_18 n25_570528_1146912 n25_570528_1108000 0.035374499999999996
R25_3_19 n25_570528_1183392 n25_570528_1146912 0.0331636
R25_3_20 n25_570528_1222304 n25_570528_1183392 0.035374499999999996
R25_3_21 n25_570528_1261216 n25_570528_1222304 0.035374499999999996
R25_3_22 n25_570528_1297696 n25_570528_1261216 0.0331636
R25_3_23 n25_570528_1336608 n25_570528_1297696 0.035374499999999996
R25_3_24 n25_570528_1373088 n25_570528_1336608 0.0331636
R25_3_25 n25_570528_1412000 n25_570528_1373088 0.035374499999999996
R25_3_26 n25_570528_1448480 n25_570528_1412000 0.0331636
R25_3_27 n25_570528_1487392 n25_570528_1448480 0.035374499999999996
R25_3_28 n25_570528_1526304 n25_570528_1487392 0.035374499999999996
R25_3_29 n25_570528_1562784 n25_570528_1526304 0.0331636
R25_3_30 n25_570528_1601696 n25_570528_1562784 0.035374499999999996
R25_3_31 n25_570528_1641130 n25_570528_1601696 0.0358491
R25_3_32 n25_570528_1641290 n25_570528_1641130 0.000145455
R25_4_0 n25_609440_480880 n25_609440_480720 0.000145455
R25_4_1 n25_609440_502432 n25_609440_480880 0.0195927
R25_4_2 n25_609440_538912 n25_609440_502432 0.0331636
R25_4_3 n25_609440_577824 n25_609440_538912 0.035374499999999996
R25_4_4 n25_609440_614304 n25_609440_577824 0.0331636
R25_4_5 n25_609440_653216 n25_609440_614304 0.035374499999999996
R25_4_6 n25_609440_692128 n25_609440_653216 0.035374499999999996
R25_4_7 n25_609440_728608 n25_609440_692128 0.0331636
R25_4_8 n25_609440_767520 n25_609440_728608 0.035374499999999996
R25_4_9 n25_609440_804000 n25_609440_767520 0.0331636
R25_4_10 n25_609440_842912 n25_609440_804000 0.035374499999999996
R25_4_11 n25_609440_881824 n25_609440_842912 0.035374499999999996
R25_4_12 n25_609440_918304 n25_609440_881824 0.0331636
R25_4_13 n25_609440_957216 n25_609440_918304 0.035374499999999996
R25_4_14 n25_609440_993696 n25_609440_957216 0.0331636
R25_4_15 n25_609440_1032608 n25_609440_993696 0.035374499999999996
R25_4_16 n25_609440_1071520 n25_609440_1032608 0.035374499999999996
R25_4_17 n25_609440_1108000 n25_609440_1071520 0.0331636
R25_4_18 n25_609440_1146912 n25_609440_1108000 0.035374499999999996
R25_4_19 n25_609440_1183392 n25_609440_1146912 0.0331636
R25_4_20 n25_609440_1222304 n25_609440_1183392 0.035374499999999996
R25_4_21 n25_609440_1261216 n25_609440_1222304 0.035374499999999996
R25_4_22 n25_609440_1297696 n25_609440_1261216 0.0331636
R25_4_23 n25_609440_1336608 n25_609440_1297696 0.035374499999999996
R25_4_24 n25_609440_1373088 n25_609440_1336608 0.0331636
R25_4_25 n25_609440_1412000 n25_609440_1373088 0.035374499999999996
R25_4_26 n25_609440_1448480 n25_609440_1412000 0.0331636
R25_4_27 n25_609440_1487392 n25_609440_1448480 0.035374499999999996
R25_4_28 n25_609440_1526304 n25_609440_1487392 0.035374499999999996
R25_4_29 n25_609440_1562784 n25_609440_1526304 0.0331636
R25_4_30 n25_609440_1601696 n25_609440_1562784 0.035374499999999996
R25_4_31 n25_609440_1641130 n25_609440_1601696 0.0358491
R25_4_32 n25_609440_1641290 n25_609440_1641130 0.000145455
R25_5_0 n25_647136_480880 n25_647136_480720 0.000145455
R25_5_1 n25_647136_502432 n25_647136_480880 0.0195927
R25_5_2 n25_647136_538912 n25_647136_502432 0.0331636
R25_5_3 n25_647136_577824 n25_647136_538912 0.035374499999999996
R25_5_4 n25_647136_614304 n25_647136_577824 0.0331636
R25_5_5 n25_647136_653216 n25_647136_614304 0.035374499999999996
R25_5_6 n25_647136_692128 n25_647136_653216 0.035374499999999996
R25_5_7 n25_647136_728608 n25_647136_692128 0.0331636
R25_5_8 n25_647136_767520 n25_647136_728608 0.035374499999999996
R25_5_9 n25_647136_804000 n25_647136_767520 0.0331636
R25_5_10 n25_647136_842912 n25_647136_804000 0.035374499999999996
R25_5_11 n25_647136_881824 n25_647136_842912 0.035374499999999996
R25_5_12 n25_647136_918304 n25_647136_881824 0.0331636
R25_5_13 n25_647136_957216 n25_647136_918304 0.035374499999999996
R25_5_14 n25_647136_993696 n25_647136_957216 0.0331636
R25_5_15 n25_647136_1032608 n25_647136_993696 0.035374499999999996
R25_5_16 n25_647136_1071520 n25_647136_1032608 0.035374499999999996
R25_5_17 n25_647136_1108000 n25_647136_1071520 0.0331636
R25_5_18 n25_647136_1146912 n25_647136_1108000 0.035374499999999996
R25_5_19 n25_647136_1183392 n25_647136_1146912 0.0331636
R25_5_20 n25_647136_1222304 n25_647136_1183392 0.035374499999999996
R25_5_21 n25_647136_1261216 n25_647136_1222304 0.035374499999999996
R25_5_22 n25_647136_1297696 n25_647136_1261216 0.0331636
R25_5_23 n25_647136_1336608 n25_647136_1297696 0.035374499999999996
R25_5_24 n25_647136_1373088 n25_647136_1336608 0.0331636
R25_5_25 n25_647136_1412000 n25_647136_1373088 0.035374499999999996
R25_5_26 n25_647136_1448480 n25_647136_1412000 0.0331636
R25_5_27 n25_647136_1487392 n25_647136_1448480 0.035374499999999996
R25_5_28 n25_647136_1526304 n25_647136_1487392 0.035374499999999996
R25_5_29 n25_647136_1562784 n25_647136_1526304 0.0331636
R25_5_30 n25_647136_1601696 n25_647136_1562784 0.035374499999999996
R25_5_31 n25_647136_1641130 n25_647136_1601696 0.0358491
R25_5_32 n25_647136_1641290 n25_647136_1641130 0.000145455
R25_6_0 n25_686048_480880 n25_686048_480720 0.000145455
R25_6_1 n25_686048_502432 n25_686048_480880 0.0195927
R25_6_2 n25_686048_538912 n25_686048_502432 0.0331636
R25_6_3 n25_686048_577824 n25_686048_538912 0.035374499999999996
R25_6_4 n25_686048_614304 n25_686048_577824 0.0331636
R25_6_5 n25_686048_653216 n25_686048_614304 0.035374499999999996
R25_6_6 n25_686048_692128 n25_686048_653216 0.035374499999999996
R25_6_7 n25_686048_728608 n25_686048_692128 0.0331636
R25_6_8 n25_686048_767520 n25_686048_728608 0.035374499999999996
R25_6_9 n25_686048_804000 n25_686048_767520 0.0331636
R25_6_10 n25_686048_842912 n25_686048_804000 0.035374499999999996
R25_6_11 n25_686048_881824 n25_686048_842912 0.035374499999999996
R25_6_12 n25_686048_918304 n25_686048_881824 0.0331636
R25_6_13 n25_686048_957216 n25_686048_918304 0.035374499999999996
R25_6_14 n25_686048_993696 n25_686048_957216 0.0331636
R25_6_15 n25_686048_1032608 n25_686048_993696 0.035374499999999996
R25_6_16 n25_686048_1071520 n25_686048_1032608 0.035374499999999996
R25_6_17 n25_686048_1108000 n25_686048_1071520 0.0331636
R25_6_18 n25_686048_1146912 n25_686048_1108000 0.035374499999999996
R25_6_19 n25_686048_1183392 n25_686048_1146912 0.0331636
R25_6_20 n25_686048_1222304 n25_686048_1183392 0.035374499999999996
R25_6_21 n25_686048_1261216 n25_686048_1222304 0.035374499999999996
R25_6_22 n25_686048_1297696 n25_686048_1261216 0.0331636
R25_6_23 n25_686048_1336608 n25_686048_1297696 0.035374499999999996
R25_6_24 n25_686048_1373088 n25_686048_1336608 0.0331636
R25_6_25 n25_686048_1412000 n25_686048_1373088 0.035374499999999996
R25_6_26 n25_686048_1448480 n25_686048_1412000 0.0331636
R25_6_27 n25_686048_1487392 n25_686048_1448480 0.035374499999999996
R25_6_28 n25_686048_1526304 n25_686048_1487392 0.035374499999999996
R25_6_29 n25_686048_1562784 n25_686048_1526304 0.0331636
R25_6_30 n25_686048_1601696 n25_686048_1562784 0.035374499999999996
R25_6_31 n25_686048_1641130 n25_686048_1601696 0.0358491
R25_6_32 n25_686048_1641290 n25_686048_1641130 0.000145455
R25_7_0 n25_723744_480880 n25_723744_480720 0.000145455
R25_7_1 n25_723744_502432 n25_723744_480880 0.0195927
R25_7_2 n25_723744_538912 n25_723744_502432 0.0331636
R25_7_3 n25_723744_577824 n25_723744_538912 0.035374499999999996
R25_7_4 n25_723744_614304 n25_723744_577824 0.0331636
R25_7_5 n25_723744_653216 n25_723744_614304 0.035374499999999996
R25_7_6 n25_723744_692128 n25_723744_653216 0.035374499999999996
R25_7_7 n25_723744_728608 n25_723744_692128 0.0331636
R25_7_8 n25_723744_767520 n25_723744_728608 0.035374499999999996
R25_7_9 n25_723744_804000 n25_723744_767520 0.0331636
R25_7_10 n25_723744_842912 n25_723744_804000 0.035374499999999996
R25_7_11 n25_723744_881824 n25_723744_842912 0.035374499999999996
R25_7_12 n25_723744_918304 n25_723744_881824 0.0331636
R25_7_13 n25_723744_957216 n25_723744_918304 0.035374499999999996
R25_7_14 n25_723744_993696 n25_723744_957216 0.0331636
R25_7_15 n25_723744_1032608 n25_723744_993696 0.035374499999999996
R25_7_16 n25_723744_1071520 n25_723744_1032608 0.035374499999999996
R25_7_17 n25_723744_1108000 n25_723744_1071520 0.0331636
R25_7_18 n25_723744_1146912 n25_723744_1108000 0.035374499999999996
R25_7_19 n25_723744_1183392 n25_723744_1146912 0.0331636
R25_7_20 n25_723744_1222304 n25_723744_1183392 0.035374499999999996
R25_7_21 n25_723744_1261216 n25_723744_1222304 0.035374499999999996
R25_7_22 n25_723744_1297696 n25_723744_1261216 0.0331636
R25_7_23 n25_723744_1336608 n25_723744_1297696 0.035374499999999996
R25_7_24 n25_723744_1373088 n25_723744_1336608 0.0331636
R25_7_25 n25_723744_1412000 n25_723744_1373088 0.035374499999999996
R25_7_26 n25_723744_1448480 n25_723744_1412000 0.0331636
R25_7_27 n25_723744_1487392 n25_723744_1448480 0.035374499999999996
R25_7_28 n25_723744_1526304 n25_723744_1487392 0.035374499999999996
R25_7_29 n25_723744_1562784 n25_723744_1526304 0.0331636
R25_7_30 n25_723744_1601696 n25_723744_1562784 0.035374499999999996
R25_7_31 n25_723744_1641130 n25_723744_1601696 0.0358491
R25_7_32 n25_723744_1641290 n25_723744_1641130 0.000145455
R25_8_0 n25_761440_480880 n25_761440_480720 0.000145455
R25_8_1 n25_761440_502432 n25_761440_480880 0.0195927
R25_8_2 n25_761440_538912 n25_761440_502432 0.0331636
R25_8_3 n25_761440_577824 n25_761440_538912 0.035374499999999996
R25_8_4 n25_761440_614304 n25_761440_577824 0.0331636
R25_8_5 n25_761440_653216 n25_761440_614304 0.035374499999999996
R25_8_6 n25_761440_692128 n25_761440_653216 0.035374499999999996
R25_8_7 n25_761440_728608 n25_761440_692128 0.0331636
R25_8_8 n25_761440_767520 n25_761440_728608 0.035374499999999996
R25_8_9 n25_761440_804000 n25_761440_767520 0.0331636
R25_8_10 n25_761440_842912 n25_761440_804000 0.035374499999999996
R25_8_11 n25_761440_881824 n25_761440_842912 0.035374499999999996
R25_8_12 n25_761440_918304 n25_761440_881824 0.0331636
R25_8_13 n25_761440_957216 n25_761440_918304 0.035374499999999996
R25_8_14 n25_761440_993696 n25_761440_957216 0.0331636
R25_8_15 n25_761440_1032608 n25_761440_993696 0.035374499999999996
R25_8_16 n25_761440_1071520 n25_761440_1032608 0.035374499999999996
R25_8_17 n25_761440_1108000 n25_761440_1071520 0.0331636
R25_8_18 n25_761440_1146912 n25_761440_1108000 0.035374499999999996
R25_8_19 n25_761440_1183392 n25_761440_1146912 0.0331636
R25_8_20 n25_761440_1222304 n25_761440_1183392 0.035374499999999996
R25_8_21 n25_761440_1261216 n25_761440_1222304 0.035374499999999996
R25_8_22 n25_761440_1297696 n25_761440_1261216 0.0331636
R25_8_23 n25_761440_1336608 n25_761440_1297696 0.035374499999999996
R25_8_24 n25_761440_1373088 n25_761440_1336608 0.0331636
R25_8_25 n25_761440_1412000 n25_761440_1373088 0.035374499999999996
R25_8_26 n25_761440_1448480 n25_761440_1412000 0.0331636
R25_8_27 n25_761440_1487392 n25_761440_1448480 0.035374499999999996
R25_8_28 n25_761440_1526304 n25_761440_1487392 0.035374499999999996
R25_8_29 n25_761440_1562784 n25_761440_1526304 0.0331636
R25_8_30 n25_761440_1601696 n25_761440_1562784 0.035374499999999996
R25_8_31 n25_761440_1641130 n25_761440_1601696 0.0358491
R25_8_32 n25_761440_1641290 n25_761440_1641130 0.000145455
R25_9_0 n25_800352_480880 n25_800352_480720 0.000145455
R25_9_1 n25_800352_502432 n25_800352_480880 0.0195927
R25_9_2 n25_800352_538912 n25_800352_502432 0.0331636
R25_9_3 n25_800352_577824 n25_800352_538912 0.035374499999999996
R25_9_4 n25_800352_614304 n25_800352_577824 0.0331636
R25_9_5 n25_800352_653216 n25_800352_614304 0.035374499999999996
R25_9_6 n25_800352_692128 n25_800352_653216 0.035374499999999996
R25_9_7 n25_800352_728608 n25_800352_692128 0.0331636
R25_9_8 n25_800352_767520 n25_800352_728608 0.035374499999999996
R25_9_9 n25_800352_804000 n25_800352_767520 0.0331636
R25_9_10 n25_800352_842912 n25_800352_804000 0.035374499999999996
R25_9_11 n25_800352_881824 n25_800352_842912 0.035374499999999996
R25_9_12 n25_800352_918304 n25_800352_881824 0.0331636
R25_9_13 n25_800352_957216 n25_800352_918304 0.035374499999999996
R25_9_14 n25_800352_993696 n25_800352_957216 0.0331636
R25_9_15 n25_800352_1032608 n25_800352_993696 0.035374499999999996
R25_9_16 n25_800352_1071520 n25_800352_1032608 0.035374499999999996
R25_9_17 n25_800352_1108000 n25_800352_1071520 0.0331636
R25_9_18 n25_800352_1146912 n25_800352_1108000 0.035374499999999996
R25_9_19 n25_800352_1183392 n25_800352_1146912 0.0331636
R25_9_20 n25_800352_1222304 n25_800352_1183392 0.035374499999999996
R25_9_21 n25_800352_1261216 n25_800352_1222304 0.035374499999999996
R25_9_22 n25_800352_1297696 n25_800352_1261216 0.0331636
R25_9_23 n25_800352_1336608 n25_800352_1297696 0.035374499999999996
R25_9_24 n25_800352_1373088 n25_800352_1336608 0.0331636
R25_9_25 n25_800352_1412000 n25_800352_1373088 0.035374499999999996
R25_9_26 n25_800352_1448480 n25_800352_1412000 0.0331636
R25_9_27 n25_800352_1487392 n25_800352_1448480 0.035374499999999996
R25_9_28 n25_800352_1526304 n25_800352_1487392 0.035374499999999996
R25_9_29 n25_800352_1562784 n25_800352_1526304 0.0331636
R25_9_30 n25_800352_1601696 n25_800352_1562784 0.035374499999999996
R25_9_31 n25_800352_1641130 n25_800352_1601696 0.0358491
R25_9_32 n25_800352_1641290 n25_800352_1641130 0.000145455
R25_10_0 n25_838048_480880 n25_838048_480720 0.000145455
R25_10_1 n25_838048_502432 n25_838048_480880 0.0195927
R25_10_2 n25_838048_538912 n25_838048_502432 0.0331636
R25_10_3 n25_838048_577824 n25_838048_538912 0.035374499999999996
R25_10_4 n25_838048_614304 n25_838048_577824 0.0331636
R25_10_5 n25_838048_653216 n25_838048_614304 0.035374499999999996
R25_10_6 n25_838048_692128 n25_838048_653216 0.035374499999999996
R25_10_7 n25_838048_728608 n25_838048_692128 0.0331636
R25_10_8 n25_838048_767520 n25_838048_728608 0.035374499999999996
R25_10_9 n25_838048_804000 n25_838048_767520 0.0331636
R25_10_10 n25_838048_842912 n25_838048_804000 0.035374499999999996
R25_10_11 n25_838048_881824 n25_838048_842912 0.035374499999999996
R25_10_12 n25_838048_918304 n25_838048_881824 0.0331636
R25_10_13 n25_838048_957216 n25_838048_918304 0.035374499999999996
R25_10_14 n25_838048_993696 n25_838048_957216 0.0331636
R25_10_15 n25_838048_1032608 n25_838048_993696 0.035374499999999996
R25_10_16 n25_838048_1071520 n25_838048_1032608 0.035374499999999996
R25_10_17 n25_838048_1108000 n25_838048_1071520 0.0331636
R25_10_18 n25_838048_1146912 n25_838048_1108000 0.035374499999999996
R25_10_19 n25_838048_1183392 n25_838048_1146912 0.0331636
R25_10_20 n25_838048_1222304 n25_838048_1183392 0.035374499999999996
R25_10_21 n25_838048_1261216 n25_838048_1222304 0.035374499999999996
R25_10_22 n25_838048_1297696 n25_838048_1261216 0.0331636
R25_10_23 n25_838048_1336608 n25_838048_1297696 0.035374499999999996
R25_10_24 n25_838048_1373088 n25_838048_1336608 0.0331636
R25_10_25 n25_838048_1412000 n25_838048_1373088 0.035374499999999996
R25_10_26 n25_838048_1448480 n25_838048_1412000 0.0331636
R25_10_27 n25_838048_1487392 n25_838048_1448480 0.035374499999999996
R25_10_28 n25_838048_1526304 n25_838048_1487392 0.035374499999999996
R25_10_29 n25_838048_1562784 n25_838048_1526304 0.0331636
R25_10_30 n25_838048_1601696 n25_838048_1562784 0.035374499999999996
R25_10_31 n25_838048_1641130 n25_838048_1601696 0.0358491
R25_10_32 n25_838048_1641290 n25_838048_1641130 0.000145455
R25_11_0 n25_876960_480880 n25_876960_480720 0.000145455
R25_11_1 n25_876960_502432 n25_876960_480880 0.0195927
R25_11_2 n25_876960_538912 n25_876960_502432 0.0331636
R25_11_3 n25_876960_577824 n25_876960_538912 0.035374499999999996
R25_11_4 n25_876960_614304 n25_876960_577824 0.0331636
R25_11_5 n25_876960_653216 n25_876960_614304 0.035374499999999996
R25_11_6 n25_876960_692128 n25_876960_653216 0.035374499999999996
R25_11_7 n25_876960_728608 n25_876960_692128 0.0331636
R25_11_8 n25_876960_767520 n25_876960_728608 0.035374499999999996
R25_11_9 n25_876960_804000 n25_876960_767520 0.0331636
R25_11_10 n25_876960_842912 n25_876960_804000 0.035374499999999996
R25_11_11 n25_876960_881824 n25_876960_842912 0.035374499999999996
R25_11_12 n25_876960_918304 n25_876960_881824 0.0331636
R25_11_13 n25_876960_957216 n25_876960_918304 0.035374499999999996
R25_11_14 n25_876960_993696 n25_876960_957216 0.0331636
R25_11_15 n25_876960_1032608 n25_876960_993696 0.035374499999999996
R25_11_16 n25_876960_1071520 n25_876960_1032608 0.035374499999999996
R25_11_17 n25_876960_1108000 n25_876960_1071520 0.0331636
R25_11_18 n25_876960_1146912 n25_876960_1108000 0.035374499999999996
R25_11_19 n25_876960_1183392 n25_876960_1146912 0.0331636
R25_11_20 n25_876960_1222304 n25_876960_1183392 0.035374499999999996
R25_11_21 n25_876960_1261216 n25_876960_1222304 0.035374499999999996
R25_11_22 n25_876960_1297696 n25_876960_1261216 0.0331636
R25_11_23 n25_876960_1336608 n25_876960_1297696 0.035374499999999996
R25_11_24 n25_876960_1373088 n25_876960_1336608 0.0331636
R25_11_25 n25_876960_1412000 n25_876960_1373088 0.035374499999999996
R25_11_26 n25_876960_1448480 n25_876960_1412000 0.0331636
R25_11_27 n25_876960_1487392 n25_876960_1448480 0.035374499999999996
R25_11_28 n25_876960_1526304 n25_876960_1487392 0.035374499999999996
R25_11_29 n25_876960_1562784 n25_876960_1526304 0.0331636
R25_11_30 n25_876960_1601696 n25_876960_1562784 0.035374499999999996
R25_11_31 n25_876960_1641130 n25_876960_1601696 0.0358491
R25_11_32 n25_876960_1641290 n25_876960_1641130 0.000145455
R25_12_0 n25_914656_480880 n25_914656_480720 0.000145455
R25_12_1 n25_914656_502432 n25_914656_480880 0.0195927
R25_12_2 n25_914656_538912 n25_914656_502432 0.0331636
R25_12_3 n25_914656_577824 n25_914656_538912 0.035374499999999996
R25_12_4 n25_914656_614304 n25_914656_577824 0.0331636
R25_12_5 n25_914656_653216 n25_914656_614304 0.035374499999999996
R25_12_6 n25_914656_692128 n25_914656_653216 0.035374499999999996
R25_12_7 n25_914656_728608 n25_914656_692128 0.0331636
R25_12_8 n25_914656_767520 n25_914656_728608 0.035374499999999996
R25_12_9 n25_914656_804000 n25_914656_767520 0.0331636
R25_12_10 n25_914656_842912 n25_914656_804000 0.035374499999999996
R25_12_11 n25_914656_881824 n25_914656_842912 0.035374499999999996
R25_12_12 n25_914656_918304 n25_914656_881824 0.0331636
R25_12_13 n25_914656_957216 n25_914656_918304 0.035374499999999996
R25_12_14 n25_914656_993696 n25_914656_957216 0.0331636
R25_12_15 n25_914656_1032608 n25_914656_993696 0.035374499999999996
R25_12_16 n25_914656_1071520 n25_914656_1032608 0.035374499999999996
R25_12_17 n25_914656_1108000 n25_914656_1071520 0.0331636
R25_12_18 n25_914656_1146912 n25_914656_1108000 0.035374499999999996
R25_12_19 n25_914656_1183392 n25_914656_1146912 0.0331636
R25_12_20 n25_914656_1222304 n25_914656_1183392 0.035374499999999996
R25_12_21 n25_914656_1261216 n25_914656_1222304 0.035374499999999996
R25_12_22 n25_914656_1297696 n25_914656_1261216 0.0331636
R25_12_23 n25_914656_1336608 n25_914656_1297696 0.035374499999999996
R25_12_24 n25_914656_1373088 n25_914656_1336608 0.0331636
R25_12_25 n25_914656_1412000 n25_914656_1373088 0.035374499999999996
R25_12_26 n25_914656_1448480 n25_914656_1412000 0.0331636
R25_12_27 n25_914656_1487392 n25_914656_1448480 0.035374499999999996
R25_12_28 n25_914656_1526304 n25_914656_1487392 0.035374499999999996
R25_12_29 n25_914656_1562784 n25_914656_1526304 0.0331636
R25_12_30 n25_914656_1601696 n25_914656_1562784 0.035374499999999996
R25_12_31 n25_914656_1641130 n25_914656_1601696 0.0358491
R25_12_32 n25_914656_1641290 n25_914656_1641130 0.000145455
R25_13_0 n25_952352_480880 n25_952352_480720 0.000145455
R25_13_1 n25_952352_502432 n25_952352_480880 0.0195927
R25_13_2 n25_952352_538912 n25_952352_502432 0.0331636
R25_13_3 n25_952352_577824 n25_952352_538912 0.035374499999999996
R25_13_4 n25_952352_614304 n25_952352_577824 0.0331636
R25_13_5 n25_952352_653216 n25_952352_614304 0.035374499999999996
R25_13_6 n25_952352_692128 n25_952352_653216 0.035374499999999996
R25_13_7 n25_952352_728608 n25_952352_692128 0.0331636
R25_13_8 n25_952352_767520 n25_952352_728608 0.035374499999999996
R25_13_9 n25_952352_804000 n25_952352_767520 0.0331636
R25_13_10 n25_952352_842912 n25_952352_804000 0.035374499999999996
R25_13_11 n25_952352_881824 n25_952352_842912 0.035374499999999996
R25_13_12 n25_952352_918304 n25_952352_881824 0.0331636
R25_13_13 n25_952352_957216 n25_952352_918304 0.035374499999999996
R25_13_14 n25_952352_993696 n25_952352_957216 0.0331636
R25_13_15 n25_952352_1032608 n25_952352_993696 0.035374499999999996
R25_13_16 n25_952352_1071520 n25_952352_1032608 0.035374499999999996
R25_13_17 n25_952352_1108000 n25_952352_1071520 0.0331636
R25_13_18 n25_952352_1146912 n25_952352_1108000 0.035374499999999996
R25_13_19 n25_952352_1183392 n25_952352_1146912 0.0331636
R25_13_20 n25_952352_1222304 n25_952352_1183392 0.035374499999999996
R25_13_21 n25_952352_1261216 n25_952352_1222304 0.035374499999999996
R25_13_22 n25_952352_1297696 n25_952352_1261216 0.0331636
R25_13_23 n25_952352_1336608 n25_952352_1297696 0.035374499999999996
R25_13_24 n25_952352_1373088 n25_952352_1336608 0.0331636
R25_13_25 n25_952352_1412000 n25_952352_1373088 0.035374499999999996
R25_13_26 n25_952352_1448480 n25_952352_1412000 0.0331636
R25_13_27 n25_952352_1487392 n25_952352_1448480 0.035374499999999996
R25_13_28 n25_952352_1526304 n25_952352_1487392 0.035374499999999996
R25_13_29 n25_952352_1562784 n25_952352_1526304 0.0331636
R25_13_30 n25_952352_1601696 n25_952352_1562784 0.035374499999999996
R25_13_31 n25_952352_1641130 n25_952352_1601696 0.0358491
R25_13_32 n25_952352_1641290 n25_952352_1641130 0.000145455
R25_14_0 n25_991264_480880 n25_991264_480720 0.000145455
R25_14_1 n25_991264_502432 n25_991264_480880 0.0195927
R25_14_2 n25_991264_538912 n25_991264_502432 0.0331636
R25_14_3 n25_991264_577824 n25_991264_538912 0.035374499999999996
R25_14_4 n25_991264_614304 n25_991264_577824 0.0331636
R25_14_5 n25_991264_653216 n25_991264_614304 0.035374499999999996
R25_14_6 n25_991264_692128 n25_991264_653216 0.035374499999999996
R25_14_7 n25_991264_728608 n25_991264_692128 0.0331636
R25_14_8 n25_991264_767520 n25_991264_728608 0.035374499999999996
R25_14_9 n25_991264_804000 n25_991264_767520 0.0331636
R25_14_10 n25_991264_842912 n25_991264_804000 0.035374499999999996
R25_14_11 n25_991264_881824 n25_991264_842912 0.035374499999999996
R25_14_12 n25_991264_918304 n25_991264_881824 0.0331636
R25_14_13 n25_991264_957216 n25_991264_918304 0.035374499999999996
R25_14_14 n25_991264_993696 n25_991264_957216 0.0331636
R25_14_15 n25_991264_1032608 n25_991264_993696 0.035374499999999996
R25_14_16 n25_991264_1071520 n25_991264_1032608 0.035374499999999996
R25_14_17 n25_991264_1108000 n25_991264_1071520 0.0331636
R25_14_18 n25_991264_1146912 n25_991264_1108000 0.035374499999999996
R25_14_19 n25_991264_1183392 n25_991264_1146912 0.0331636
R25_14_20 n25_991264_1222304 n25_991264_1183392 0.035374499999999996
R25_14_21 n25_991264_1261216 n25_991264_1222304 0.035374499999999996
R25_14_22 n25_991264_1297696 n25_991264_1261216 0.0331636
R25_14_23 n25_991264_1336608 n25_991264_1297696 0.035374499999999996
R25_14_24 n25_991264_1373088 n25_991264_1336608 0.0331636
R25_14_25 n25_991264_1412000 n25_991264_1373088 0.035374499999999996
R25_14_26 n25_991264_1448480 n25_991264_1412000 0.0331636
R25_14_27 n25_991264_1487392 n25_991264_1448480 0.035374499999999996
R25_14_28 n25_991264_1526304 n25_991264_1487392 0.035374499999999996
R25_14_29 n25_991264_1562784 n25_991264_1526304 0.0331636
R25_14_30 n25_991264_1601696 n25_991264_1562784 0.035374499999999996
R25_14_31 n25_991264_1641130 n25_991264_1601696 0.0358491
R25_14_32 n25_991264_1641290 n25_991264_1641130 0.000145455
R25_15_0 n25_1028960_480880 n25_1028960_480720 0.000145455
R25_15_1 n25_1028960_502432 n25_1028960_480880 0.0195927
R25_15_2 n25_1028960_538912 n25_1028960_502432 0.0331636
R25_15_3 n25_1028960_577824 n25_1028960_538912 0.035374499999999996
R25_15_4 n25_1028960_614304 n25_1028960_577824 0.0331636
R25_15_5 n25_1028960_653216 n25_1028960_614304 0.035374499999999996
R25_15_6 n25_1028960_692128 n25_1028960_653216 0.035374499999999996
R25_15_7 n25_1028960_728608 n25_1028960_692128 0.0331636
R25_15_8 n25_1028960_767520 n25_1028960_728608 0.035374499999999996
R25_15_9 n25_1028960_804000 n25_1028960_767520 0.0331636
R25_15_10 n25_1028960_842912 n25_1028960_804000 0.035374499999999996
R25_15_11 n25_1028960_881824 n25_1028960_842912 0.035374499999999996
R25_15_12 n25_1028960_918304 n25_1028960_881824 0.0331636
R25_15_13 n25_1028960_957216 n25_1028960_918304 0.035374499999999996
R25_15_14 n25_1028960_993696 n25_1028960_957216 0.0331636
R25_15_15 n25_1028960_1032608 n25_1028960_993696 0.035374499999999996
R25_15_16 n25_1028960_1071520 n25_1028960_1032608 0.035374499999999996
R25_15_17 n25_1028960_1108000 n25_1028960_1071520 0.0331636
R25_15_18 n25_1028960_1146912 n25_1028960_1108000 0.035374499999999996
R25_15_19 n25_1028960_1183392 n25_1028960_1146912 0.0331636
R25_15_20 n25_1028960_1222304 n25_1028960_1183392 0.035374499999999996
R25_15_21 n25_1028960_1261216 n25_1028960_1222304 0.035374499999999996
R25_15_22 n25_1028960_1297696 n25_1028960_1261216 0.0331636
R25_15_23 n25_1028960_1336608 n25_1028960_1297696 0.035374499999999996
R25_15_24 n25_1028960_1373088 n25_1028960_1336608 0.0331636
R25_15_25 n25_1028960_1412000 n25_1028960_1373088 0.035374499999999996
R25_15_26 n25_1028960_1448480 n25_1028960_1412000 0.0331636
R25_15_27 n25_1028960_1487392 n25_1028960_1448480 0.035374499999999996
R25_15_28 n25_1028960_1526304 n25_1028960_1487392 0.035374499999999996
R25_15_29 n25_1028960_1562784 n25_1028960_1526304 0.0331636
R25_15_30 n25_1028960_1601696 n25_1028960_1562784 0.035374499999999996
R25_15_31 n25_1028960_1641130 n25_1028960_1601696 0.0358491
R25_15_32 n25_1028960_1641290 n25_1028960_1641130 0.000145455
R25_16_0 n25_1067872_480880 n25_1067872_480720 0.000145455
R25_16_1 n25_1067872_502432 n25_1067872_480880 0.0195927
R25_16_2 n25_1067872_538912 n25_1067872_502432 0.0331636
R25_16_3 n25_1067872_577824 n25_1067872_538912 0.035374499999999996
R25_16_4 n25_1067872_614304 n25_1067872_577824 0.0331636
R25_16_5 n25_1067872_653216 n25_1067872_614304 0.035374499999999996
R25_16_6 n25_1067872_692128 n25_1067872_653216 0.035374499999999996
R25_16_7 n25_1067872_728608 n25_1067872_692128 0.0331636
R25_16_8 n25_1067872_767520 n25_1067872_728608 0.035374499999999996
R25_16_9 n25_1067872_804000 n25_1067872_767520 0.0331636
R25_16_10 n25_1067872_842912 n25_1067872_804000 0.035374499999999996
R25_16_11 n25_1067872_881824 n25_1067872_842912 0.035374499999999996
R25_16_12 n25_1067872_918304 n25_1067872_881824 0.0331636
R25_16_13 n25_1067872_957216 n25_1067872_918304 0.035374499999999996
R25_16_14 n25_1067872_993696 n25_1067872_957216 0.0331636
R25_16_15 n25_1067872_1032608 n25_1067872_993696 0.035374499999999996
R25_16_16 n25_1067872_1071520 n25_1067872_1032608 0.035374499999999996
R25_16_17 n25_1067872_1108000 n25_1067872_1071520 0.0331636
R25_16_18 n25_1067872_1146912 n25_1067872_1108000 0.035374499999999996
R25_16_19 n25_1067872_1183392 n25_1067872_1146912 0.0331636
R25_16_20 n25_1067872_1222304 n25_1067872_1183392 0.035374499999999996
R25_16_21 n25_1067872_1261216 n25_1067872_1222304 0.035374499999999996
R25_16_22 n25_1067872_1297696 n25_1067872_1261216 0.0331636
R25_16_23 n25_1067872_1336608 n25_1067872_1297696 0.035374499999999996
R25_16_24 n25_1067872_1373088 n25_1067872_1336608 0.0331636
R25_16_25 n25_1067872_1412000 n25_1067872_1373088 0.035374499999999996
R25_16_26 n25_1067872_1448480 n25_1067872_1412000 0.0331636
R25_16_27 n25_1067872_1487392 n25_1067872_1448480 0.035374499999999996
R25_16_28 n25_1067872_1526304 n25_1067872_1487392 0.035374499999999996
R25_16_29 n25_1067872_1562784 n25_1067872_1526304 0.0331636
R25_16_30 n25_1067872_1601696 n25_1067872_1562784 0.035374499999999996
R25_16_31 n25_1067872_1641130 n25_1067872_1601696 0.0358491
R25_16_32 n25_1067872_1641290 n25_1067872_1641130 0.000145455
R25_17_0 n25_1105568_480880 n25_1105568_480720 0.000145455
R25_17_1 n25_1105568_502432 n25_1105568_480880 0.0195927
R25_17_2 n25_1105568_538912 n25_1105568_502432 0.0331636
R25_17_3 n25_1105568_577824 n25_1105568_538912 0.035374499999999996
R25_17_4 n25_1105568_614304 n25_1105568_577824 0.0331636
R25_17_5 n25_1105568_653216 n25_1105568_614304 0.035374499999999996
R25_17_6 n25_1105568_692128 n25_1105568_653216 0.035374499999999996
R25_17_7 n25_1105568_728608 n25_1105568_692128 0.0331636
R25_17_8 n25_1105568_767520 n25_1105568_728608 0.035374499999999996
R25_17_9 n25_1105568_804000 n25_1105568_767520 0.0331636
R25_17_10 n25_1105568_842912 n25_1105568_804000 0.035374499999999996
R25_17_11 n25_1105568_881824 n25_1105568_842912 0.035374499999999996
R25_17_12 n25_1105568_918304 n25_1105568_881824 0.0331636
R25_17_13 n25_1105568_957216 n25_1105568_918304 0.035374499999999996
R25_17_14 n25_1105568_993696 n25_1105568_957216 0.0331636
R25_17_15 n25_1105568_1032608 n25_1105568_993696 0.035374499999999996
R25_17_16 n25_1105568_1071520 n25_1105568_1032608 0.035374499999999996
R25_17_17 n25_1105568_1108000 n25_1105568_1071520 0.0331636
R25_17_18 n25_1105568_1146912 n25_1105568_1108000 0.035374499999999996
R25_17_19 n25_1105568_1183392 n25_1105568_1146912 0.0331636
R25_17_20 n25_1105568_1222304 n25_1105568_1183392 0.035374499999999996
R25_17_21 n25_1105568_1261216 n25_1105568_1222304 0.035374499999999996
R25_17_22 n25_1105568_1297696 n25_1105568_1261216 0.0331636
R25_17_23 n25_1105568_1336608 n25_1105568_1297696 0.035374499999999996
R25_17_24 n25_1105568_1373088 n25_1105568_1336608 0.0331636
R25_17_25 n25_1105568_1412000 n25_1105568_1373088 0.035374499999999996
R25_17_26 n25_1105568_1448480 n25_1105568_1412000 0.0331636
R25_17_27 n25_1105568_1487392 n25_1105568_1448480 0.035374499999999996
R25_17_28 n25_1105568_1526304 n25_1105568_1487392 0.035374499999999996
R25_17_29 n25_1105568_1562784 n25_1105568_1526304 0.0331636
R25_17_30 n25_1105568_1601696 n25_1105568_1562784 0.035374499999999996
R25_17_31 n25_1105568_1641130 n25_1105568_1601696 0.0358491
R25_17_32 n25_1105568_1641290 n25_1105568_1641130 0.000145455
R25_18_0 n25_1144480_480880 n25_1144480_480720 0.000145455
R25_18_1 n25_1144480_502432 n25_1144480_480880 0.0195927
R25_18_2 n25_1144480_538912 n25_1144480_502432 0.0331636
R25_18_3 n25_1144480_577824 n25_1144480_538912 0.035374499999999996
R25_18_4 n25_1144480_614304 n25_1144480_577824 0.0331636
R25_18_5 n25_1144480_653216 n25_1144480_614304 0.035374499999999996
R25_18_6 n25_1144480_692128 n25_1144480_653216 0.035374499999999996
R25_18_7 n25_1144480_728608 n25_1144480_692128 0.0331636
R25_18_8 n25_1144480_767520 n25_1144480_728608 0.035374499999999996
R25_18_9 n25_1144480_804000 n25_1144480_767520 0.0331636
R25_18_10 n25_1144480_842912 n25_1144480_804000 0.035374499999999996
R25_18_11 n25_1144480_881824 n25_1144480_842912 0.035374499999999996
R25_18_12 n25_1144480_918304 n25_1144480_881824 0.0331636
R25_18_13 n25_1144480_957216 n25_1144480_918304 0.035374499999999996
R25_18_14 n25_1144480_993696 n25_1144480_957216 0.0331636
R25_18_15 n25_1144480_1032608 n25_1144480_993696 0.035374499999999996
R25_18_16 n25_1144480_1071520 n25_1144480_1032608 0.035374499999999996
R25_18_17 n25_1144480_1108000 n25_1144480_1071520 0.0331636
R25_18_18 n25_1144480_1146912 n25_1144480_1108000 0.035374499999999996
R25_18_19 n25_1144480_1183392 n25_1144480_1146912 0.0331636
R25_18_20 n25_1144480_1222304 n25_1144480_1183392 0.035374499999999996
R25_18_21 n25_1144480_1261216 n25_1144480_1222304 0.035374499999999996
R25_18_22 n25_1144480_1297696 n25_1144480_1261216 0.0331636
R25_18_23 n25_1144480_1336608 n25_1144480_1297696 0.035374499999999996
R25_18_24 n25_1144480_1373088 n25_1144480_1336608 0.0331636
R25_18_25 n25_1144480_1412000 n25_1144480_1373088 0.035374499999999996
R25_18_26 n25_1144480_1448480 n25_1144480_1412000 0.0331636
R25_18_27 n25_1144480_1487392 n25_1144480_1448480 0.035374499999999996
R25_18_28 n25_1144480_1526304 n25_1144480_1487392 0.035374499999999996
R25_18_29 n25_1144480_1562784 n25_1144480_1526304 0.0331636
R25_18_30 n25_1144480_1601696 n25_1144480_1562784 0.035374499999999996
R25_18_31 n25_1144480_1641130 n25_1144480_1601696 0.0358491
R25_18_32 n25_1144480_1641290 n25_1144480_1641130 0.000145455
R25_19_0 n25_1182176_480880 n25_1182176_480720 0.000145455
R25_19_1 n25_1182176_502432 n25_1182176_480880 0.0195927
R25_19_2 n25_1182176_538912 n25_1182176_502432 0.0331636
R25_19_3 n25_1182176_577824 n25_1182176_538912 0.035374499999999996
R25_19_4 n25_1182176_614304 n25_1182176_577824 0.0331636
R25_19_5 n25_1182176_653216 n25_1182176_614304 0.035374499999999996
R25_19_6 n25_1182176_692128 n25_1182176_653216 0.035374499999999996
R25_19_7 n25_1182176_728608 n25_1182176_692128 0.0331636
R25_19_8 n25_1182176_767520 n25_1182176_728608 0.035374499999999996
R25_19_9 n25_1182176_804000 n25_1182176_767520 0.0331636
R25_19_10 n25_1182176_842912 n25_1182176_804000 0.035374499999999996
R25_19_11 n25_1182176_881824 n25_1182176_842912 0.035374499999999996
R25_19_12 n25_1182176_918304 n25_1182176_881824 0.0331636
R25_19_13 n25_1182176_957216 n25_1182176_918304 0.035374499999999996
R25_19_14 n25_1182176_993696 n25_1182176_957216 0.0331636
R25_19_15 n25_1182176_1032608 n25_1182176_993696 0.035374499999999996
R25_19_16 n25_1182176_1071520 n25_1182176_1032608 0.035374499999999996
R25_19_17 n25_1182176_1108000 n25_1182176_1071520 0.0331636
R25_19_18 n25_1182176_1146912 n25_1182176_1108000 0.035374499999999996
R25_19_19 n25_1182176_1183392 n25_1182176_1146912 0.0331636
R25_19_20 n25_1182176_1222304 n25_1182176_1183392 0.035374499999999996
R25_19_21 n25_1182176_1261216 n25_1182176_1222304 0.035374499999999996
R25_19_22 n25_1182176_1297696 n25_1182176_1261216 0.0331636
R25_19_23 n25_1182176_1336608 n25_1182176_1297696 0.035374499999999996
R25_19_24 n25_1182176_1373088 n25_1182176_1336608 0.0331636
R25_19_25 n25_1182176_1412000 n25_1182176_1373088 0.035374499999999996
R25_19_26 n25_1182176_1448480 n25_1182176_1412000 0.0331636
R25_19_27 n25_1182176_1487392 n25_1182176_1448480 0.035374499999999996
R25_19_28 n25_1182176_1526304 n25_1182176_1487392 0.035374499999999996
R25_19_29 n25_1182176_1562784 n25_1182176_1526304 0.0331636
R25_19_30 n25_1182176_1601696 n25_1182176_1562784 0.035374499999999996
R25_19_31 n25_1182176_1641130 n25_1182176_1601696 0.0358491
R25_19_32 n25_1182176_1641290 n25_1182176_1641130 0.000145455
R25_20_0 n25_1219872_480880 n25_1219872_480720 0.000145455
R25_20_1 n25_1219872_502432 n25_1219872_480880 0.0195927
R25_20_2 n25_1219872_538912 n25_1219872_502432 0.0331636
R25_20_3 n25_1219872_577824 n25_1219872_538912 0.035374499999999996
R25_20_4 n25_1219872_614304 n25_1219872_577824 0.0331636
R25_20_5 n25_1219872_653216 n25_1219872_614304 0.035374499999999996
R25_20_6 n25_1219872_692128 n25_1219872_653216 0.035374499999999996
R25_20_7 n25_1219872_728608 n25_1219872_692128 0.0331636
R25_20_8 n25_1219872_767520 n25_1219872_728608 0.035374499999999996
R25_20_9 n25_1219872_804000 n25_1219872_767520 0.0331636
R25_20_10 n25_1219872_842912 n25_1219872_804000 0.035374499999999996
R25_20_11 n25_1219872_881824 n25_1219872_842912 0.035374499999999996
R25_20_12 n25_1219872_918304 n25_1219872_881824 0.0331636
R25_20_13 n25_1219872_957216 n25_1219872_918304 0.035374499999999996
R25_20_14 n25_1219872_993696 n25_1219872_957216 0.0331636
R25_20_15 n25_1219872_1032608 n25_1219872_993696 0.035374499999999996
R25_20_16 n25_1219872_1071520 n25_1219872_1032608 0.035374499999999996
R25_20_17 n25_1219872_1108000 n25_1219872_1071520 0.0331636
R25_20_18 n25_1219872_1146912 n25_1219872_1108000 0.035374499999999996
R25_20_19 n25_1219872_1183392 n25_1219872_1146912 0.0331636
R25_20_20 n25_1219872_1222304 n25_1219872_1183392 0.035374499999999996
R25_20_21 n25_1219872_1261216 n25_1219872_1222304 0.035374499999999996
R25_20_22 n25_1219872_1297696 n25_1219872_1261216 0.0331636
R25_20_23 n25_1219872_1336608 n25_1219872_1297696 0.035374499999999996
R25_20_24 n25_1219872_1373088 n25_1219872_1336608 0.0331636
R25_20_25 n25_1219872_1412000 n25_1219872_1373088 0.035374499999999996
R25_20_26 n25_1219872_1448480 n25_1219872_1412000 0.0331636
R25_20_27 n25_1219872_1487392 n25_1219872_1448480 0.035374499999999996
R25_20_28 n25_1219872_1526304 n25_1219872_1487392 0.035374499999999996
R25_20_29 n25_1219872_1562784 n25_1219872_1526304 0.0331636
R25_20_30 n25_1219872_1601696 n25_1219872_1562784 0.035374499999999996
R25_20_31 n25_1219872_1641130 n25_1219872_1601696 0.0358491
R25_20_32 n25_1219872_1641290 n25_1219872_1641130 0.000145455
R25_21_0 n25_1258784_480880 n25_1258784_480720 0.000145455
R25_21_1 n25_1258784_502432 n25_1258784_480880 0.0195927
R25_21_2 n25_1258784_538912 n25_1258784_502432 0.0331636
R25_21_3 n25_1258784_577824 n25_1258784_538912 0.035374499999999996
R25_21_4 n25_1258784_614304 n25_1258784_577824 0.0331636
R25_21_5 n25_1258784_653216 n25_1258784_614304 0.035374499999999996
R25_21_6 n25_1258784_692128 n25_1258784_653216 0.035374499999999996
R25_21_7 n25_1258784_728608 n25_1258784_692128 0.0331636
R25_21_8 n25_1258784_767520 n25_1258784_728608 0.035374499999999996
R25_21_9 n25_1258784_804000 n25_1258784_767520 0.0331636
R25_21_10 n25_1258784_842912 n25_1258784_804000 0.035374499999999996
R25_21_11 n25_1258784_881824 n25_1258784_842912 0.035374499999999996
R25_21_12 n25_1258784_918304 n25_1258784_881824 0.0331636
R25_21_13 n25_1258784_957216 n25_1258784_918304 0.035374499999999996
R25_21_14 n25_1258784_993696 n25_1258784_957216 0.0331636
R25_21_15 n25_1258784_1032608 n25_1258784_993696 0.035374499999999996
R25_21_16 n25_1258784_1071520 n25_1258784_1032608 0.035374499999999996
R25_21_17 n25_1258784_1108000 n25_1258784_1071520 0.0331636
R25_21_18 n25_1258784_1146912 n25_1258784_1108000 0.035374499999999996
R25_21_19 n25_1258784_1183392 n25_1258784_1146912 0.0331636
R25_21_20 n25_1258784_1222304 n25_1258784_1183392 0.035374499999999996
R25_21_21 n25_1258784_1261216 n25_1258784_1222304 0.035374499999999996
R25_21_22 n25_1258784_1297696 n25_1258784_1261216 0.0331636
R25_21_23 n25_1258784_1336608 n25_1258784_1297696 0.035374499999999996
R25_21_24 n25_1258784_1373088 n25_1258784_1336608 0.0331636
R25_21_25 n25_1258784_1412000 n25_1258784_1373088 0.035374499999999996
R25_21_26 n25_1258784_1448480 n25_1258784_1412000 0.0331636
R25_21_27 n25_1258784_1487392 n25_1258784_1448480 0.035374499999999996
R25_21_28 n25_1258784_1526304 n25_1258784_1487392 0.035374499999999996
R25_21_29 n25_1258784_1562784 n25_1258784_1526304 0.0331636
R25_21_30 n25_1258784_1601696 n25_1258784_1562784 0.035374499999999996
R25_21_31 n25_1258784_1641130 n25_1258784_1601696 0.0358491
R25_21_32 n25_1258784_1641290 n25_1258784_1641130 0.000145455
R25_22_0 n25_1296480_480880 n25_1296480_480720 0.000145455
R25_22_1 n25_1296480_502432 n25_1296480_480880 0.0195927
R25_22_2 n25_1296480_538912 n25_1296480_502432 0.0331636
R25_22_3 n25_1296480_577824 n25_1296480_538912 0.035374499999999996
R25_22_4 n25_1296480_614304 n25_1296480_577824 0.0331636
R25_22_5 n25_1296480_653216 n25_1296480_614304 0.035374499999999996
R25_22_6 n25_1296480_692128 n25_1296480_653216 0.035374499999999996
R25_22_7 n25_1296480_728608 n25_1296480_692128 0.0331636
R25_22_8 n25_1296480_767520 n25_1296480_728608 0.035374499999999996
R25_22_9 n25_1296480_804000 n25_1296480_767520 0.0331636
R25_22_10 n25_1296480_842912 n25_1296480_804000 0.035374499999999996
R25_22_11 n25_1296480_881824 n25_1296480_842912 0.035374499999999996
R25_22_12 n25_1296480_918304 n25_1296480_881824 0.0331636
R25_22_13 n25_1296480_957216 n25_1296480_918304 0.035374499999999996
R25_22_14 n25_1296480_993696 n25_1296480_957216 0.0331636
R25_22_15 n25_1296480_1032608 n25_1296480_993696 0.035374499999999996
R25_22_16 n25_1296480_1071520 n25_1296480_1032608 0.035374499999999996
R25_22_17 n25_1296480_1108000 n25_1296480_1071520 0.0331636
R25_22_18 n25_1296480_1146912 n25_1296480_1108000 0.035374499999999996
R25_22_19 n25_1296480_1183392 n25_1296480_1146912 0.0331636
R25_22_20 n25_1296480_1222304 n25_1296480_1183392 0.035374499999999996
R25_22_21 n25_1296480_1261216 n25_1296480_1222304 0.035374499999999996
R25_22_22 n25_1296480_1297696 n25_1296480_1261216 0.0331636
R25_22_23 n25_1296480_1336608 n25_1296480_1297696 0.035374499999999996
R25_22_24 n25_1296480_1373088 n25_1296480_1336608 0.0331636
R25_22_25 n25_1296480_1412000 n25_1296480_1373088 0.035374499999999996
R25_22_26 n25_1296480_1448480 n25_1296480_1412000 0.0331636
R25_22_27 n25_1296480_1487392 n25_1296480_1448480 0.035374499999999996
R25_22_28 n25_1296480_1526304 n25_1296480_1487392 0.035374499999999996
R25_22_29 n25_1296480_1562784 n25_1296480_1526304 0.0331636
R25_22_30 n25_1296480_1601696 n25_1296480_1562784 0.035374499999999996
R25_22_31 n25_1296480_1641130 n25_1296480_1601696 0.0358491
R25_22_32 n25_1296480_1641290 n25_1296480_1641130 0.000145455
R25_23_0 n25_1335392_480880 n25_1335392_480720 0.000145455
R25_23_1 n25_1335392_502432 n25_1335392_480880 0.0195927
R25_23_2 n25_1335392_538912 n25_1335392_502432 0.0331636
R25_23_3 n25_1335392_577824 n25_1335392_538912 0.035374499999999996
R25_23_4 n25_1335392_614304 n25_1335392_577824 0.0331636
R25_23_5 n25_1335392_653216 n25_1335392_614304 0.035374499999999996
R25_23_6 n25_1335392_692128 n25_1335392_653216 0.035374499999999996
R25_23_7 n25_1335392_728608 n25_1335392_692128 0.0331636
R25_23_8 n25_1335392_767520 n25_1335392_728608 0.035374499999999996
R25_23_9 n25_1335392_804000 n25_1335392_767520 0.0331636
R25_23_10 n25_1335392_842912 n25_1335392_804000 0.035374499999999996
R25_23_11 n25_1335392_881824 n25_1335392_842912 0.035374499999999996
R25_23_12 n25_1335392_918304 n25_1335392_881824 0.0331636
R25_23_13 n25_1335392_957216 n25_1335392_918304 0.035374499999999996
R25_23_14 n25_1335392_993696 n25_1335392_957216 0.0331636
R25_23_15 n25_1335392_1032608 n25_1335392_993696 0.035374499999999996
R25_23_16 n25_1335392_1071520 n25_1335392_1032608 0.035374499999999996
R25_23_17 n25_1335392_1108000 n25_1335392_1071520 0.0331636
R25_23_18 n25_1335392_1146912 n25_1335392_1108000 0.035374499999999996
R25_23_19 n25_1335392_1183392 n25_1335392_1146912 0.0331636
R25_23_20 n25_1335392_1222304 n25_1335392_1183392 0.035374499999999996
R25_23_21 n25_1335392_1261216 n25_1335392_1222304 0.035374499999999996
R25_23_22 n25_1335392_1297696 n25_1335392_1261216 0.0331636
R25_23_23 n25_1335392_1336608 n25_1335392_1297696 0.035374499999999996
R25_23_24 n25_1335392_1373088 n25_1335392_1336608 0.0331636
R25_23_25 n25_1335392_1412000 n25_1335392_1373088 0.035374499999999996
R25_23_26 n25_1335392_1448480 n25_1335392_1412000 0.0331636
R25_23_27 n25_1335392_1487392 n25_1335392_1448480 0.035374499999999996
R25_23_28 n25_1335392_1526304 n25_1335392_1487392 0.035374499999999996
R25_23_29 n25_1335392_1562784 n25_1335392_1526304 0.0331636
R25_23_30 n25_1335392_1601696 n25_1335392_1562784 0.035374499999999996
R25_23_31 n25_1335392_1641130 n25_1335392_1601696 0.0358491
R25_23_32 n25_1335392_1641290 n25_1335392_1641130 0.000145455
R25_24_0 n25_1373088_480880 n25_1373088_480720 0.000145455
R25_24_1 n25_1373088_502432 n25_1373088_480880 0.0195927
R25_24_2 n25_1373088_538912 n25_1373088_502432 0.0331636
R25_24_3 n25_1373088_577824 n25_1373088_538912 0.035374499999999996
R25_24_4 n25_1373088_614304 n25_1373088_577824 0.0331636
R25_24_5 n25_1373088_653216 n25_1373088_614304 0.035374499999999996
R25_24_6 n25_1373088_692128 n25_1373088_653216 0.035374499999999996
R25_24_7 n25_1373088_728608 n25_1373088_692128 0.0331636
R25_24_8 n25_1373088_767520 n25_1373088_728608 0.035374499999999996
R25_24_9 n25_1373088_804000 n25_1373088_767520 0.0331636
R25_24_10 n25_1373088_842912 n25_1373088_804000 0.035374499999999996
R25_24_11 n25_1373088_881824 n25_1373088_842912 0.035374499999999996
R25_24_12 n25_1373088_918304 n25_1373088_881824 0.0331636
R25_24_13 n25_1373088_957216 n25_1373088_918304 0.035374499999999996
R25_24_14 n25_1373088_993696 n25_1373088_957216 0.0331636
R25_24_15 n25_1373088_1032608 n25_1373088_993696 0.035374499999999996
R25_24_16 n25_1373088_1071520 n25_1373088_1032608 0.035374499999999996
R25_24_17 n25_1373088_1108000 n25_1373088_1071520 0.0331636
R25_24_18 n25_1373088_1146912 n25_1373088_1108000 0.035374499999999996
R25_24_19 n25_1373088_1183392 n25_1373088_1146912 0.0331636
R25_24_20 n25_1373088_1222304 n25_1373088_1183392 0.035374499999999996
R25_24_21 n25_1373088_1261216 n25_1373088_1222304 0.035374499999999996
R25_24_22 n25_1373088_1297696 n25_1373088_1261216 0.0331636
R25_24_23 n25_1373088_1336608 n25_1373088_1297696 0.035374499999999996
R25_24_24 n25_1373088_1373088 n25_1373088_1336608 0.0331636
R25_24_25 n25_1373088_1412000 n25_1373088_1373088 0.035374499999999996
R25_24_26 n25_1373088_1448480 n25_1373088_1412000 0.0331636
R25_24_27 n25_1373088_1487392 n25_1373088_1448480 0.035374499999999996
R25_24_28 n25_1373088_1526304 n25_1373088_1487392 0.035374499999999996
R25_24_29 n25_1373088_1562784 n25_1373088_1526304 0.0331636
R25_24_30 n25_1373088_1601696 n25_1373088_1562784 0.035374499999999996
R25_24_31 n25_1373088_1641130 n25_1373088_1601696 0.0358491
R25_24_32 n25_1373088_1641290 n25_1373088_1641130 0.000145455
R25_25_0 n25_1412000_480880 n25_1412000_480720 0.000145455
R25_25_1 n25_1412000_502432 n25_1412000_480880 0.0195927
R25_25_2 n25_1412000_538912 n25_1412000_502432 0.0331636
R25_25_3 n25_1412000_577824 n25_1412000_538912 0.035374499999999996
R25_25_4 n25_1412000_614304 n25_1412000_577824 0.0331636
R25_25_5 n25_1412000_653216 n25_1412000_614304 0.035374499999999996
R25_25_6 n25_1412000_692128 n25_1412000_653216 0.035374499999999996
R25_25_7 n25_1412000_728608 n25_1412000_692128 0.0331636
R25_25_8 n25_1412000_767520 n25_1412000_728608 0.035374499999999996
R25_25_9 n25_1412000_804000 n25_1412000_767520 0.0331636
R25_25_10 n25_1412000_842912 n25_1412000_804000 0.035374499999999996
R25_25_11 n25_1412000_881824 n25_1412000_842912 0.035374499999999996
R25_25_12 n25_1412000_918304 n25_1412000_881824 0.0331636
R25_25_13 n25_1412000_957216 n25_1412000_918304 0.035374499999999996
R25_25_14 n25_1412000_993696 n25_1412000_957216 0.0331636
R25_25_15 n25_1412000_1032608 n25_1412000_993696 0.035374499999999996
R25_25_16 n25_1412000_1071520 n25_1412000_1032608 0.035374499999999996
R25_25_17 n25_1412000_1108000 n25_1412000_1071520 0.0331636
R25_25_18 n25_1412000_1146912 n25_1412000_1108000 0.035374499999999996
R25_25_19 n25_1412000_1183392 n25_1412000_1146912 0.0331636
R25_25_20 n25_1412000_1222304 n25_1412000_1183392 0.035374499999999996
R25_25_21 n25_1412000_1261216 n25_1412000_1222304 0.035374499999999996
R25_25_22 n25_1412000_1297696 n25_1412000_1261216 0.0331636
R25_25_23 n25_1412000_1336608 n25_1412000_1297696 0.035374499999999996
R25_25_24 n25_1412000_1373088 n25_1412000_1336608 0.0331636
R25_25_25 n25_1412000_1412000 n25_1412000_1373088 0.035374499999999996
R25_25_26 n25_1412000_1448480 n25_1412000_1412000 0.0331636
R25_25_27 n25_1412000_1487392 n25_1412000_1448480 0.035374499999999996
R25_25_28 n25_1412000_1526304 n25_1412000_1487392 0.035374499999999996
R25_25_29 n25_1412000_1562784 n25_1412000_1526304 0.0331636
R25_25_30 n25_1412000_1601696 n25_1412000_1562784 0.035374499999999996
R25_25_31 n25_1412000_1641130 n25_1412000_1601696 0.0358491
R25_25_32 n25_1412000_1641290 n25_1412000_1641130 0.000145455
R25_26_0 n25_1449696_480880 n25_1449696_480720 0.000145455
R25_26_1 n25_1449696_502432 n25_1449696_480880 0.0195927
R25_26_2 n25_1449696_538912 n25_1449696_502432 0.0331636
R25_26_3 n25_1449696_577824 n25_1449696_538912 0.035374499999999996
R25_26_4 n25_1449696_614304 n25_1449696_577824 0.0331636
R25_26_5 n25_1449696_653216 n25_1449696_614304 0.035374499999999996
R25_26_6 n25_1449696_692128 n25_1449696_653216 0.035374499999999996
R25_26_7 n25_1449696_728608 n25_1449696_692128 0.0331636
R25_26_8 n25_1449696_767520 n25_1449696_728608 0.035374499999999996
R25_26_9 n25_1449696_804000 n25_1449696_767520 0.0331636
R25_26_10 n25_1449696_842912 n25_1449696_804000 0.035374499999999996
R25_26_11 n25_1449696_881824 n25_1449696_842912 0.035374499999999996
R25_26_12 n25_1449696_918304 n25_1449696_881824 0.0331636
R25_26_13 n25_1449696_957216 n25_1449696_918304 0.035374499999999996
R25_26_14 n25_1449696_993696 n25_1449696_957216 0.0331636
R25_26_15 n25_1449696_1032608 n25_1449696_993696 0.035374499999999996
R25_26_16 n25_1449696_1071520 n25_1449696_1032608 0.035374499999999996
R25_26_17 n25_1449696_1108000 n25_1449696_1071520 0.0331636
R25_26_18 n25_1449696_1146912 n25_1449696_1108000 0.035374499999999996
R25_26_19 n25_1449696_1183392 n25_1449696_1146912 0.0331636
R25_26_20 n25_1449696_1222304 n25_1449696_1183392 0.035374499999999996
R25_26_21 n25_1449696_1261216 n25_1449696_1222304 0.035374499999999996
R25_26_22 n25_1449696_1297696 n25_1449696_1261216 0.0331636
R25_26_23 n25_1449696_1336608 n25_1449696_1297696 0.035374499999999996
R25_26_24 n25_1449696_1373088 n25_1449696_1336608 0.0331636
R25_26_25 n25_1449696_1412000 n25_1449696_1373088 0.035374499999999996
R25_26_26 n25_1449696_1448480 n25_1449696_1412000 0.0331636
R25_26_27 n25_1449696_1487392 n25_1449696_1448480 0.035374499999999996
R25_26_28 n25_1449696_1526304 n25_1449696_1487392 0.035374499999999996
R25_26_29 n25_1449696_1562784 n25_1449696_1526304 0.0331636
R25_26_30 n25_1449696_1601696 n25_1449696_1562784 0.035374499999999996
R25_26_31 n25_1449696_1641130 n25_1449696_1601696 0.0358491
R25_26_32 n25_1449696_1641290 n25_1449696_1641130 0.000145455
R25_27_0 n25_1487392_480880 n25_1487392_480720 0.000145455
R25_27_1 n25_1487392_502432 n25_1487392_480880 0.0195927
R25_27_2 n25_1487392_538912 n25_1487392_502432 0.0331636
R25_27_3 n25_1487392_577824 n25_1487392_538912 0.035374499999999996
R25_27_4 n25_1487392_614304 n25_1487392_577824 0.0331636
R25_27_5 n25_1487392_653216 n25_1487392_614304 0.035374499999999996
R25_27_6 n25_1487392_692128 n25_1487392_653216 0.035374499999999996
R25_27_7 n25_1487392_728608 n25_1487392_692128 0.0331636
R25_27_8 n25_1487392_767520 n25_1487392_728608 0.035374499999999996
R25_27_9 n25_1487392_804000 n25_1487392_767520 0.0331636
R25_27_10 n25_1487392_842912 n25_1487392_804000 0.035374499999999996
R25_27_11 n25_1487392_881824 n25_1487392_842912 0.035374499999999996
R25_27_12 n25_1487392_918304 n25_1487392_881824 0.0331636
R25_27_13 n25_1487392_957216 n25_1487392_918304 0.035374499999999996
R25_27_14 n25_1487392_993696 n25_1487392_957216 0.0331636
R25_27_15 n25_1487392_1032608 n25_1487392_993696 0.035374499999999996
R25_27_16 n25_1487392_1071520 n25_1487392_1032608 0.035374499999999996
R25_27_17 n25_1487392_1108000 n25_1487392_1071520 0.0331636
R25_27_18 n25_1487392_1146912 n25_1487392_1108000 0.035374499999999996
R25_27_19 n25_1487392_1183392 n25_1487392_1146912 0.0331636
R25_27_20 n25_1487392_1222304 n25_1487392_1183392 0.035374499999999996
R25_27_21 n25_1487392_1261216 n25_1487392_1222304 0.035374499999999996
R25_27_22 n25_1487392_1297696 n25_1487392_1261216 0.0331636
R25_27_23 n25_1487392_1336608 n25_1487392_1297696 0.035374499999999996
R25_27_24 n25_1487392_1373088 n25_1487392_1336608 0.0331636
R25_27_25 n25_1487392_1412000 n25_1487392_1373088 0.035374499999999996
R25_27_26 n25_1487392_1448480 n25_1487392_1412000 0.0331636
R25_27_27 n25_1487392_1487392 n25_1487392_1448480 0.035374499999999996
R25_27_28 n25_1487392_1526304 n25_1487392_1487392 0.035374499999999996
R25_27_29 n25_1487392_1562784 n25_1487392_1526304 0.0331636
R25_27_30 n25_1487392_1601696 n25_1487392_1562784 0.035374499999999996
R25_27_31 n25_1487392_1641130 n25_1487392_1601696 0.0358491
R25_27_32 n25_1487392_1641290 n25_1487392_1641130 0.000145455
R25_28_0 n25_1526304_480880 n25_1526304_480720 0.000145455
R25_28_1 n25_1526304_502432 n25_1526304_480880 0.0195927
R25_28_2 n25_1526304_538912 n25_1526304_502432 0.0331636
R25_28_3 n25_1526304_577824 n25_1526304_538912 0.035374499999999996
R25_28_4 n25_1526304_614304 n25_1526304_577824 0.0331636
R25_28_5 n25_1526304_653216 n25_1526304_614304 0.035374499999999996
R25_28_6 n25_1526304_692128 n25_1526304_653216 0.035374499999999996
R25_28_7 n25_1526304_728608 n25_1526304_692128 0.0331636
R25_28_8 n25_1526304_767520 n25_1526304_728608 0.035374499999999996
R25_28_9 n25_1526304_804000 n25_1526304_767520 0.0331636
R25_28_10 n25_1526304_842912 n25_1526304_804000 0.035374499999999996
R25_28_11 n25_1526304_881824 n25_1526304_842912 0.035374499999999996
R25_28_12 n25_1526304_918304 n25_1526304_881824 0.0331636
R25_28_13 n25_1526304_957216 n25_1526304_918304 0.035374499999999996
R25_28_14 n25_1526304_993696 n25_1526304_957216 0.0331636
R25_28_15 n25_1526304_1032608 n25_1526304_993696 0.035374499999999996
R25_28_16 n25_1526304_1071520 n25_1526304_1032608 0.035374499999999996
R25_28_17 n25_1526304_1108000 n25_1526304_1071520 0.0331636
R25_28_18 n25_1526304_1146912 n25_1526304_1108000 0.035374499999999996
R25_28_19 n25_1526304_1183392 n25_1526304_1146912 0.0331636
R25_28_20 n25_1526304_1222304 n25_1526304_1183392 0.035374499999999996
R25_28_21 n25_1526304_1261216 n25_1526304_1222304 0.035374499999999996
R25_28_22 n25_1526304_1297696 n25_1526304_1261216 0.0331636
R25_28_23 n25_1526304_1336608 n25_1526304_1297696 0.035374499999999996
R25_28_24 n25_1526304_1373088 n25_1526304_1336608 0.0331636
R25_28_25 n25_1526304_1412000 n25_1526304_1373088 0.035374499999999996
R25_28_26 n25_1526304_1448480 n25_1526304_1412000 0.0331636
R25_28_27 n25_1526304_1487392 n25_1526304_1448480 0.035374499999999996
R25_28_28 n25_1526304_1526304 n25_1526304_1487392 0.035374499999999996
R25_28_29 n25_1526304_1562784 n25_1526304_1526304 0.0331636
R25_28_30 n25_1526304_1601696 n25_1526304_1562784 0.035374499999999996
R25_28_31 n25_1526304_1641130 n25_1526304_1601696 0.0358491
R25_28_32 n25_1526304_1641290 n25_1526304_1641130 0.000145455
R25_29_0 n25_1564000_480880 n25_1564000_480720 0.000145455
R25_29_1 n25_1564000_502432 n25_1564000_480880 0.0195927
R25_29_2 n25_1564000_538912 n25_1564000_502432 0.0331636
R25_29_3 n25_1564000_577824 n25_1564000_538912 0.035374499999999996
R25_29_4 n25_1564000_614304 n25_1564000_577824 0.0331636
R25_29_5 n25_1564000_653216 n25_1564000_614304 0.035374499999999996
R25_29_6 n25_1564000_692128 n25_1564000_653216 0.035374499999999996
R25_29_7 n25_1564000_728608 n25_1564000_692128 0.0331636
R25_29_8 n25_1564000_767520 n25_1564000_728608 0.035374499999999996
R25_29_9 n25_1564000_804000 n25_1564000_767520 0.0331636
R25_29_10 n25_1564000_842912 n25_1564000_804000 0.035374499999999996
R25_29_11 n25_1564000_881824 n25_1564000_842912 0.035374499999999996
R25_29_12 n25_1564000_918304 n25_1564000_881824 0.0331636
R25_29_13 n25_1564000_957216 n25_1564000_918304 0.035374499999999996
R25_29_14 n25_1564000_993696 n25_1564000_957216 0.0331636
R25_29_15 n25_1564000_1032608 n25_1564000_993696 0.035374499999999996
R25_29_16 n25_1564000_1071520 n25_1564000_1032608 0.035374499999999996
R25_29_17 n25_1564000_1108000 n25_1564000_1071520 0.0331636
R25_29_18 n25_1564000_1146912 n25_1564000_1108000 0.035374499999999996
R25_29_19 n25_1564000_1183392 n25_1564000_1146912 0.0331636
R25_29_20 n25_1564000_1222304 n25_1564000_1183392 0.035374499999999996
R25_29_21 n25_1564000_1261216 n25_1564000_1222304 0.035374499999999996
R25_29_22 n25_1564000_1297696 n25_1564000_1261216 0.0331636
R25_29_23 n25_1564000_1336608 n25_1564000_1297696 0.035374499999999996
R25_29_24 n25_1564000_1373088 n25_1564000_1336608 0.0331636
R25_29_25 n25_1564000_1412000 n25_1564000_1373088 0.035374499999999996
R25_29_26 n25_1564000_1448480 n25_1564000_1412000 0.0331636
R25_29_27 n25_1564000_1487392 n25_1564000_1448480 0.035374499999999996
R25_29_28 n25_1564000_1526304 n25_1564000_1487392 0.035374499999999996
R25_29_29 n25_1564000_1562784 n25_1564000_1526304 0.0331636
R25_29_30 n25_1564000_1601696 n25_1564000_1562784 0.035374499999999996
R25_29_31 n25_1564000_1641130 n25_1564000_1601696 0.0358491
R25_29_32 n25_1564000_1641290 n25_1564000_1641130 0.000145455
R25_30_0 n25_1602912_480880 n25_1602912_480720 0.000145455
R25_30_1 n25_1602912_502432 n25_1602912_480880 0.0195927
R25_30_2 n25_1602912_538912 n25_1602912_502432 0.0331636
R25_30_3 n25_1602912_577824 n25_1602912_538912 0.035374499999999996
R25_30_4 n25_1602912_614304 n25_1602912_577824 0.0331636
R25_30_5 n25_1602912_653216 n25_1602912_614304 0.035374499999999996
R25_30_6 n25_1602912_692128 n25_1602912_653216 0.035374499999999996
R25_30_7 n25_1602912_728608 n25_1602912_692128 0.0331636
R25_30_8 n25_1602912_767520 n25_1602912_728608 0.035374499999999996
R25_30_9 n25_1602912_804000 n25_1602912_767520 0.0331636
R25_30_10 n25_1602912_842912 n25_1602912_804000 0.035374499999999996
R25_30_11 n25_1602912_881824 n25_1602912_842912 0.035374499999999996
R25_30_12 n25_1602912_918304 n25_1602912_881824 0.0331636
R25_30_13 n25_1602912_957216 n25_1602912_918304 0.035374499999999996
R25_30_14 n25_1602912_993696 n25_1602912_957216 0.0331636
R25_30_15 n25_1602912_1032608 n25_1602912_993696 0.035374499999999996
R25_30_16 n25_1602912_1071520 n25_1602912_1032608 0.035374499999999996
R25_30_17 n25_1602912_1108000 n25_1602912_1071520 0.0331636
R25_30_18 n25_1602912_1146912 n25_1602912_1108000 0.035374499999999996
R25_30_19 n25_1602912_1183392 n25_1602912_1146912 0.0331636
R25_30_20 n25_1602912_1222304 n25_1602912_1183392 0.035374499999999996
R25_30_21 n25_1602912_1261216 n25_1602912_1222304 0.035374499999999996
R25_30_22 n25_1602912_1297696 n25_1602912_1261216 0.0331636
R25_30_23 n25_1602912_1336608 n25_1602912_1297696 0.035374499999999996
R25_30_24 n25_1602912_1373088 n25_1602912_1336608 0.0331636
R25_30_25 n25_1602912_1412000 n25_1602912_1373088 0.035374499999999996
R25_30_26 n25_1602912_1448480 n25_1602912_1412000 0.0331636
R25_30_27 n25_1602912_1487392 n25_1602912_1448480 0.035374499999999996
R25_30_28 n25_1602912_1526304 n25_1602912_1487392 0.035374499999999996
R25_30_29 n25_1602912_1562784 n25_1602912_1526304 0.0331636
R25_30_30 n25_1602912_1601696 n25_1602912_1562784 0.035374499999999996
R25_30_31 n25_1602912_1641130 n25_1602912_1601696 0.0358491
R25_30_32 n25_1602912_1641290 n25_1602912_1641130 0.000145455
R25_31_0 n25_1641180_480880 n25_1641180_480720 7.272729999999999e-05
R25_31_1 n25_1641180_502432 n25_1641180_480880 0.00979636
R25_31_2 n25_1641180_538912 n25_1641180_502432 0.0165818
R25_31_3 n25_1641180_577824 n25_1641180_538912 0.0176873
R25_31_4 n25_1641180_614304 n25_1641180_577824 0.0165818
R25_31_5 n25_1641180_653216 n25_1641180_614304 0.0176873
R25_31_6 n25_1641180_692128 n25_1641180_653216 0.0176873
R25_31_7 n25_1641180_728608 n25_1641180_692128 0.0165818
R25_31_8 n25_1641180_767520 n25_1641180_728608 0.0176873
R25_31_9 n25_1641180_804000 n25_1641180_767520 0.0165818
R25_31_10 n25_1641180_842912 n25_1641180_804000 0.0176873
R25_31_11 n25_1641180_881824 n25_1641180_842912 0.0176873
R25_31_12 n25_1641180_918304 n25_1641180_881824 0.0165818
R25_31_13 n25_1641180_957216 n25_1641180_918304 0.0176873
R25_31_14 n25_1641180_993696 n25_1641180_957216 0.0165818
R25_31_15 n25_1641180_1032608 n25_1641180_993696 0.0176873
R25_31_16 n25_1641180_1071520 n25_1641180_1032608 0.0176873
R25_31_17 n25_1641180_1108000 n25_1641180_1071520 0.0165818
R25_31_18 n25_1641180_1146912 n25_1641180_1108000 0.0176873
R25_31_19 n25_1641180_1183392 n25_1641180_1146912 0.0165818
R25_31_20 n25_1641180_1222304 n25_1641180_1183392 0.0176873
R25_31_21 n25_1641180_1261216 n25_1641180_1222304 0.0176873
R25_31_22 n25_1641180_1297696 n25_1641180_1261216 0.0165818
R25_31_23 n25_1641180_1336608 n25_1641180_1297696 0.0176873
R25_31_24 n25_1641180_1373088 n25_1641180_1336608 0.0165818
R25_31_25 n25_1641180_1412000 n25_1641180_1373088 0.0176873
R25_31_26 n25_1641180_1448480 n25_1641180_1412000 0.0165818
R25_31_27 n25_1641180_1487392 n25_1641180_1448480 0.0176873
R25_31_28 n25_1641180_1526304 n25_1641180_1487392 0.0176873
R25_31_29 n25_1641180_1562784 n25_1641180_1526304 0.0165818
R25_31_30 n25_1641180_1601696 n25_1641180_1562784 0.0176873
R25_31_31 n25_1641180_1619905 n25_1641180_1601696 0.00827682
R25_31_32 n25_1641180_1641130 n25_1641180_1619905 0.009647729999999998
R25_31_33 n25_1641180_1641290 n25_1641180_1641130 7.272729999999999e-05
R41_0_0 n41_979937_1641130 n41_979937_1640970 2.8e-05
R41_0_1 n41_979937_1820000 n41_979937_1641130 0.0313023
R41_0_2 n41_979937_1825000 n41_979937_1820000 0.000875
R41_1_0 n41_1620161_300000 n41_1620161_295000 0.000875
R41_1_1 n41_1620161_480880 n41_1620161_300000 0.031654
R41_1_2 n41_1620161_481040 n41_1620161_480880 2.8e-05
iB00_0_v n1_295000_940095 0 -5.90468e-06
iB00_1_v n1_300000_940095 0 5.90468e-06
iB00_2_v n1_474796_940095 0 7.20366e-05
iB00_3_v n1_474906_940095 0 -2.14024e-17
iB00_4_v n1_474686_940095 0 -7.20366e-05
iB00_5_v n1_474796_918304 0 3.80265e-05
iB00_6_v n1_474796_957216 0 3.40101e-05
iB00_7_v n1_474796_993696 0 2.04716e-05
iB00_8_v n1_474686_957216 0 1.3538500000000001e-05
iB00_9_v n1_474906_957216 0 -1.3538500000000001e-05
iB00_10_v n1_493920_957216 0 1.3538500000000001e-05
iB00_11_v n1_532832_957216 0 7.68561e-06
iB00_12_v n1_493920_957296 0 -5.85286e-06
iB00_13_v n1_493920_957136 0 5.85286e-06
iB00_14_v n1_493920_918304 0 2.12006e-06
iB00_15_v n1_493920_993696 0 3.5026200000000003e-06
iB00_16_v n1_493920_1032608 0 4.1786999999999995e-06
iB00_17_v n1_493920_993776 0 -8.210850000000001e-07
iB00_18_v n1_493920_993616 0 8.210850000000001e-07
iB00_19_v n1_532832_993696 0 6.04522e-06
iB00_20_v n1_474686_993696 0 0.0
iB00_21_v n1_474906_993696 0 -6.8663e-06
iB00_22_v n1_474796_1032608 0 1.36053e-05
iB00_23_v n1_474796_1071520 0 9.51256e-06
iB00_24_v n1_474686_1032608 0 4.0927799999999995e-06
iB00_25_v n1_474906_1032608 0 -4.0927799999999995e-06
iB00_26_v n1_532832_1032608 0 4.47609e-06
iB00_27_v n1_493920_1032688 0 3.83315e-07
iB00_28_v n1_493920_1032528 0 -3.83315e-07
iB00_29_v n1_493920_1071520 0 3.50537e-06
iB00_30_v n1_493920_1108000 0 2.6443000000000002e-06
iB00_31_v n1_493920_1071600 0 5.71061e-07
iB00_32_v n1_493920_1071440 0 -5.71061e-07
iB00_33_v n1_532832_1071520 0 3.34163e-06
iB00_34_v n1_474686_1071520 0 0.0
iB00_35_v n1_474906_1071520 0 -2.77057e-06
iB00_36_v n1_474796_1108000 0 6.74199e-06
iB00_37_v n1_474796_1146912 0 4.69154e-06
iB00_38_v n1_474686_1108000 0 2.05046e-06
iB00_39_v n1_474906_1108000 0 -2.05046e-06
iB00_40_v n1_532832_1108000 0 2.58677e-06
iB00_41_v n1_493920_1108080 0 5.36314e-07
iB00_42_v n1_493920_1107920 0 -5.36314e-07
iB00_43_v n1_493920_1146912 0 1.89373e-06
iB00_44_v n1_493920_1183392 0 1.2595799999999998e-06
iB00_45_v n1_493920_1146992 0 4.67656e-07
iB00_46_v n1_493920_1146832 0 -4.67656e-07
iB00_47_v n1_532832_1146912 0 2.04031e-06
iB00_48_v n1_474686_1146912 0 0.0
iB00_49_v n1_474906_1146912 0 -1.57266e-06
iB00_50_v n1_474796_1183392 0 3.11888e-06
iB00_51_v n1_474796_1222304 0 1.84336e-06
iB00_52_v n1_474686_1183392 0 1.27552e-06
iB00_53_v n1_474906_1183392 0 -1.27552e-06
iB00_54_v n1_532832_1183392 0 1.5861499999999998e-06
iB00_55_v n1_493920_1183472 0 3.10627e-07
iB00_56_v n1_493920_1183312 0 -3.10627e-07
iB00_57_v n1_493920_1222304 0 6.58942e-07
iB00_58_v n1_493920_1261216 0 2.62091e-07
iB00_59_v n1_493920_1222384 0 2.51845e-07
iB00_60_v n1_493920_1222224 0 -2.51845e-07
iB00_61_v n1_532832_1222304 0 1.24965e-06
iB00_62_v n1_474686_1222304 0 0.0
iB00_63_v n1_474906_1222304 0 -9.97807e-07
iB00_64_v n1_474796_1261216 0 8.45552e-07
iB00_65_v n1_474796_1297696 0 1.7589699999999998e-08
iB00_66_v n1_474686_1261216 0 8.27963e-07
iB00_67_v n1_474906_1261216 0 -8.27963e-07
iB00_68_v n1_532832_1261216 0 9.499439999999999e-07
iB00_69_v n1_493920_1261296 0 1.2198099999999999e-07
iB00_70_v n1_493920_1261136 0 -1.2198099999999999e-07
iB00_71_v n1_493920_1297696 0 -1.4990300000000002e-07
iB00_72_v n1_493920_1336608 0 -4.7454700000000005e-07
iB00_73_v n1_493920_1297776 0 5.50029e-08
iB00_74_v n1_493920_1297616 0 -5.50029e-08
iB00_75_v n1_532832_1297696 0 7.257060000000001e-07
iB00_76_v n1_474686_1297696 0 0.0
iB00_77_v n1_474906_1297696 0 -6.707030000000001e-07
iB00_78_v n1_474796_1336608 0 -6.53114e-07
iB00_79_v n1_474796_1373088 0 -1.16739e-06
iB00_80_v n1_474686_1336608 0 5.142779999999999e-07
iB00_81_v n1_474906_1336608 0 -5.142779999999999e-07
iB00_82_v n1_532832_1336608 0 4.93988e-07
iB00_83_v n1_493920_1336688 0 -2.02904e-08
iB00_84_v n1_493920_1336528 0 2.02904e-08
iB00_85_v n1_493920_1373088 0 -7.252470000000001e-07
iB00_86_v n1_493920_1412000 0 -9.1869e-07
iB00_87_v n1_493920_1373168 0 -1.01185e-07
iB00_88_v n1_493920_1373008 0 1.01185e-07
iB00_89_v n1_532832_1373088 0 2.72826e-07
iB00_90_v n1_474686_1373088 0 0.0
iB00_91_v n1_474906_1373088 0 -3.7401099999999997e-07
iB00_92_v n1_474796_1412000 0 -1.5414e-06
iB00_93_v n1_474796_1448480 0 -1.75899e-06
iB00_94_v n1_474686_1412000 0 2.17588e-07
iB00_95_v n1_474906_1412000 0 -2.17588e-07
iB00_96_v n1_532832_1412000 0 7.69573e-08
iB00_97_v n1_493920_1412080 0 -1.40631e-07
iB00_98_v n1_493920_1411920 0 1.40631e-07
iB00_99_v n1_493920_1448480 0 -9.72913e-07
iB00_100_v n1_493920_1487392 0 -1.05141e-06
iB00_101_v n1_493920_1448560 0 -2.11513e-07
iB00_102_v n1_493920_1448400 0 2.11513e-07
iB00_103_v n1_532832_1448480 0 -8.64965e-08
iB00_104_v n1_474686_1448480 0 0.0
iB00_105_v n1_474906_1448480 0 -1.25016e-07
iB00_106_v n1_474796_1487392 0 -1.88401e-06
iB00_107_v n1_474796_1526304 0 -1.89337e-06
iB00_108_v n1_474686_1487392 0 9.36924e-09
iB00_109_v n1_474906_1487392 0 -9.36924e-09
iB00_110_v n1_532832_1487392 0 -2.2916e-07
iB00_111_v n1_493920_1487472 0 -2.3853e-07
iB00_112_v n1_493920_1487312 0 2.3853e-07
iB00_113_v n1_493920_1526304 0 -1.07062e-06
iB00_114_v n1_493920_1562784 0 -9.69911e-07
iB00_115_v n1_493920_1526384 0 -2.6102299999999997e-07
iB00_116_v n1_493920_1526224 0 2.6102299999999997e-07
iB00_117_v n1_532832_1526304 0 -3.8264800000000005e-07
iB00_118_v n1_474686_1526304 0 0.0
iB00_119_v n1_474906_1526304 0 1.21624e-07
iB00_120_v n1_474796_1562784 0 -1.77175e-06
iB00_121_v n1_474796_1601696 0 -1.56685e-06
iB00_122_v n1_474686_1562784 0 -2.0489900000000001e-07
iB00_123_v n1_474906_1562784 0 2.0489900000000001e-07
iB00_124_v n1_532832_1562784 0 -5.11362e-07
iB00_125_v n1_493920_1562864 0 -3.06464e-07
iB00_126_v n1_493920_1562704 0 3.06464e-07
iB00_127_v n1_493920_1601696 0 -9.5346e-07
iB00_128_v n1_493920_1641130 0 -7.83883e-07
iB00_129_v n1_493920_1601776 0 -3.14584e-07
iB00_130_v n1_493920_1601616 0 3.14584e-07
iB00_131_v n1_532832_1601696 0 -6.99207e-07
iB00_132_v n1_474686_1601696 0 0.0
iB00_133_v n1_474906_1601696 0 3.84624e-07
iB00_134_v n1_474796_1641130 0 -1.18223e-06
iB00_135_v n1_474796_1641290 0 -4.77049e-17
iB00_136_v n1_474796_1640970 0 1.18223e-06
iB00_137_v n1_474686_1641130 0 0.0
iB00_138_v n1_532832_1641130 0 -1.96611e-06
iB00_139_v n1_493920_1641290 0 -7.83883e-07
iB00_140_v n1_493920_1640970 0 7.83883e-07
iB00_141_v n1_570528_1641130 0 -3.2891700000000002e-06
iB00_142_v n1_532832_1641290 0 -1.32306e-06
iB00_143_v n1_532832_1640970 0 1.32306e-06
iB00_144_v n1_532832_1601776 0 -7.91313e-07
iB00_145_v n1_532832_1601616 0 7.91313e-07
iB00_146_v n1_570528_1601696 0 -1.4905199999999999e-06
iB00_147_v n1_609440_1601696 0 -2.27822e-06
iB00_148_v n1_570528_1601776 0 -7.87704e-07
iB00_149_v n1_570528_1601616 0 7.87704e-07
iB00_150_v n1_570528_1562784 0 1.70732e-06
iB00_151_v n1_570528_1641290 0 -2.38524e-17
iB00_152_v n1_570528_1640970 0 1.60656e-06
iB00_153_v n1_609440_1641130 0 -4.89572e-06
iB00_154_v n1_647136_1641130 0 -6.8245099999999995e-06
iB00_155_v n1_609440_1641290 0 -1.9287900000000002e-06
iB00_156_v n1_609440_1640970 0 1.9287900000000002e-06
iB00_157_v n1_609440_1562784 0 2.08536e-06
iB00_158_v n1_609440_1601776 0 -9.47534e-07
iB00_159_v n1_609440_1601616 0 9.47534e-07
iB00_160_v n1_647136_1601696 0 -3.22576e-06
iB00_161_v n1_686048_1601696 0 -4.308979999999999e-06
iB00_162_v n1_647136_1601776 0 -1.08322e-06
iB00_163_v n1_647136_1601616 0 1.08322e-06
iB00_164_v n1_647136_1562784 0 2.67442e-06
iB00_165_v n1_647136_1641290 0 -2.38524e-17
iB00_166_v n1_647136_1640970 0 2.27197e-06
iB00_167_v n1_686048_1641130 0 -9.096470000000001e-06
iB00_168_v n1_723744_1641130 0 -1.1822900000000002e-05
iB00_169_v n1_686048_1641290 0 -2.72645e-06
iB00_170_v n1_686048_1640970 0 2.72645e-06
iB00_171_v n1_686048_1562784 0 3.1963299999999998e-06
iB00_172_v n1_686048_1601776 0 -1.26167e-06
iB00_173_v n1_686048_1601616 0 1.26167e-06
iB00_174_v n1_723744_1601696 0 -5.57064e-06
iB00_175_v n1_761440_1601696 0 -7.1601499999999995e-06
iB00_176_v n1_723744_1601776 0 -1.5895099999999998e-06
iB00_177_v n1_723744_1601616 0 1.5895099999999998e-06
iB00_178_v n1_723744_1562784 0 4.0009e-06
iB00_179_v n1_723744_1641290 0 -2.38524e-17
iB00_180_v n1_723744_1640970 0 3.3536e-06
iB00_181_v n1_761440_1641130 0 -1.5176500000000001e-05
iB00_182_v n1_800352_1641130 0 -1.93179e-05
iB00_183_v n1_761440_1641290 0 -4.1414e-06
iB00_184_v n1_761440_1640970 0 4.1414e-06
iB00_185_v n1_761440_1562784 0 5.22098e-06
iB00_186_v n1_761440_1601776 0 -1.73219e-06
iB00_187_v n1_761440_1601616 0 1.73219e-06
iB00_188_v n1_800352_1601696 0 -8.89234e-06
iB00_189_v n1_838048_1601696 0 -1.11747e-05
iB00_190_v n1_800352_1601776 0 -2.28235e-06
iB00_191_v n1_800352_1601616 0 2.28235e-06
iB00_192_v n1_800352_1562784 0 7.15122e-06
iB00_193_v n1_800352_1641290 0 -2.38524e-17
iB00_194_v n1_800352_1640970 0 5.5976e-06
iB00_195_v n1_838048_1641130 0 -2.49155e-05
iB00_196_v n1_876960_1641130 0 -3.2874100000000004e-05
iB00_197_v n1_838048_1641290 0 -7.958629999999999e-06
iB00_198_v n1_838048_1640970 0 7.958629999999999e-06
iB00_199_v n1_838048_1562784 0 9.99304e-06
iB00_200_v n1_838048_1601776 0 -2.8069599999999997e-06
iB00_201_v n1_838048_1601616 0 2.8069599999999997e-06
iB00_202_v n1_876960_1601696 0 -1.39817e-05
iB00_203_v n1_914656_1601696 0 -1.72182e-05
iB00_204_v n1_876960_1601776 0 -3.23652e-06
iB00_205_v n1_876960_1601616 0 3.23652e-06
iB00_206_v n1_876960_1562784 0 1.5075099999999999e-05
iB00_207_v n1_876960_1641290 0 -1.19262e-17
iB00_208_v n1_876960_1640970 0 1.26227e-05
iB00_209_v n1_914656_1641130 0 -4.54969e-05
iB00_210_v n1_952352_1641130 0 -6.82961e-05
iB00_211_v n1_914656_1641290 0 -2.27993e-05
iB00_212_v n1_914656_1640970 0 2.27993e-05
iB00_213_v n1_914656_1562784 0 2.3971200000000002e-05
iB00_214_v n1_914656_1601776 0 -1.93786e-06
iB00_215_v n1_914656_1601616 0 1.93786e-06
iB00_216_v n1_952352_1601696 0 -1.9156099999999998e-05
iB00_217_v n1_991264_1601696 0 -7.949909999999999e-06
iB00_218_v n1_952352_1601776 0 1.12061e-05
iB00_219_v n1_952352_1601616 0 -1.12061e-05
iB00_220_v n1_952352_1562784 0 3.84446e-05
iB00_221_v n1_952352_1641290 0 -1.19262e-17
iB00_222_v n1_952352_1640970 0 5.03869e-05
iB00_223_v n1_979937_1641130 0 -0.000118683
iB00_224_v n1_991264_1641130 0 0.00015373800000000002
iB00_225_v n1_979937_1641290 0 -0.000272421
iB00_226_v n1_979937_1640970 0 0.000272421
iB00_227_v n1_979937_1820000 0 -0.000272421
iB00_228_v n1_979937_1825000 0 -0.00016361700000000002
iB00_229_v n1_1028960_1641130 0 8.10476e-05
iB00_230_v n1_991264_1641290 0 -7.26905e-05
iB00_231_v n1_991264_1640970 0 7.26905e-05
iB00_232_v n1_991264_1562784 0 4.63596e-05
iB00_233_v n1_991264_1601776 0 2.54492e-05
iB00_234_v n1_991264_1601616 0 -2.54492e-05
iB00_235_v n1_1028960_1601696 0 1.74992e-05
iB00_236_v n1_1067872_1601696 0 1.75657e-05
iB00_237_v n1_1028960_1601776 0 6.64744e-08
iB00_238_v n1_1028960_1601616 0 -6.64744e-08
iB00_239_v n1_1028960_1562784 0 2.9599e-05
iB00_240_v n1_1028960_1641290 0 -1.19262e-17
iB00_241_v n1_1028960_1640970 0 3.0321799999999998e-05
iB00_242_v n1_1067872_1641130 0 5.07258e-05
iB00_243_v n1_1105568_1641130 0 3.5215e-05
iB00_244_v n1_1067872_1641290 0 -1.55109e-05
iB00_245_v n1_1067872_1640970 0 1.55109e-05
iB00_246_v n1_1067872_1562784 0 1.81812e-05
iB00_247_v n1_1067872_1601776 0 -3.24437e-06
iB00_248_v n1_1067872_1601616 0 3.24437e-06
iB00_249_v n1_1105568_1601696 0 1.43213e-05
iB00_250_v n1_1144480_1601696 0 1.12706e-05
iB00_251_v n1_1105568_1601776 0 -3.0507e-06
iB00_252_v n1_1105568_1601616 0 3.0507e-06
iB00_253_v n1_1105568_1562784 0 1.19501e-05
iB00_254_v n1_1105568_1641290 0 -2.38524e-17
iB00_255_v n1_1105568_1640970 0 9.46386e-06
iB00_256_v n1_1144480_1641130 0 2.5751099999999998e-05
iB00_257_v n1_1182176_1641130 0 1.93358e-05
iB00_258_v n1_1144480_1641290 0 -6.415330000000001e-06
iB00_259_v n1_1144480_1640970 0 6.415330000000001e-06
iB00_260_v n1_1144480_1562784 0 8.302530000000001e-06
iB00_261_v n1_1144480_1601776 0 -2.48382e-06
iB00_262_v n1_1144480_1601616 0 2.48382e-06
iB00_263_v n1_1182176_1601696 0 8.78683e-06
iB00_264_v n1_1219872_1601696 0 6.7784e-06
iB00_265_v n1_1182176_1601776 0 -2.0084299999999997e-06
iB00_266_v n1_1182176_1601616 0 2.0084299999999997e-06
iB00_267_v n1_1182176_1562784 0 6.28309e-06
iB00_268_v n1_1182176_1641290 0 -2.38524e-17
iB00_269_v n1_1182176_1640970 0 4.79405e-06
iB00_270_v n1_1219872_1641130 0 1.45417e-05
iB00_271_v n1_1258784_1641130 0 1.06539e-05
iB00_272_v n1_1219872_1641290 0 -3.88784e-06
iB00_273_v n1_1219872_1640970 0 3.88784e-06
iB00_274_v n1_1219872_1562784 0 5.00017e-06
iB00_275_v n1_1219872_1601776 0 -1.7701399999999998e-06
iB00_276_v n1_1219872_1601616 0 1.7701399999999998e-06
iB00_277_v n1_1258784_1601696 0 5.00826e-06
iB00_278_v n1_1296480_1601696 0 3.4759e-06
iB00_279_v n1_1258784_1601776 0 -1.5323599999999999e-06
iB00_280_v n1_1258784_1601616 0 1.5323599999999999e-06
iB00_281_v n1_1258784_1562784 0 4.12454e-06
iB00_282_v n1_1258784_1641290 0 -2.38524e-17
iB00_283_v n1_1258784_1640970 0 3.28249e-06
iB00_284_v n1_1296480_1641130 0 7.37139e-06
iB00_285_v n1_1335392_1641130 0 4.47495e-06
iB00_286_v n1_1296480_1641290 0 -2.89644e-06
iB00_287_v n1_1296480_1640970 0 2.89644e-06
iB00_288_v n1_1296480_1562784 0 3.54697e-06
iB00_289_v n1_1296480_1601776 0 -1.38812e-06
iB00_290_v n1_1296480_1601616 0 1.38812e-06
iB00_291_v n1_1335392_1601696 0 2.08778e-06
iB00_292_v n1_1373088_1601696 0 8.77628e-07
iB00_293_v n1_1335392_1601776 0 -1.21015e-06
iB00_294_v n1_1335392_1601616 0 1.21015e-06
iB00_295_v n1_1335392_1562784 0 3.1680100000000003e-06
iB00_296_v n1_1335392_1641290 0 -2.38524e-17
iB00_297_v n1_1335392_1640970 0 2.61209e-06
iB00_298_v n1_1373088_1641130 0 1.86286e-06
iB00_299_v n1_1412000_1641130 0 -6.50231e-07
iB00_300_v n1_1373088_1641290 0 -2.51309e-06
iB00_301_v n1_1373088_1640970 0 2.51309e-06
iB00_302_v n1_1373088_1562784 0 2.95844e-06
iB00_303_v n1_1373088_1601776 0 -1.23135e-06
iB00_304_v n1_1373088_1601616 0 1.23135e-06
iB00_305_v n1_1412000_1601696 0 -3.53717e-07
iB00_306_v n1_1449696_1601696 0 -1.49356e-06
iB00_307_v n1_1412000_1601776 0 -1.1398400000000001e-06
iB00_308_v n1_1412000_1601616 0 1.1398400000000001e-06
iB00_309_v n1_1412000_1562784 0 2.89447e-06
iB00_310_v n1_1412000_1641290 0 -2.38524e-17
iB00_311_v n1_1412000_1640970 0 2.45876e-06
iB00_312_v n1_1449696_1641130 0 -3.10899e-06
iB00_313_v n1_1487392_1641130 0 -5.67989e-06
iB00_314_v n1_1449696_1641290 0 -2.5709000000000002e-06
iB00_315_v n1_1449696_1640970 0 2.5709000000000002e-06
iB00_316_v n1_1449696_1562784 0 3.0232200000000003e-06
iB00_317_v n1_1449696_1601776 0 -1.2363700000000002e-06
iB00_318_v n1_1449696_1601616 0 1.2363700000000002e-06
iB00_319_v n1_1487392_1601696 0 -2.72992e-06
iB00_320_v n1_1526304_1601696 0 -4.01985e-06
iB00_321_v n1_1487392_1601776 0 -1.28993e-06
iB00_322_v n1_1487392_1601616 0 1.28993e-06
iB00_323_v n1_1487392_1562784 0 3.36951e-06
iB00_324_v n1_1487392_1641290 0 -2.38524e-17
iB00_325_v n1_1487392_1640970 0 2.7733599999999997e-06
iB00_326_v n1_1526304_1641130 0 -8.45325e-06
iB00_327_v n1_1564000_1641130 0 -1.1619400000000001e-05
iB00_328_v n1_1526304_1641290 0 -3.16613e-06
iB00_329_v n1_1526304_1640970 0 3.16613e-06
iB00_330_v n1_1526304_1562784 0 4.00772e-06
iB00_331_v n1_1526304_1601776 0 -1.3886199999999998e-06
iB00_332_v n1_1526304_1601616 0 1.3886199999999998e-06
iB00_333_v n1_1564000_1601696 0 -5.40847e-06
iB00_334_v n1_1602912_1601696 0 -7.26194e-06
iB00_335_v n1_1564000_1601776 0 -1.8534700000000001e-06
iB00_336_v n1_1564000_1601616 0 1.8534700000000001e-06
iB00_337_v n1_1564000_1562784 0 5.1061300000000005e-06
iB00_338_v n1_1564000_1641290 0 -2.38524e-17
iB00_339_v n1_1564000_1640970 0 3.9044499999999995e-06
iB00_340_v n1_1602912_1641130 0 -1.5523800000000002e-05
iB00_341_v n1_1641180_1641130 0 -2.0378e-05
iB00_342_v n1_1602912_1641290 0 -4.85417e-06
iB00_343_v n1_1602912_1640970 0 4.85417e-06
iB00_344_v n1_1602912_1562784 0 7.63551e-06
iB00_345_v n1_1602912_1601776 0 -3.4127699999999998e-06
iB00_346_v n1_1602912_1601616 0 3.4127699999999998e-06
iB00_347_v n1_1641180_1601696 0 -1.0674700000000001e-05
iB00_348_v n1_1641290_1601696 0 0.0
iB00_349_v n1_1641070_1601696 0 1.0674700000000001e-05
iB00_350_v n1_1641180_1562784 0 3.01733e-05
iB00_351_v n1_1641180_1619905 0 -4.0848e-05
iB00_352_v n1_1641070_1619905 0 -6.1226e-05
iB00_353_v n1_1641290_1619905 0 6.1226e-05
iB00_354_v n1_1820088_1619905 0 -6.1226e-05
iB00_355_v n1_1825088_1619905 0 -5.01856e-06
iB00_356_v n1_1641180_1641290 0 -4.77049e-17
iB00_357_v n1_1641180_1640970 0 -2.0378e-05
iB00_358_v n1_1641290_1641130 0 0.0
iB00_359_v n1_1641180_1526304 0 2.34344e-05
iB00_360_v n1_1641070_1562784 0 6.7388600000000006e-06
iB00_361_v n1_1641290_1562784 0 -6.7388600000000006e-06
iB00_362_v n1_1602912_1562864 0 -7.908820000000001e-07
iB00_363_v n1_1602912_1562704 0 7.908820000000001e-07
iB00_364_v n1_1602912_1526304 0 7.81346e-06
iB00_365_v n1_1602912_1487392 0 7.16623e-06
iB00_366_v n1_1602912_1526384 0 6.89563e-08
iB00_367_v n1_1602912_1526224 0 -6.89563e-08
iB00_368_v n1_1564000_1526304 0 4.87464e-06
iB00_369_v n1_1526304_1526304 0 4.21751e-06
iB00_370_v n1_1564000_1526384 0 -6.57136e-07
iB00_371_v n1_1564000_1526224 0 6.57136e-07
iB00_372_v n1_1564000_1487392 0 5.48068e-06
iB00_373_v n1_1564000_1562864 0 -1.12852e-06
iB00_374_v n1_1564000_1562704 0 1.12852e-06
iB00_375_v n1_1526304_1562864 0 -1.13115e-06
iB00_376_v n1_1526304_1562704 0 1.13115e-06
iB00_377_v n1_1526304_1487392 0 4.4536e-06
iB00_378_v n1_1526304_1526384 0 -8.743130000000001e-07
iB00_379_v n1_1526304_1526224 0 8.743130000000001e-07
iB00_380_v n1_1487392_1526304 0 3.3432e-06
iB00_381_v n1_1449696_1526304 0 2.39386e-06
iB00_382_v n1_1487392_1526384 0 -9.49332e-07
iB00_383_v n1_1487392_1526224 0 9.49332e-07
iB00_384_v n1_1487392_1487392 0 3.79187e-06
iB00_385_v n1_1487392_1562864 0 -1.14408e-06
iB00_386_v n1_1487392_1562704 0 1.14408e-06
iB00_387_v n1_1449696_1562864 0 -1.1197100000000001e-06
iB00_388_v n1_1449696_1562704 0 1.1197100000000001e-06
iB00_389_v n1_1449696_1487392 0 3.39493e-06
iB00_390_v n1_1449696_1526384 0 -1.06592e-06
iB00_391_v n1_1449696_1526224 0 1.06592e-06
iB00_392_v n1_1412000_1526304 0 1.3279399999999999e-06
iB00_393_v n1_1373088_1526304 0 3.94396e-07
iB00_394_v n1_1412000_1526384 0 -9.33542e-07
iB00_395_v n1_1412000_1526224 0 9.33542e-07
iB00_396_v n1_1412000_1487392 0 3.22661e-06
iB00_397_v n1_1412000_1562864 0 -1.03757e-06
iB00_398_v n1_1412000_1562704 0 1.03757e-06
iB00_399_v n1_1373088_1562864 0 -1.1522e-06
iB00_400_v n1_1373088_1562704 0 1.1522e-06
iB00_401_v n1_1373088_1487392 0 3.40925e-06
iB00_402_v n1_1373088_1526384 0 -9.81067e-07
iB00_403_v n1_1373088_1526224 0 9.81067e-07
iB00_404_v n1_1335392_1526304 0 -5.866699999999999e-07
iB00_405_v n1_1296480_1526304 0 -1.70406e-06
iB00_406_v n1_1335392_1526384 0 -1.11739e-06
iB00_407_v n1_1335392_1526224 0 1.11739e-06
iB00_408_v n1_1335392_1487392 0 3.62146e-06
iB00_409_v n1_1335392_1562864 0 -1.12568e-06
iB00_410_v n1_1335392_1562704 0 1.12568e-06
iB00_411_v n1_1296480_1562864 0 -1.27527e-06
iB00_412_v n1_1296480_1562704 0 1.27527e-06
iB00_413_v n1_1296480_1487392 0 4.062890000000001e-06
iB00_414_v n1_1296480_1526384 0 -1.1324e-06
iB00_415_v n1_1296480_1526224 0 1.1324e-06
iB00_416_v n1_1258784_1526304 0 -2.8364499999999998e-06
iB00_417_v n1_1219872_1526304 0 -4.06815e-06
iB00_418_v n1_1258784_1526384 0 -1.2317e-06
iB00_419_v n1_1258784_1526224 0 1.2317e-06
iB00_420_v n1_1258784_1487392 0 4.85138e-06
iB00_421_v n1_1258784_1562864 0 -1.3872e-06
iB00_422_v n1_1258784_1562704 0 1.3872e-06
iB00_423_v n1_1219872_1562864 0 -1.53706e-06
iB00_424_v n1_1219872_1562704 0 1.53706e-06
iB00_425_v n1_1219872_1487392 0 5.93646e-06
iB00_426_v n1_1219872_1526384 0 -1.25557e-06
iB00_427_v n1_1219872_1526224 0 1.25557e-06
iB00_428_v n1_1182176_1526304 0 -5.32372e-06
iB00_429_v n1_1144480_1526304 0 -6.64948e-06
iB00_430_v n1_1182176_1526384 0 -1.32576e-06
iB00_431_v n1_1182176_1526224 0 1.32576e-06
iB00_432_v n1_1182176_1487392 0 7.57236e-06
iB00_433_v n1_1182176_1562864 0 -1.61348e-06
iB00_434_v n1_1182176_1562704 0 1.61348e-06
iB00_435_v n1_1144480_1562864 0 -1.6718900000000002e-06
iB00_436_v n1_1144480_1562704 0 1.6718900000000002e-06
iB00_437_v n1_1144480_1487392 0 9.64246e-06
iB00_438_v n1_1144480_1526384 0 -1.01706e-06
iB00_439_v n1_1144480_1526224 0 1.01706e-06
iB00_440_v n1_1105568_1526304 0 -7.66654e-06
iB00_441_v n1_1067872_1526304 0 -8.350700000000001e-06
iB00_442_v n1_1105568_1526384 0 -6.841539999999999e-07
iB00_443_v n1_1105568_1526224 0 6.841539999999999e-07
iB00_444_v n1_1105568_1487392 0 1.27607e-05
iB00_445_v n1_1105568_1562864 0 -1.60418e-06
iB00_446_v n1_1105568_1562704 0 1.60418e-06
iB00_447_v n1_1067872_1562864 0 -6.54412e-07
iB00_448_v n1_1067872_1562704 0 6.54412e-07
iB00_449_v n1_1067872_1487392 0 1.68938e-05
iB00_450_v n1_1067872_1526384 0 4.77173e-07
iB00_451_v n1_1067872_1526224 0 -4.77173e-07
iB00_452_v n1_1028960_1526304 0 -7.87352e-06
iB00_453_v n1_991264_1526304 0 -4.7160400000000005e-06
iB00_454_v n1_1028960_1526384 0 3.1574799999999997e-06
iB00_455_v n1_1028960_1526224 0 -3.1574799999999997e-06
iB00_456_v n1_1028960_1487392 0 2.18926e-05
iB00_457_v n1_1028960_1562864 0 3.12287e-06
iB00_458_v n1_1028960_1562704 0 -3.12287e-06
iB00_459_v n1_991264_1562864 0 1.23497e-05
iB00_460_v n1_991264_1562704 0 -1.23497e-05
iB00_461_v n1_991264_1487392 0 2.5641e-05
iB00_462_v n1_991264_1526384 0 7.002099999999999e-06
iB00_463_v n1_991264_1526224 0 -7.002099999999999e-06
iB00_464_v n1_952352_1526304 0 2.28605e-06
iB00_465_v n1_914656_1526304 0 7.38934e-06
iB00_466_v n1_952352_1526384 0 5.10329e-06
iB00_467_v n1_952352_1526224 0 -5.10329e-06
iB00_468_v n1_952352_1487392 0 2.41876e-05
iB00_469_v n1_952352_1562864 0 7.5566799999999995e-06
iB00_470_v n1_952352_1562704 0 -7.5566799999999995e-06
iB00_471_v n1_914656_1562864 0 1.05292e-06
iB00_472_v n1_914656_1562704 0 -1.05292e-06
iB00_473_v n1_914656_1487392 0 1.96728e-05
iB00_474_v n1_914656_1526384 0 1.80288e-06
iB00_475_v n1_914656_1526224 0 -1.80288e-06
iB00_476_v n1_876960_1526304 0 9.19222e-06
iB00_477_v n1_838048_1526304 0 9.09508e-06
iB00_478_v n1_876960_1526384 0 -9.71383e-08
iB00_479_v n1_876960_1526224 0 9.71383e-08
iB00_480_v n1_876960_1487392 0 1.51354e-05
iB00_481_v n1_876960_1562864 0 -1.10618e-06
iB00_482_v n1_876960_1562704 0 1.10618e-06
iB00_483_v n1_838048_1562864 0 -1.6908e-06
iB00_484_v n1_838048_1562704 0 1.6908e-06
iB00_485_v n1_838048_1487392 0 1.1366599999999999e-05
iB00_486_v n1_838048_1526384 0 -9.205440000000001e-07
iB00_487_v n1_838048_1526224 0 9.205440000000001e-07
iB00_488_v n1_800352_1526304 0 8.174539999999999e-06
iB00_489_v n1_761440_1526304 0 6.9024999999999996e-06
iB00_490_v n1_800352_1526384 0 -1.2720400000000001e-06
iB00_491_v n1_800352_1526224 0 1.2720400000000001e-06
iB00_492_v n1_800352_1487392 0 8.515760000000001e-06
iB00_493_v n1_800352_1562864 0 -1.76119e-06
iB00_494_v n1_800352_1562704 0 1.76119e-06
iB00_495_v n1_761440_1562864 0 -1.38372e-06
iB00_496_v n1_761440_1562704 0 1.38372e-06
iB00_497_v n1_761440_1487392 0 6.47752e-06
iB00_498_v n1_761440_1526384 0 -1.1463199999999999e-06
iB00_499_v n1_761440_1526224 0 1.1463199999999999e-06
iB00_500_v n1_723744_1526304 0 5.7561799999999995e-06
iB00_501_v n1_686048_1526304 0 4.671340000000001e-06
iB00_502_v n1_723744_1526384 0 -1.08483e-06
iB00_503_v n1_723744_1526224 0 1.08483e-06
iB00_504_v n1_723744_1487392 0 4.9492e-06
iB00_505_v n1_723744_1562864 0 -1.3667e-06
iB00_506_v n1_723744_1562704 0 1.3667e-06
iB00_507_v n1_686048_1562864 0 -1.10134e-06
iB00_508_v n1_686048_1562704 0 1.10134e-06
iB00_509_v n1_686048_1487392 0 3.84239e-06
iB00_510_v n1_686048_1526384 0 -1.0530599999999999e-06
iB00_511_v n1_686048_1526224 0 1.0530599999999999e-06
iB00_512_v n1_647136_1526304 0 3.61828e-06
iB00_513_v n1_609440_1526304 0 2.6299e-06
iB00_514_v n1_647136_1526384 0 -9.8838e-07
iB00_515_v n1_647136_1526224 0 9.8838e-07
iB00_516_v n1_647136_1487392 0 2.9850800000000003e-06
iB00_517_v n1_647136_1562864 0 -1.12798e-06
iB00_518_v n1_647136_1562704 0 1.12798e-06
iB00_519_v n1_609440_1562864 0 -8.28044e-07
iB00_520_v n1_609440_1562704 0 8.28044e-07
iB00_521_v n1_609440_1487392 0 2.3301300000000003e-06
iB00_522_v n1_609440_1526384 0 -7.74522e-07
iB00_523_v n1_609440_1526224 0 7.74522e-07
iB00_524_v n1_570528_1526304 0 1.85538e-06
iB00_525_v n1_570528_1526384 0 -8.30039e-07
iB00_526_v n1_570528_1526224 0 8.30039e-07
iB00_527_v n1_570528_1487392 0 1.6939200000000001e-06
iB00_528_v n1_570528_1562864 0 -8.01664e-07
iB00_529_v n1_570528_1562704 0 8.01664e-07
iB00_530_v n1_532832_1562864 0 -7.68813e-07
iB00_531_v n1_532832_1562704 0 7.68813e-07
iB00_532_v n1_532832_1526384 0 -6.42692e-07
iB00_533_v n1_532832_1526224 0 6.42692e-07
iB00_534_v n1_532832_1487472 0 -6.2038e-07
iB00_535_v n1_532832_1487312 0 6.2038e-07
iB00_536_v n1_570528_1487472 0 -6.75337e-07
iB00_537_v n1_570528_1487312 0 6.75337e-07
iB00_538_v n1_570528_1448480 0 1.82436e-06
iB00_539_v n1_570528_1412000 0 1.7801e-06
iB00_540_v n1_570528_1448560 0 -6.356349999999999e-07
iB00_541_v n1_570528_1448400 0 6.356349999999999e-07
iB00_542_v n1_609440_1448480 0 -1.21796e-06
iB00_543_v n1_532832_1448560 0 -4.95826e-07
iB00_544_v n1_532832_1448400 0 4.95826e-07
iB00_545_v n1_532832_1412080 0 -4.22216e-07
iB00_546_v n1_532832_1411920 0 4.22216e-07
iB00_547_v n1_609440_1412000 0 -9.17207e-07
iB00_548_v n1_570528_1412080 0 -5.719479999999999e-07
iB00_549_v n1_570528_1411920 0 5.719479999999999e-07
iB00_550_v n1_570528_1373088 0 1.69718e-06
iB00_551_v n1_570528_1336608 0 1.68889e-06
iB00_552_v n1_570528_1373168 0 -4.5206800000000005e-07
iB00_553_v n1_570528_1373008 0 4.5206800000000005e-07
iB00_554_v n1_609440_1373088 0 -5.820600000000001e-07
iB00_555_v n1_532832_1373168 0 -4.02818e-07
iB00_556_v n1_532832_1373008 0 4.02818e-07
iB00_557_v n1_532832_1336688 0 -3.67829e-07
iB00_558_v n1_532832_1336528 0 3.67829e-07
iB00_559_v n1_609440_1336608 0 -3.39843e-07
iB00_560_v n1_570528_1336688 0 -4.66003e-07
iB00_561_v n1_570528_1336528 0 4.66003e-07
iB00_562_v n1_570528_1297696 0 1.4194e-06
iB00_563_v n1_570528_1261216 0 1.18106e-06
iB00_564_v n1_570528_1297776 0 -3.99658e-07
iB00_565_v n1_570528_1297616 0 3.99658e-07
iB00_566_v n1_609440_1297696 0 -6.02579e-09
iB00_567_v n1_532832_1297776 0 -3.3207400000000004e-07
iB00_568_v n1_532832_1297616 0 3.3207400000000004e-07
iB00_569_v n1_532832_1261296 0 -2.69398e-07
iB00_570_v n1_532832_1261136 0 2.69398e-07
iB00_571_v n1_609440_1261216 0 3.33628e-07
iB00_572_v n1_570528_1261296 0 -3.46918e-07
iB00_573_v n1_570528_1261136 0 3.46918e-07
iB00_574_v n1_570528_1222304 0 1.0075800000000002e-06
iB00_575_v n1_570528_1183392 0 6.81318e-07
iB00_576_v n1_570528_1222384 0 -3.74108e-07
iB00_577_v n1_570528_1222224 0 3.74108e-07
iB00_578_v n1_609440_1222304 0 6.77911e-07
iB00_579_v n1_532832_1222384 0 -1.97634e-07
iB00_580_v n1_532832_1222224 0 1.97634e-07
iB00_581_v n1_532832_1183472 0 -1.62781e-07
iB00_582_v n1_532832_1183312 0 1.62781e-07
iB00_583_v n1_609440_1183392 0 1.1128e-06
iB00_584_v n1_570528_1183472 0 -3.10567e-07
iB00_585_v n1_570528_1183312 0 3.10567e-07
iB00_586_v n1_570528_1146912 0 4.88218e-07
iB00_587_v n1_570528_1108000 0 2.43515e-07
iB00_588_v n1_570528_1146992 0 -3.2414e-07
iB00_589_v n1_570528_1146832 0 3.2414e-07
iB00_590_v n1_609440_1146912 0 1.5090699999999999e-06
iB00_591_v n1_532832_1146992 0 -2.07105e-07
iB00_592_v n1_532832_1146832 0 2.07105e-07
iB00_593_v n1_532832_1108080 0 -1.71575e-07
iB00_594_v n1_532832_1107920 0 1.71575e-07
iB00_595_v n1_609440_1108000 0 2.00774e-06
iB00_596_v n1_570528_1108080 0 -4.0746199999999997e-07
iB00_597_v n1_570528_1107920 0 4.0746199999999997e-07
iB00_598_v n1_570528_1071520 0 2.50986e-08
iB00_599_v n1_570528_1032608 0 1.6092600000000002e-07
iB00_600_v n1_570528_1071600 0 -4.70426e-07
iB00_601_v n1_570528_1071440 0 4.70426e-07
iB00_602_v n1_609440_1071520 0 2.50753e-06
iB00_603_v n1_532832_1071600 0 -3.63673e-07
iB00_604_v n1_532832_1071440 0 3.63673e-07
iB00_605_v n1_532832_1032688 0 -7.031840000000001e-07
iB00_606_v n1_532832_1032528 0 7.031840000000001e-07
iB00_607_v n1_609440_1032608 0 2.91529e-06
iB00_608_v n1_570528_1032688 0 -8.57614e-07
iB00_609_v n1_570528_1032528 0 8.57614e-07
iB00_610_v n1_570528_993696 0 2.48922e-07
iB00_611_v n1_570528_957216 0 9.368249999999999e-07
iB00_612_v n1_570528_993776 0 -1.12866e-06
iB00_613_v n1_570528_993616 0 1.12866e-06
iB00_614_v n1_609440_993696 0 3.3987599999999997e-06
iB00_615_v n1_532832_993776 0 -1.5177999999999999e-06
iB00_616_v n1_532832_993616 0 1.5177999999999999e-06
iB00_617_v n1_532832_918304 0 1.80146e-06
iB00_618_v n1_532832_957296 0 -2.61968e-06
iB00_619_v n1_532832_957136 0 2.61968e-06
iB00_620_v n1_609440_957216 0 3.6545900000000003e-06
iB00_621_v n1_570528_957296 0 -1.41134e-06
iB00_622_v n1_570528_957136 0 1.41134e-06
iB00_623_v n1_570528_918304 0 1.82872e-06
iB00_624_v n1_570528_881824 0 2.59157e-06
iB00_625_v n1_570528_918384 0 -1.4240100000000001e-06
iB00_626_v n1_570528_918224 0 1.4240100000000001e-06
iB00_627_v n1_609440_918304 0 3.65654e-06
iB00_628_v n1_532832_918384 0 -2.43956e-06
iB00_629_v n1_532832_918224 0 2.43956e-06
iB00_630_v n1_532832_881824 0 3.64189e-06
iB00_631_v n1_532832_842912 0 4.44336e-06
iB00_632_v n1_532832_881904 0 -1.42019e-06
iB00_633_v n1_532832_881744 0 1.42019e-06
iB00_634_v n1_493920_881824 0 -5.97271e-06
iB00_635_v n1_474796_881824 0 -6.5103399999999996e-06
iB00_636_v n1_493920_881904 0 -5.37624e-07
iB00_637_v n1_493920_881744 0 5.37624e-07
iB00_638_v n1_493920_842912 0 7.202400000000001e-06
iB00_639_v n1_493920_918384 0 -4.9133800000000006e-06
iB00_640_v n1_493920_918224 0 4.9133800000000006e-06
iB00_641_v n1_474686_918304 0 0.0
iB00_642_v n1_474906_918304 0 -1.24335e-05
iB00_643_v n1_474796_842912 0 1.90827e-05
iB00_644_v n1_474686_881824 0 6.5103399999999996e-06
iB00_645_v n1_474906_881824 0 -6.5103399999999996e-06
iB00_646_v n1_474796_804000 0 1.50446e-05
iB00_647_v n1_474686_842912 0 4.038070000000001e-06
iB00_648_v n1_474906_842912 0 -4.038070000000001e-06
iB00_649_v n1_493920_842992 0 5.013730000000001e-07
iB00_650_v n1_493920_842832 0 -5.013730000000001e-07
iB00_651_v n1_493920_804000 0 6.3684299999999994e-06
iB00_652_v n1_493920_767520 0 5.503939999999999e-06
iB00_653_v n1_493920_804080 0 6.99448e-07
iB00_654_v n1_493920_803920 0 -6.99448e-07
iB00_655_v n1_532832_804000 0 3.5178700000000003e-06
iB00_656_v n1_474686_804000 0 0.0
iB00_657_v n1_474906_804000 0 -2.8184199999999997e-06
iB00_658_v n1_474796_767520 0 1.22262e-05
iB00_659_v n1_474796_728608 0 1.00114e-05
iB00_660_v n1_474686_767520 0 2.21477e-06
iB00_661_v n1_474906_767520 0 -2.21477e-06
iB00_662_v n1_532832_767520 0 2.8297299999999998e-06
iB00_663_v n1_493920_767600 0 6.14964e-07
iB00_664_v n1_493920_767440 0 -6.14964e-07
iB00_665_v n1_493920_728608 0 4.59896e-06
iB00_666_v n1_493920_692128 0 3.88258e-06
iB00_667_v n1_493920_728688 0 5.450080000000001e-07
iB00_668_v n1_493920_728528 0 -5.450080000000001e-07
iB00_669_v n1_532832_728608 0 2.32983e-06
iB00_670_v n1_474686_728608 0 0.0
iB00_671_v n1_474906_728608 0 -1.78482e-06
iB00_672_v n1_474796_692128 0 8.22663e-06
iB00_673_v n1_474796_653216 0 6.67045e-06
iB00_674_v n1_474686_692128 0 1.5561800000000001e-06
iB00_675_v n1_474906_692128 0 -1.5561800000000001e-06
iB00_676_v n1_532832_692128 0 2.01067e-06
iB00_677_v n1_493920_692208 0 4.54494e-07
iB00_678_v n1_493920_692048 0 -4.54494e-07
iB00_679_v n1_493920_653216 0 3.16444e-06
iB00_680_v n1_493920_614304 0 2.48036e-06
iB00_681_v n1_493920_653296 0 3.50324e-07
iB00_682_v n1_493920_653136 0 -3.50324e-07
iB00_683_v n1_532832_653216 0 1.72598e-06
iB00_684_v n1_474686_653216 0 0.0
iB00_685_v n1_474906_653216 0 -1.37566e-06
iB00_686_v n1_474796_614304 0 5.29479e-06
iB00_687_v n1_474796_577824 0 4.09568e-06
iB00_688_v n1_474686_614304 0 1.19911e-06
iB00_689_v n1_474906_614304 0 -1.19911e-06
iB00_690_v n1_532832_614304 0 1.54726e-06
iB00_691_v n1_493920_614384 0 3.48158e-07
iB00_692_v n1_493920_614224 0 -3.48158e-07
iB00_693_v n1_493920_577824 0 1.92274e-06
iB00_694_v n1_493920_538912 0 1.3777900000000001e-06
iB00_695_v n1_493920_577904 0 3.1477799999999996e-07
iB00_696_v n1_493920_577744 0 -3.1477799999999996e-07
iB00_697_v n1_532832_577824 0 1.38992e-06
iB00_698_v n1_474686_577824 0 0.0
iB00_699_v n1_474906_577824 0 -1.0751400000000001e-06
iB00_700_v n1_474796_538912 0 3.02054e-06
iB00_701_v n1_474796_502432 0 2.08543e-06
iB00_702_v n1_474686_538912 0 9.351109999999999e-07
iB00_703_v n1_474906_538912 0 -9.351109999999999e-07
iB00_704_v n1_532832_538912 0 1.2120200000000001e-06
iB00_705_v n1_493920_538992 0 2.76905e-07
iB00_706_v n1_493920_538832 0 -2.76905e-07
iB00_707_v n1_493920_502432 0 8.7071e-07
iB00_708_v n1_493920_480880 0 4.82257e-07
iB00_709_v n1_493920_502512 0 2.43447e-07
iB00_710_v n1_493920_502352 0 -2.43447e-07
iB00_711_v n1_532832_502432 0 1.00811e-06
iB00_712_v n1_474686_502432 0 0.0
iB00_713_v n1_474906_502432 0 -7.646639999999999e-07
iB00_714_v n1_474796_480880 0 1.32077e-06
iB00_715_v n1_474796_480720 0 -4.77049e-17
iB00_716_v n1_474796_481040 0 1.32077e-06
iB00_717_v n1_474686_480880 0 0.0
iB00_718_v n1_532832_480880 0 1.80302e-06
iB00_719_v n1_493920_481040 0 4.82257e-07
iB00_720_v n1_493920_480720 0 -4.82257e-07
iB00_721_v n1_570528_480880 0 1.91479e-06
iB00_722_v n1_532832_481040 0 1.1176299999999999e-07
iB00_723_v n1_532832_480720 0 -1.1176299999999999e-07
iB00_724_v n1_532832_502512 0 1.60941e-08
iB00_725_v n1_532832_502352 0 -1.60941e-08
iB00_726_v n1_570528_502432 0 1.02421e-06
iB00_727_v n1_609440_502432 0 9.32673e-07
iB00_728_v n1_570528_502512 0 -9.15327e-08
iB00_729_v n1_570528_502352 0 9.15327e-08
iB00_730_v n1_570528_538912 0 -2.1913900000000001e-07
iB00_731_v n1_570528_577824 0 -6.961209999999999e-07
iB00_732_v n1_570528_538992 0 -9.31023e-08
iB00_733_v n1_570528_538832 0 9.31023e-08
iB00_734_v n1_609440_538912 0 1.0481799999999998e-06
iB00_735_v n1_532832_538992 0 -7.0734e-08
iB00_736_v n1_532832_538832 0 7.0734e-08
iB00_737_v n1_532832_577904 0 -6.674240000000001e-08
iB00_738_v n1_532832_577744 0 6.674240000000001e-08
iB00_739_v n1_609440_577824 0 1.1331500000000001e-06
iB00_740_v n1_570528_577904 0 -1.9003100000000002e-07
iB00_741_v n1_570528_577744 0 1.9003100000000002e-07
iB00_742_v n1_570528_614304 0 -1.14509e-06
iB00_743_v n1_570528_653216 0 -1.7564e-06
iB00_744_v n1_570528_614384 0 -2.48141e-07
iB00_745_v n1_570528_614224 0 2.48141e-07
iB00_746_v n1_609440_614304 0 1.30356e-06
iB00_747_v n1_532832_614384 0 4.44055e-09
iB00_748_v n1_532832_614224 0 -4.44055e-09
iB00_749_v n1_532832_653296 0 2.94532e-08
iB00_750_v n1_532832_653136 0 -2.94532e-08
iB00_751_v n1_609440_653216 0 1.5748400000000002e-06
iB00_752_v n1_570528_653296 0 -1.80598e-07
iB00_753_v n1_570528_653136 0 1.80598e-07
iB00_754_v n1_570528_692128 0 -2.16557e-06
iB00_755_v n1_570528_728608 0 -2.50024e-06
iB00_756_v n1_570528_692208 0 -1.50562e-07
iB00_757_v n1_570528_692048 0 1.50562e-07
iB00_758_v n1_609440_692128 0 1.84663e-06
iB00_759_v n1_532832_692208 0 -1.34847e-08
iB00_760_v n1_532832_692048 0 1.34847e-08
iB00_761_v n1_532832_728688 0 3.2842500000000004e-08
iB00_762_v n1_532832_728528 0 -3.2842500000000004e-08
iB00_763_v n1_609440_728608 0 2.09048e-06
iB00_764_v n1_570528_728688 0 -2.72192e-07
iB00_765_v n1_570528_728528 0 2.72192e-07
iB00_766_v n1_570528_767520 0 -2.87301e-06
iB00_767_v n1_570528_804000 0 -3.10791e-06
iB00_768_v n1_570528_767600 0 -3.64018e-07
iB00_769_v n1_570528_767440 0 3.64018e-07
iB00_770_v n1_609440_767520 0 2.40814e-06
iB00_771_v n1_532832_767600 0 -5.75776e-08
iB00_772_v n1_532832_767440 0 5.75776e-08
iB00_773_v n1_532832_804080 0 -2.51502e-07
iB00_774_v n1_532832_803920 0 2.51502e-07
iB00_775_v n1_609440_804000 0 2.72031e-06
iB00_776_v n1_570528_804080 0 -5.46051e-07
iB00_777_v n1_570528_803920 0 5.46051e-07
iB00_778_v n1_570528_842912 0 -3.25924e-06
iB00_779_v n1_570528_842992 0 -7.61671e-07
iB00_780_v n1_570528_842832 0 7.61671e-07
iB00_781_v n1_609440_842912 0 3.11742e-06
iB00_782_v n1_532832_842992 0 -6.6035e-07
iB00_783_v n1_532832_842832 0 6.6035e-07
iB00_784_v n1_647136_842912 0 2.47978e-06
iB00_785_v n1_609440_842992 0 -6.3764e-07
iB00_786_v n1_609440_842832 0 6.3764e-07
iB00_787_v n1_609440_881824 0 -2.45567e-06
iB00_788_v n1_609440_881904 0 -8.82416e-07
iB00_789_v n1_609440_881744 0 8.82416e-07
iB00_790_v n1_647136_881824 0 2.6151899999999997e-06
iB00_791_v n1_570528_881904 0 -1.05492e-06
iB00_792_v n1_570528_881744 0 1.05492e-06
iB00_793_v n1_686048_881824 0 1.9343e-06
iB00_794_v n1_647136_881904 0 -6.80891e-07
iB00_795_v n1_647136_881744 0 6.80891e-07
iB00_796_v n1_647136_918304 0 -2.09579e-06
iB00_797_v n1_647136_957216 0 -1.94949e-06
iB00_798_v n1_647136_918384 0 -6.87951e-07
iB00_799_v n1_647136_918224 0 6.87951e-07
iB00_800_v n1_686048_918304 0 2.01242e-06
iB00_801_v n1_609440_918384 0 -9.5617e-07
iB00_802_v n1_609440_918224 0 9.5617e-07
iB00_803_v n1_609440_957296 0 -1.01697e-06
iB00_804_v n1_609440_957136 0 1.01697e-06
iB00_805_v n1_686048_957216 0 1.96387e-06
iB00_806_v n1_647136_957296 0 -6.73745e-07
iB00_807_v n1_647136_957136 0 6.73745e-07
iB00_808_v n1_647136_993696 0 -1.74401e-06
iB00_809_v n1_647136_1032608 0 -1.66212e-06
iB00_810_v n1_647136_993776 0 -6.87591e-07
iB00_811_v n1_647136_993616 0 6.87591e-07
iB00_812_v n1_686048_993696 0 1.80831e-06
iB00_813_v n1_609440_993776 0 -9.02853e-07
iB00_814_v n1_609440_993616 0 9.02853e-07
iB00_815_v n1_609440_1032688 0 -6.781410000000001e-07
iB00_816_v n1_609440_1032528 0 6.781410000000001e-07
iB00_817_v n1_686048_1032608 0 1.59717e-06
iB00_818_v n1_647136_1032688 0 -6.39978e-07
iB00_819_v n1_647136_1032528 0 6.39978e-07
iB00_820_v n1_647136_1071520 0 -1.66326e-06
iB00_821_v n1_647136_1108000 0 -1.70059e-06
iB00_822_v n1_647136_1071600 0 -5.51684e-07
iB00_823_v n1_647136_1071440 0 5.51684e-07
iB00_824_v n1_686048_1071520 0 1.30078e-06
iB00_825_v n1_609440_1071600 0 -6.550720000000001e-07
iB00_826_v n1_609440_1071440 0 6.550720000000001e-07
iB00_827_v n1_609440_1108080 0 -4.81669e-07
iB00_828_v n1_609440_1107920 0 4.81669e-07
iB00_829_v n1_686048_1108000 0 9.92062e-07
iB00_830_v n1_647136_1108080 0 -5.340059999999999e-07
iB00_831_v n1_647136_1107920 0 5.340059999999999e-07
iB00_832_v n1_647136_1146912 0 -1.90869e-06
iB00_833_v n1_647136_1183392 0 -2.0798499999999997e-06
iB00_834_v n1_647136_1146992 0 -4.959260000000001e-07
iB00_835_v n1_647136_1146832 0 4.959260000000001e-07
iB00_836_v n1_686048_1146912 0 6.51963e-07
iB00_837_v n1_609440_1146992 0 -3.6118100000000004e-07
iB00_838_v n1_609440_1146832 0 3.6118100000000004e-07
iB00_839_v n1_609440_1183472 0 -3.56011e-07
iB00_840_v n1_609440_1183312 0 3.56011e-07
iB00_841_v n1_686048_1183392 0 3.13569e-07
iB00_842_v n1_647136_1183472 0 -4.43221e-07
iB00_843_v n1_647136_1183312 0 4.43221e-07
iB00_844_v n1_647136_1222304 0 -2.33883e-06
iB00_845_v n1_647136_1261216 0 -2.4454300000000003e-06
iB00_846_v n1_647136_1222384 0 -3.6896299999999997e-07
iB00_847_v n1_647136_1222224 0 3.6896299999999997e-07
iB00_848_v n1_686048_1222304 0 -5.2078e-08
iB00_849_v n1_609440_1222384 0 -3.61025e-07
iB00_850_v n1_609440_1222224 0 3.61025e-07
iB00_851_v n1_609440_1261296 0 -4.3238199999999996e-07
iB00_852_v n1_609440_1261136 0 4.3238199999999996e-07
iB00_853_v n1_686048_1261216 0 -5.06833e-07
iB00_854_v n1_647136_1261296 0 -4.0808e-07
iB00_855_v n1_647136_1261136 0 4.0808e-07
iB00_856_v n1_647136_1297696 0 -2.5918e-06
iB00_857_v n1_647136_1336608 0 -2.7549100000000004e-06
iB00_858_v n1_647136_1297776 0 -3.98409e-07
iB00_859_v n1_647136_1297616 0 3.98409e-07
iB00_860_v n1_686048_1297696 0 -8.557630000000001e-07
iB00_861_v n1_609440_1297776 0 -4.51329e-07
iB00_862_v n1_609440_1297616 0 4.51329e-07
iB00_863_v n1_609440_1336688 0 -4.890790000000001e-07
iB00_864_v n1_609440_1336528 0 4.890790000000001e-07
iB00_865_v n1_686048_1336608 0 -1.26104e-06
iB00_866_v n1_647136_1336688 0 -4.32115e-07
iB00_867_v n1_647136_1336528 0 4.32115e-07
iB00_868_v n1_647136_1373088 0 -2.88856e-06
iB00_869_v n1_647136_1412000 0 -3.01439e-06
iB00_870_v n1_647136_1373168 0 -5.2315e-07
iB00_871_v n1_647136_1373008 0 5.2315e-07
iB00_872_v n1_686048_1373088 0 -1.70514e-06
iB00_873_v n1_609440_1373168 0 -5.99929e-07
iB00_874_v n1_609440_1373008 0 5.99929e-07
iB00_875_v n1_609440_1412080 0 -6.25163e-07
iB00_876_v n1_609440_1411920 0 6.25163e-07
iB00_877_v n1_686048_1412000 0 -2.185e-06
iB00_878_v n1_647136_1412080 0 -6.42634e-07
iB00_879_v n1_647136_1411920 0 6.42634e-07
iB00_880_v n1_647136_1448480 0 -3.08311e-06
iB00_881_v n1_647136_1448560 0 -8.2239e-07
iB00_882_v n1_647136_1448400 0 8.2239e-07
iB00_883_v n1_686048_1448480 0 -2.70937e-06
iB00_884_v n1_609440_1448560 0 -6.6902e-07
iB00_885_v n1_609440_1448400 0 6.6902e-07
iB00_886_v n1_609440_1487472 0 -7.538140000000001e-07
iB00_887_v n1_609440_1487312 0 7.538140000000001e-07
iB00_888_v n1_647136_1487472 0 -8.94236e-07
iB00_889_v n1_647136_1487312 0 8.94236e-07
iB00_890_v n1_686048_1487472 0 -9.04905e-07
iB00_891_v n1_686048_1487312 0 9.04905e-07
iB00_892_v n1_686048_1448560 0 -7.52e-07
iB00_893_v n1_686048_1448400 0 7.52e-07
iB00_894_v n1_723744_1448480 0 -3.46137e-06
iB00_895_v n1_761440_1448480 0 -4.16997e-06
iB00_896_v n1_723744_1448560 0 -7.08609e-07
iB00_897_v n1_723744_1448400 0 7.08609e-07
iB00_898_v n1_723744_1412000 0 5.19972e-06
iB00_899_v n1_723744_1487472 0 -8.587999999999999e-07
iB00_900_v n1_723744_1487312 0 8.587999999999999e-07
iB00_901_v n1_761440_1487472 0 -9.07045e-07
iB00_902_v n1_761440_1487312 0 9.07045e-07
iB00_903_v n1_761440_1412000 0 6.5306100000000005e-06
iB00_904_v n1_761440_1448560 0 -6.97445e-07
iB00_905_v n1_761440_1448400 0 6.97445e-07
iB00_906_v n1_800352_1448480 0 -4.86742e-06
iB00_907_v n1_838048_1448480 0 -5.3428700000000006e-06
iB00_908_v n1_800352_1448560 0 -4.75449e-07
iB00_909_v n1_800352_1448400 0 4.75449e-07
iB00_910_v n1_800352_1412000 0 8.18153e-06
iB00_911_v n1_800352_1487472 0 -8.02123e-07
iB00_912_v n1_800352_1487312 0 8.02123e-07
iB00_913_v n1_838048_1487472 0 -4.91488e-07
iB00_914_v n1_838048_1487312 0 4.91488e-07
iB00_915_v n1_838048_1412000 0 1.01904e-05
iB00_916_v n1_838048_1448560 0 -1.6661399999999999e-07
iB00_917_v n1_838048_1448400 0 1.6661399999999999e-07
iB00_918_v n1_876960_1448480 0 -5.50948e-06
iB00_919_v n1_914656_1448480 0 -5.05919e-06
iB00_920_v n1_876960_1448560 0 4.50292e-07
iB00_921_v n1_876960_1448400 0 -4.50292e-07
iB00_922_v n1_876960_1412000 0 1.2663e-05
iB00_923_v n1_876960_1487472 0 3.78185e-07
iB00_924_v n1_876960_1487312 0 -3.78185e-07
iB00_925_v n1_914656_1487472 0 1.7907999999999999e-06
iB00_926_v n1_914656_1487312 0 -1.7907999999999999e-06
iB00_927_v n1_914656_1412000 0 1.50237e-05
iB00_928_v n1_914656_1448560 0 1.50227e-06
iB00_929_v n1_914656_1448400 0 -1.50227e-06
iB00_930_v n1_952352_1448480 0 -3.55691e-06
iB00_931_v n1_991264_1448480 0 -1.17391e-06
iB00_932_v n1_952352_1448560 0 2.3830000000000003e-06
iB00_933_v n1_952352_1448400 0 -2.3830000000000003e-06
iB00_934_v n1_952352_1412000 0 1.67e-05
iB00_935_v n1_952352_1487472 0 3.43725e-06
iB00_936_v n1_952352_1487312 0 -3.43725e-06
iB00_937_v n1_991264_1487472 0 4.23706e-06
iB00_938_v n1_991264_1487312 0 -4.23706e-06
iB00_939_v n1_991264_1412000 0 1.7145799999999998e-05
iB00_940_v n1_991264_1448560 0 2.81821e-06
iB00_941_v n1_991264_1448400 0 -2.81821e-06
iB00_942_v n1_1028960_1448480 0 1.64429e-06
iB00_943_v n1_1067872_1448480 0 3.5621200000000003e-06
iB00_944_v n1_1028960_1448560 0 1.91783e-06
iB00_945_v n1_1028960_1448400 0 -1.91783e-06
iB00_946_v n1_1028960_1412000 0 1.5818599999999998e-05
iB00_947_v n1_1028960_1487472 0 2.57076e-06
iB00_948_v n1_1028960_1487312 0 -2.57076e-06
iB00_949_v n1_1067872_1487472 0 8.576000000000001e-07
iB00_950_v n1_1067872_1487312 0 -8.576000000000001e-07
iB00_951_v n1_1067872_1412000 0 1.3552e-05
iB00_952_v n1_1067872_1448560 0 9.01534e-07
iB00_953_v n1_1067872_1448400 0 -9.01534e-07
iB00_954_v n1_1105568_1448480 0 4.46365e-06
iB00_955_v n1_1144480_1448480 0 4.6422e-06
iB00_956_v n1_1105568_1448560 0 1.78549e-07
iB00_957_v n1_1105568_1448400 0 -1.78549e-07
iB00_958_v n1_1105568_1412000 0 1.11903e-05
iB00_959_v n1_1105568_1487472 0 -8.76871e-08
iB00_960_v n1_1105568_1487312 0 8.76871e-08
iB00_961_v n1_1144480_1487472 0 -5.07261e-07
iB00_962_v n1_1144480_1487312 0 5.07261e-07
iB00_963_v n1_1144480_1412000 0 9.09366e-06
iB00_964_v n1_1144480_1448560 0 -2.41708e-07
iB00_965_v n1_1144480_1448400 0 2.41708e-07
iB00_966_v n1_1182176_1448480 0 4.4005e-06
iB00_967_v n1_1219872_1448480 0 3.7584699999999997e-06
iB00_968_v n1_1182176_1448560 0 -6.420249999999999e-07
iB00_969_v n1_1182176_1448400 0 6.420249999999999e-07
iB00_970_v n1_1182176_1412000 0 7.2538200000000005e-06
iB00_971_v n1_1182176_1487472 0 -1.09293e-06
iB00_972_v n1_1182176_1487312 0 1.09293e-06
iB00_973_v n1_1219872_1487472 0 -9.42015e-07
iB00_974_v n1_1219872_1487312 0 9.42015e-07
iB00_975_v n1_1219872_1412000 0 5.772679999999999e-06
iB00_976_v n1_1219872_1448560 0 -8.97303e-07
iB00_977_v n1_1219872_1448400 0 8.97303e-07
iB00_978_v n1_1258784_1448480 0 2.8611700000000003e-06
iB00_979_v n1_1296480_1448480 0 2.07244e-06
iB00_980_v n1_1258784_1448560 0 -7.88732e-07
iB00_981_v n1_1258784_1448400 0 7.88732e-07
iB00_982_v n1_1258784_1412000 0 4.70125e-06
iB00_983_v n1_1258784_1487472 0 -1.09084e-06
iB00_984_v n1_1258784_1487312 0 1.09084e-06
iB00_985_v n1_1296480_1487472 0 -9.38891e-07
iB00_986_v n1_1296480_1487312 0 9.38891e-07
iB00_987_v n1_1296480_1412000 0 3.93567e-06
iB00_988_v n1_1296480_1448560 0 -8.4626e-07
iB00_989_v n1_1296480_1448400 0 8.4626e-07
iB00_990_v n1_1335392_1448480 0 1.22618e-06
iB00_991_v n1_1373088_1448480 0 2.9581e-07
iB00_992_v n1_1335392_1448560 0 -9.303659999999999e-07
iB00_993_v n1_1335392_1448400 0 9.303659999999999e-07
iB00_994_v n1_1335392_1412000 0 3.31146e-06
iB00_995_v n1_1335392_1487472 0 -1.00187e-06
iB00_996_v n1_1335392_1487312 0 1.00187e-06
iB00_997_v n1_1373088_1487472 0 -9.62149e-07
iB00_998_v n1_1373088_1487312 0 9.62149e-07
iB00_999_v n1_1373088_1412000 0 3.0149500000000002e-06
iB00_1000_v n1_1373088_1448560 0 -9.00215e-07
iB00_1001_v n1_1373088_1448400 0 9.00215e-07
iB00_1002_v n1_1412000_1448480 0 -6.04405e-07
iB00_1003_v n1_1449696_1448480 0 -1.2065e-06
iB00_1004_v n1_1412000_1448560 0 -6.02093e-07
iB00_1005_v n1_1412000_1448400 0 6.02093e-07
iB00_1006_v n1_1412000_1412000 0 2.95024e-06
iB00_1007_v n1_1412000_1487472 0 -7.48407e-07
iB00_1008_v n1_1412000_1487312 0 7.48407e-07
iB00_1009_v n1_1449696_1487472 0 -9.43326e-07
iB00_1010_v n1_1449696_1487312 0 9.43326e-07
iB00_1011_v n1_1449696_1412000 0 2.90477e-06
iB00_1012_v n1_1449696_1448560 0 -8.292529999999999e-07
iB00_1013_v n1_1449696_1448400 0 8.292529999999999e-07
iB00_1014_v n1_1487392_1448480 0 -2.03575e-06
iB00_1015_v n1_1526304_1448480 0 -2.66526e-06
iB00_1016_v n1_1487392_1448560 0 -6.295120000000001e-07
iB00_1017_v n1_1487392_1448400 0 6.295120000000001e-07
iB00_1018_v n1_1487392_1412000 0 3.27523e-06
iB00_1019_v n1_1487392_1487472 0 -8.18431e-07
iB00_1020_v n1_1487392_1487312 0 8.18431e-07
iB00_1021_v n1_1526304_1487472 0 -6.67315e-07
iB00_1022_v n1_1526304_1487312 0 6.67315e-07
iB00_1023_v n1_1526304_1412000 0 3.7445600000000003e-06
iB00_1024_v n1_1526304_1448560 0 -4.768740000000001e-07
iB00_1025_v n1_1526304_1448400 0 4.768740000000001e-07
iB00_1026_v n1_1564000_1448480 0 -3.1421399999999998e-06
iB00_1027_v n1_1602912_1448480 0 -3.38682e-06
iB00_1028_v n1_1564000_1448560 0 -2.44685e-07
iB00_1029_v n1_1564000_1448400 0 2.44685e-07
iB00_1030_v n1_1564000_1412000 0 4.34435e-06
iB00_1031_v n1_1564000_1487472 0 -3.3228e-07
iB00_1032_v n1_1564000_1487312 0 3.3228e-07
iB00_1033_v n1_1641180_1487392 0 -3.67099e-06
iB00_1034_v n1_1602912_1487472 0 3.2804399999999997e-07
iB00_1035_v n1_1602912_1487312 0 -3.2804399999999997e-07
iB00_1036_v n1_1602912_1412000 0 5.17321e-06
iB00_1037_v n1_1602912_1448560 0 3.56019e-07
iB00_1038_v n1_1602912_1448400 0 -3.56019e-07
iB00_1039_v n1_1641180_1448480 0 -3.0308000000000003e-06
iB00_1040_v n1_1641290_1448480 0 0.0
iB00_1041_v n1_1641070_1448480 0 3.0308000000000003e-06
iB00_1042_v n1_1641180_1412000 0 1.1926900000000001e-05
iB00_1043_v n1_1641070_1487392 0 3.67099e-06
iB00_1044_v n1_1641290_1487392 0 -3.67099e-06
iB00_1045_v n1_1641070_1526304 0 4.80569e-06
iB00_1046_v n1_1641290_1526304 0 -4.80569e-06
iB00_1047_v n1_1641180_1373088 0 9.287490000000001e-06
iB00_1048_v n1_1641070_1412000 0 2.63945e-06
iB00_1049_v n1_1641290_1412000 0 -2.63945e-06
iB00_1050_v n1_1602912_1412080 0 3.4370499999999997e-07
iB00_1051_v n1_1602912_1411920 0 -3.4370499999999997e-07
iB00_1052_v n1_1602912_1373088 0 4.2133e-06
iB00_1053_v n1_1602912_1336608 0 3.1696799999999998e-06
iB00_1054_v n1_1602912_1373168 0 2.1634200000000002e-07
iB00_1055_v n1_1602912_1373008 0 -2.1634200000000002e-07
iB00_1056_v n1_1564000_1373088 0 2.62843e-06
iB00_1057_v n1_1526304_1373088 0 2.5736000000000002e-06
iB00_1058_v n1_1564000_1373168 0 -5.48263e-08
iB00_1059_v n1_1564000_1373008 0 5.48263e-08
iB00_1060_v n1_1564000_1336608 0 2.8352999999999998e-06
iB00_1061_v n1_1564000_1412080 0 -1.42552e-07
iB00_1062_v n1_1564000_1411920 0 1.42552e-07
iB00_1063_v n1_1526304_1412080 0 -4.03919e-07
iB00_1064_v n1_1526304_1411920 0 4.03919e-07
iB00_1065_v n1_1526304_1336608 0 2.33527e-06
iB00_1066_v n1_1526304_1373168 0 -3.26583e-07
iB00_1067_v n1_1526304_1373008 0 3.26583e-07
iB00_1068_v n1_1487392_1373088 0 2.2470200000000004e-06
iB00_1069_v n1_1449696_1373088 0 1.78644e-06
iB00_1070_v n1_1487392_1373168 0 -4.60577e-07
iB00_1071_v n1_1487392_1373008 0 4.60577e-07
iB00_1072_v n1_1487392_1336608 0 2.06351e-06
iB00_1073_v n1_1487392_1412080 0 -5.871780000000001e-07
iB00_1074_v n1_1487392_1411920 0 5.871780000000001e-07
iB00_1075_v n1_1449696_1412080 0 -6.20156e-07
iB00_1076_v n1_1449696_1411920 0 6.20156e-07
iB00_1077_v n1_1449696_1336608 0 2.1206799999999997e-06
iB00_1078_v n1_1449696_1373168 0 -4.70449e-07
iB00_1079_v n1_1449696_1373008 0 4.70449e-07
iB00_1080_v n1_1412000_1373088 0 1.31599e-06
iB00_1081_v n1_1373088_1373088 0 7.29417e-07
iB00_1082_v n1_1412000_1373168 0 -5.865739999999999e-07
iB00_1083_v n1_1412000_1373008 0 5.865739999999999e-07
iB00_1084_v n1_1412000_1336608 0 2.1307299999999998e-06
iB00_1085_v n1_1412000_1412080 0 -5.93436e-07
iB00_1086_v n1_1412000_1411920 0 5.93436e-07
iB00_1087_v n1_1373088_1412080 0 -7.8267e-07
iB00_1088_v n1_1373088_1411920 0 7.8267e-07
iB00_1089_v n1_1373088_1336608 0 2.34993e-06
iB00_1090_v n1_1373088_1373168 0 -6.78756e-07
iB00_1091_v n1_1373088_1373008 0 6.78756e-07
iB00_1092_v n1_1335392_1373088 0 5.06613e-08
iB00_1093_v n1_1296480_1373088 0 -6.2547e-07
iB00_1094_v n1_1335392_1373168 0 -6.76131e-07
iB00_1095_v n1_1335392_1373008 0 6.76131e-07
iB00_1096_v n1_1335392_1336608 0 2.79346e-06
iB00_1097_v n1_1335392_1412080 0 -7.75428e-07
iB00_1098_v n1_1335392_1411920 0 7.75428e-07
iB00_1099_v n1_1296480_1412080 0 -7.65384e-07
iB00_1100_v n1_1296480_1411920 0 7.65384e-07
iB00_1101_v n1_1296480_1336608 0 3.3750099999999997e-06
iB00_1102_v n1_1296480_1373168 0 -6.27683e-07
iB00_1103_v n1_1296480_1373008 0 6.27683e-07
iB00_1104_v n1_1258784_1373088 0 -1.25315e-06
iB00_1105_v n1_1219872_1373088 0 -1.8507599999999999e-06
iB00_1106_v n1_1258784_1373168 0 -5.97611e-07
iB00_1107_v n1_1258784_1373008 0 5.97611e-07
iB00_1108_v n1_1258784_1336608 0 4.167459999999999e-06
iB00_1109_v n1_1258784_1412080 0 -6.51804e-07
iB00_1110_v n1_1258784_1411920 0 6.51804e-07
iB00_1111_v n1_1219872_1412080 0 -6.745059999999999e-07
iB00_1112_v n1_1219872_1411920 0 6.745059999999999e-07
iB00_1113_v n1_1219872_1336608 0 5.1337600000000005e-06
iB00_1114_v n1_1219872_1373168 0 -4.867809999999999e-07
iB00_1115_v n1_1219872_1373008 0 4.867809999999999e-07
iB00_1116_v n1_1182176_1373088 0 -2.33754e-06
iB00_1117_v n1_1144480_1373088 0 -2.65355e-06
iB00_1118_v n1_1182176_1373168 0 -3.1600600000000003e-07
iB00_1119_v n1_1182176_1373008 0 3.1600600000000003e-07
iB00_1120_v n1_1182176_1336608 0 6.37969e-06
iB00_1121_v n1_1182176_1412080 0 -4.61693e-07
iB00_1122_v n1_1182176_1411920 0 4.61693e-07
iB00_1123_v n1_1144480_1412080 0 -1.4553499999999999e-07
iB00_1124_v n1_1144480_1411920 0 1.4553499999999999e-07
iB00_1125_v n1_1144480_1336608 0 7.84163e-06
iB00_1126_v n1_1144480_1373168 0 3.2655099999999996e-08
iB00_1127_v n1_1144480_1373008 0 -3.2655099999999996e-08
iB00_1128_v n1_1105568_1373088 0 -2.62089e-06
iB00_1129_v n1_1067872_1373088 0 -2.3184e-06
iB00_1130_v n1_1105568_1373168 0 3.0248900000000003e-07
iB00_1131_v n1_1105568_1373008 0 -3.0248900000000003e-07
iB00_1132_v n1_1105568_1336608 0 9.26116e-06
iB00_1133_v n1_1105568_1412080 0 3.4473099999999997e-07
iB00_1134_v n1_1105568_1411920 0 -3.4473099999999997e-07
iB00_1135_v n1_1067872_1412080 0 8.18103e-07
iB00_1136_v n1_1067872_1411920 0 -8.18103e-07
iB00_1137_v n1_1067872_1336608 0 1.0659200000000001e-05
iB00_1138_v n1_1067872_1373168 0 6.821940000000001e-07
iB00_1139_v n1_1067872_1373008 0 -6.821940000000001e-07
iB00_1140_v n1_1028960_1373088 0 -1.63621e-06
iB00_1141_v n1_991264_1373088 0 -5.24349e-07
iB00_1142_v n1_1028960_1373168 0 1.11186e-06
iB00_1143_v n1_1028960_1373008 0 -1.11186e-06
iB00_1144_v n1_1028960_1336608 0 1.18051e-05
iB00_1145_v n1_1028960_1412080 0 1.4812000000000001e-06
iB00_1146_v n1_1028960_1411920 0 -1.4812000000000001e-06
iB00_1147_v n1_991264_1412080 0 1.9338700000000003e-06
iB00_1148_v n1_991264_1411920 0 -1.9338700000000003e-06
iB00_1149_v n1_991264_1336608 0 1.2282e-05
iB00_1150_v n1_991264_1373168 0 1.31866e-06
iB00_1151_v n1_991264_1373008 0 -1.31866e-06
iB00_1152_v n1_952352_1373088 0 7.94308e-07
iB00_1153_v n1_914656_1373088 0 2.10543e-06
iB00_1154_v n1_952352_1373168 0 1.31112e-06
iB00_1155_v n1_952352_1373008 0 -1.31112e-06
iB00_1156_v n1_952352_1336608 0 1.21484e-05
iB00_1157_v n1_952352_1412080 0 1.7573700000000001e-06
iB00_1158_v n1_952352_1411920 0 -1.7573700000000001e-06
iB00_1159_v n1_914656_1412080 0 1.15825e-06
iB00_1160_v n1_914656_1411920 0 -1.15825e-06
iB00_1161_v n1_914656_1336608 0 1.11423e-05
iB00_1162_v n1_914656_1373168 0 8.273659999999999e-07
iB00_1163_v n1_914656_1373008 0 -8.273659999999999e-07
iB00_1164_v n1_876960_1373088 0 2.93279e-06
iB00_1165_v n1_838048_1373088 0 3.3585799999999998e-06
iB00_1166_v n1_876960_1373168 0 4.2578499999999997e-07
iB00_1167_v n1_876960_1373008 0 -4.2578499999999997e-07
iB00_1168_v n1_876960_1336608 0 9.98565e-06
iB00_1169_v n1_876960_1412080 0 4.3283699999999997e-07
iB00_1170_v n1_876960_1411920 0 -4.3283699999999997e-07
iB00_1171_v n1_838048_1412080 0 2.7720900000000002e-08
iB00_1172_v n1_838048_1411920 0 -2.7720900000000002e-08
iB00_1173_v n1_838048_1336608 0 8.53863e-06
iB00_1174_v n1_838048_1373168 0 7.62595e-08
iB00_1175_v n1_838048_1373008 0 -7.62595e-08
iB00_1176_v n1_800352_1373088 0 3.4348400000000004e-06
iB00_1177_v n1_761440_1373088 0 3.29316e-06
iB00_1178_v n1_800352_1373168 0 -1.41672e-07
iB00_1179_v n1_800352_1373008 0 1.41672e-07
iB00_1180_v n1_800352_1336608 0 7.2427300000000005e-06
iB00_1181_v n1_800352_1412080 0 -2.69584e-07
iB00_1182_v n1_800352_1411920 0 2.69584e-07
iB00_1183_v n1_761440_1412080 0 -5.62494e-07
iB00_1184_v n1_761440_1411920 0 5.62494e-07
iB00_1185_v n1_761440_1336608 0 5.92146e-06
iB00_1186_v n1_761440_1373168 0 -4.39874e-07
iB00_1187_v n1_761440_1373008 0 4.39874e-07
iB00_1188_v n1_723744_1373088 0 2.85329e-06
iB00_1189_v n1_723744_1373168 0 -5.51715e-07
iB00_1190_v n1_723744_1373008 0 5.51715e-07
iB00_1191_v n1_723744_1336608 0 4.7410200000000006e-06
iB00_1192_v n1_723744_1412080 0 -5.623330000000001e-07
iB00_1193_v n1_723744_1411920 0 5.623330000000001e-07
iB00_1194_v n1_686048_1412080 0 -7.535690000000001e-07
iB00_1195_v n1_686048_1411920 0 7.535690000000001e-07
iB00_1196_v n1_686048_1373168 0 -5.96436e-07
iB00_1197_v n1_686048_1373008 0 5.96436e-07
iB00_1198_v n1_686048_1336688 0 -5.67691e-07
iB00_1199_v n1_686048_1336528 0 5.67691e-07
iB00_1200_v n1_723744_1336688 0 -4.3113e-07
iB00_1201_v n1_723744_1336528 0 4.3113e-07
iB00_1202_v n1_723744_1297696 0 4.48179e-06
iB00_1203_v n1_723744_1261216 0 4.16649e-06
iB00_1204_v n1_723744_1297776 0 -4.1740599999999997e-07
iB00_1205_v n1_723744_1297616 0 4.1740599999999997e-07
iB00_1206_v n1_761440_1297696 0 -1.7384600000000001e-06
iB00_1207_v n1_686048_1297776 0 -4.65291e-07
iB00_1208_v n1_686048_1297616 0 4.65291e-07
iB00_1209_v n1_686048_1261296 0 -3.82772e-07
iB00_1210_v n1_686048_1261136 0 3.82772e-07
iB00_1211_v n1_761440_1261216 0 -1.22154e-06
iB00_1212_v n1_723744_1261296 0 -3.31932e-07
iB00_1213_v n1_723744_1261136 0 3.31932e-07
iB00_1214_v n1_723744_1222304 0 4.0055e-06
iB00_1215_v n1_723744_1183392 0 3.7230599999999997e-06
iB00_1216_v n1_723744_1222384 0 -2.82395e-07
iB00_1217_v n1_723744_1222224 0 2.82395e-07
iB00_1218_v n1_761440_1222304 0 -8.04857e-07
iB00_1219_v n1_686048_1222384 0 -4.70383e-07
iB00_1220_v n1_686048_1222224 0 4.70383e-07
iB00_1221_v n1_686048_1183472 0 -4.71199e-07
iB00_1222_v n1_686048_1183312 0 4.71199e-07
iB00_1223_v n1_761440_1183392 0 -4.59322e-07
iB00_1224_v n1_723744_1183472 0 -3.0169300000000003e-07
iB00_1225_v n1_723744_1183312 0 3.0169300000000003e-07
iB00_1226_v n1_723744_1146912 0 3.36524e-06
iB00_1227_v n1_723744_1108000 0 3.1721499999999998e-06
iB00_1228_v n1_723744_1146992 0 -2.69899e-07
iB00_1229_v n1_723744_1146832 0 2.69899e-07
iB00_1230_v n1_761440_1146912 0 -1.3064300000000001e-07
iB00_1231_v n1_686048_1146992 0 -5.127070000000001e-07
iB00_1232_v n1_686048_1146832 0 5.127070000000001e-07
iB00_1233_v n1_686048_1108080 0 -5.263620000000001e-07
iB00_1234_v n1_686048_1107920 0 5.263620000000001e-07
iB00_1235_v n1_761440_1108000 0 1.15139e-07
iB00_1236_v n1_723744_1108080 0 -3.50561e-07
iB00_1237_v n1_723744_1107920 0 3.50561e-07
iB00_1238_v n1_723744_1071520 0 2.86191e-06
iB00_1239_v n1_723744_1032608 0 2.60452e-06
iB00_1240_v n1_723744_1071600 0 -3.86821e-07
iB00_1241_v n1_723744_1071440 0 3.86821e-07
iB00_1242_v n1_761440_1071520 0 3.44027e-07
iB00_1243_v n1_686048_1071600 0 -5.699280000000001e-07
iB00_1244_v n1_686048_1071440 0 5.699280000000001e-07
iB00_1245_v n1_686048_1032688 0 -6.67551e-07
iB00_1246_v n1_686048_1032528 0 6.67551e-07
iB00_1247_v n1_761440_1032608 0 5.66412e-07
iB00_1248_v n1_723744_1032688 0 -3.6321299999999996e-07
iB00_1249_v n1_723744_1032528 0 3.6321299999999996e-07
iB00_1250_v n1_723744_993696 0 2.48626e-06
iB00_1251_v n1_723744_957216 0 2.3291900000000002e-06
iB00_1252_v n1_723744_993776 0 -4.50934e-07
iB00_1253_v n1_723744_993616 0 4.50934e-07
iB00_1254_v n1_761440_993696 0 7.026730000000001e-07
iB00_1255_v n1_686048_993776 0 -6.54707e-07
iB00_1256_v n1_686048_993616 0 6.54707e-07
iB00_1257_v n1_686048_957296 0 -6.76666e-07
iB00_1258_v n1_686048_957136 0 6.76666e-07
iB00_1259_v n1_761440_957216 0 7.88974e-07
iB00_1260_v n1_723744_957296 0 -4.98233e-07
iB00_1261_v n1_723744_957136 0 4.98233e-07
iB00_1262_v n1_723744_918304 0 2.1912099999999997e-06
iB00_1263_v n1_723744_881824 0 2.04305e-06
iB00_1264_v n1_723744_918384 0 -5.21696e-07
iB00_1265_v n1_723744_918224 0 5.21696e-07
iB00_1266_v n1_761440_918304 0 8.45021e-07
iB00_1267_v n1_686048_918384 0 -6.457e-07
iB00_1268_v n1_686048_918224 0 6.457e-07
iB00_1269_v n1_686048_842912 0 1.96577e-06
iB00_1270_v n1_686048_881904 0 -5.13455e-07
iB00_1271_v n1_686048_881744 0 5.13455e-07
iB00_1272_v n1_761440_881824 0 8.80107e-07
iB00_1273_v n1_723744_881904 0 -5.40736e-07
iB00_1274_v n1_723744_881744 0 5.40736e-07
iB00_1275_v n1_723744_842912 0 1.8497100000000001e-06
iB00_1276_v n1_723744_804000 0 1.6844e-06
iB00_1277_v n1_723744_842992 0 -5.01675e-07
iB00_1278_v n1_723744_842832 0 5.01675e-07
iB00_1279_v n1_761440_842912 0 8.56929e-07
iB00_1280_v n1_686048_842992 0 -4.52375e-07
iB00_1281_v n1_686048_842832 0 4.52375e-07
iB00_1282_v n1_686048_804000 0 1.8715500000000001e-06
iB00_1283_v n1_686048_767520 0 1.71168e-06
iB00_1284_v n1_686048_804080 0 -4.58436e-07
iB00_1285_v n1_686048_803920 0 4.58436e-07
iB00_1286_v n1_647136_804000 0 -1.7166799999999999e-06
iB00_1287_v n1_647136_804080 0 -5.26228e-07
iB00_1288_v n1_647136_803920 0 5.26228e-07
iB00_1289_v n1_647136_767520 0 1.9714300000000003e-06
iB00_1290_v n1_647136_842992 0 -6.68804e-07
iB00_1291_v n1_647136_842832 0 6.68804e-07
iB00_1292_v n1_647136_728608 0 1.76554e-06
iB00_1293_v n1_647136_767600 0 -4.0363600000000003e-07
iB00_1294_v n1_647136_767440 0 4.0363600000000003e-07
iB00_1295_v n1_609440_767600 0 -4.14321e-07
iB00_1296_v n1_609440_767440 0 4.14321e-07
iB00_1297_v n1_609440_804080 0 -4.77403e-07
iB00_1298_v n1_609440_803920 0 4.77403e-07
iB00_1299_v n1_609440_728688 0 -3.62626e-07
iB00_1300_v n1_609440_728528 0 3.62626e-07
iB00_1301_v n1_686048_728608 0 1.44218e-06
iB00_1302_v n1_647136_728688 0 -2.85676e-07
iB00_1303_v n1_647136_728528 0 2.85676e-07
iB00_1304_v n1_647136_692128 0 1.5710999999999999e-06
iB00_1305_v n1_647136_653216 0 1.26837e-06
iB00_1306_v n1_647136_692208 0 -2.5478399999999996e-07
iB00_1307_v n1_647136_692048 0 2.5478399999999996e-07
iB00_1308_v n1_686048_692128 0 1.25768e-06
iB00_1309_v n1_609440_692208 0 -3.3415799999999997e-07
iB00_1310_v n1_609440_692048 0 3.3415799999999997e-07
iB00_1311_v n1_609440_653296 0 -2.62925e-07
iB00_1312_v n1_609440_653136 0 2.62925e-07
iB00_1313_v n1_686048_653216 0 1.10573e-06
iB00_1314_v n1_647136_653296 0 -2.0618500000000002e-07
iB00_1315_v n1_647136_653136 0 2.0618500000000002e-07
iB00_1316_v n1_647136_614304 0 9.23546e-07
iB00_1317_v n1_647136_577824 0 6.87318e-07
iB00_1318_v n1_647136_614384 0 -1.74468e-07
iB00_1319_v n1_647136_614224 0 1.74468e-07
iB00_1320_v n1_686048_614304 0 9.708609999999999e-07
iB00_1321_v n1_609440_614384 0 -1.58233e-07
iB00_1322_v n1_609440_614224 0 1.58233e-07
iB00_1323_v n1_609440_577904 0 -4.20358e-08
iB00_1324_v n1_609440_577744 0 4.20358e-08
iB00_1325_v n1_686048_577824 0 8.170449999999999e-07
iB00_1326_v n1_647136_577904 0 -2.7406799999999996e-07
iB00_1327_v n1_647136_577744 0 2.7406799999999996e-07
iB00_1328_v n1_647136_538912 0 2.00839e-07
iB00_1329_v n1_647136_502432 0 -1.94664e-07
iB00_1330_v n1_647136_538992 0 -1.68422e-07
iB00_1331_v n1_647136_538832 0 1.68422e-07
iB00_1332_v n1_686048_538912 0 7.448080000000001e-07
iB00_1333_v n1_609440_538992 0 -1.3495e-07
iB00_1334_v n1_609440_538832 0 1.3495e-07
iB00_1335_v n1_609440_480880 0 -2.23974e-07
iB00_1336_v n1_609440_502512 0 -1.08238e-07
iB00_1337_v n1_609440_502352 0 1.08238e-07
iB00_1338_v n1_686048_502432 0 6.52704e-07
iB00_1339_v n1_647136_502512 0 -1.71731e-07
iB00_1340_v n1_647136_502352 0 1.71731e-07
iB00_1341_v n1_647136_480880 0 -3.4391599999999997e-07
iB00_1342_v n1_647136_480720 0 -2.38524e-17
iB00_1343_v n1_647136_481040 0 -3.4391599999999997e-07
iB00_1344_v n1_686048_480880 0 1.23371e-06
iB00_1345_v n1_609440_481040 0 -2.23974e-07
iB00_1346_v n1_609440_480720 0 2.23974e-07
iB00_1347_v n1_570528_481040 0 -1.1319000000000001e-07
iB00_1348_v n1_570528_480720 0 1.1319000000000001e-07
iB00_1349_v n1_723744_480880 0 7.65195e-07
iB00_1350_v n1_686048_481040 0 -4.68513e-07
iB00_1351_v n1_686048_480720 0 4.68513e-07
iB00_1352_v n1_686048_502512 0 -2.53965e-07
iB00_1353_v n1_686048_502352 0 2.53965e-07
iB00_1354_v n1_723744_502432 0 3.98738e-07
iB00_1355_v n1_761440_502432 0 1.32629e-07
iB00_1356_v n1_723744_502512 0 -2.66109e-07
iB00_1357_v n1_723744_502352 0 2.66109e-07
iB00_1358_v n1_723744_538912 0 4.989560000000001e-07
iB00_1359_v n1_723744_577824 0 1.41989e-07
iB00_1360_v n1_723744_538992 0 -2.75446e-07
iB00_1361_v n1_723744_538832 0 2.75446e-07
iB00_1362_v n1_761440_538912 0 1.81193e-07
iB00_1363_v n1_686048_538992 0 -2.8816999999999997e-07
iB00_1364_v n1_686048_538832 0 2.8816999999999997e-07
iB00_1365_v n1_686048_577904 0 -2.5113700000000003e-07
iB00_1366_v n1_686048_577744 0 2.5113700000000003e-07
iB00_1367_v n1_761440_577824 0 2.8343699999999997e-07
iB00_1368_v n1_723744_577904 0 -2.82471e-07
iB00_1369_v n1_723744_577744 0 2.82471e-07
iB00_1370_v n1_723744_614304 0 -8.89634e-08
iB00_1371_v n1_723744_653216 0 -4.63211e-07
iB00_1372_v n1_723744_614384 0 -3.8547e-07
iB00_1373_v n1_723744_614224 0 3.8547e-07
iB00_1374_v n1_761440_614304 0 3.22467e-07
iB00_1375_v n1_686048_614384 0 -2.62924e-07
iB00_1376_v n1_686048_614224 0 2.62924e-07
iB00_1377_v n1_686048_653296 0 -2.90161e-07
iB00_1378_v n1_686048_653136 0 2.90161e-07
iB00_1379_v n1_761440_653216 0 4.3337300000000005e-07
iB00_1380_v n1_723744_653296 0 -3.82195e-07
iB00_1381_v n1_723744_653136 0 3.82195e-07
iB00_1382_v n1_723744_692128 0 -6.82311e-07
iB00_1383_v n1_723744_728608 0 -1.02379e-06
iB00_1384_v n1_723744_692208 0 -4.4054e-07
iB00_1385_v n1_723744_692048 0 4.4054e-07
iB00_1386_v n1_761440_692128 0 5.32438e-07
iB00_1387_v n1_686048_692208 0 -2.84707e-07
iB00_1388_v n1_686048_692048 0 2.84707e-07
iB00_1389_v n1_686048_728688 0 -3.8449699999999995e-07
iB00_1390_v n1_686048_728528 0 3.8449699999999995e-07
iB00_1391_v n1_761440_728608 0 6.39151e-07
iB00_1392_v n1_723744_728688 0 -4.1853000000000003e-07
iB00_1393_v n1_723744_728528 0 4.1853000000000003e-07
iB00_1394_v n1_723744_767520 0 -1.31364e-06
iB00_1395_v n1_723744_767600 0 -4.07364e-07
iB00_1396_v n1_723744_767440 0 4.07364e-07
iB00_1397_v n1_761440_767520 0 7.39865e-07
iB00_1398_v n1_686048_767600 0 -4.42952e-07
iB00_1399_v n1_686048_767440 0 4.42952e-07
iB00_1400_v n1_800352_767520 0 3.23578e-07
iB00_1401_v n1_761440_767600 0 -4.1628800000000003e-07
iB00_1402_v n1_761440_767440 0 4.1628800000000003e-07
iB00_1403_v n1_761440_804000 0 -1.38915e-06
iB00_1404_v n1_761440_804080 0 -4.49477e-07
iB00_1405_v n1_761440_803920 0 4.49477e-07
iB00_1406_v n1_800352_804000 0 3.41514e-07
iB00_1407_v n1_723744_804080 0 -4.6725500000000004e-07
iB00_1408_v n1_723744_803920 0 4.6725500000000004e-07
iB00_1409_v n1_838048_804000 0 -8.67139e-09
iB00_1410_v n1_800352_804080 0 -3.50187e-07
iB00_1411_v n1_800352_803920 0 3.50187e-07
iB00_1412_v n1_800352_842912 0 -1.56518e-06
iB00_1413_v n1_800352_881824 0 -1.77237e-06
iB00_1414_v n1_800352_842992 0 -2.96232e-07
iB00_1415_v n1_800352_842832 0 2.96232e-07
iB00_1416_v n1_838048_842912 0 4.33362e-08
iB00_1417_v n1_761440_842992 0 -5.1736e-07
iB00_1418_v n1_761440_842832 0 5.1736e-07
iB00_1419_v n1_761440_881904 0 -5.228159999999999e-07
iB00_1420_v n1_761440_881744 0 5.228159999999999e-07
iB00_1421_v n1_838048_881824 0 1.9913599999999997e-08
iB00_1422_v n1_800352_881904 0 -3.37378e-07
iB00_1423_v n1_800352_881744 0 3.37378e-07
iB00_1424_v n1_800352_918304 0 -2.11807e-06
iB00_1425_v n1_800352_957216 0 -2.34369e-06
iB00_1426_v n1_800352_918384 0 -3.09095e-07
iB00_1427_v n1_800352_918224 0 3.09095e-07
iB00_1428_v n1_838048_918304 0 4.56521e-08
iB00_1429_v n1_761440_918384 0 -4.90273e-07
iB00_1430_v n1_761440_918224 0 4.90273e-07
iB00_1431_v n1_761440_957296 0 -4.59143e-07
iB00_1432_v n1_761440_957136 0 4.59143e-07
iB00_1433_v n1_838048_957216 0 -1.3883800000000001e-08
iB00_1434_v n1_800352_957296 0 -3.4371500000000003e-07
iB00_1435_v n1_800352_957136 0 3.4371500000000003e-07
iB00_1436_v n1_800352_993696 0 -2.62035e-06
iB00_1437_v n1_800352_1032608 0 -3.01506e-06
iB00_1438_v n1_800352_993776 0 -3.66176e-07
iB00_1439_v n1_800352_993616 0 3.66176e-07
iB00_1440_v n1_838048_993696 0 -9.45406e-08
iB00_1441_v n1_761440_993776 0 -4.31039e-07
iB00_1442_v n1_761440_993616 0 4.31039e-07
iB00_1443_v n1_761440_1032688 0 -4.3747399999999996e-07
iB00_1444_v n1_761440_1032528 0 4.3747399999999996e-07
iB00_1445_v n1_838048_1032608 0 -1.82445e-07
iB00_1446_v n1_800352_1032688 0 -3.11384e-07
iB00_1447_v n1_800352_1032528 0 3.11384e-07
iB00_1448_v n1_800352_1071520 0 -3.31176e-06
iB00_1449_v n1_800352_1108000 0 -3.73492e-06
iB00_1450_v n1_800352_1071600 0 -3.46006e-07
iB00_1451_v n1_800352_1071440 0 3.46006e-07
iB00_1452_v n1_838048_1071520 0 -3.69029e-07
iB00_1453_v n1_761440_1071600 0 -3.6705e-07
iB00_1454_v n1_761440_1071440 0 3.6705e-07
iB00_1455_v n1_761440_1108080 0 -3.41598e-07
iB00_1456_v n1_761440_1107920 0 3.41598e-07
iB00_1457_v n1_838048_1108000 0 -5.486010000000001e-07
iB00_1458_v n1_800352_1108080 0 -3.22143e-07
iB00_1459_v n1_800352_1107920 0 3.22143e-07
iB00_1460_v n1_800352_1146912 0 -4.16e-06
iB00_1461_v n1_800352_1183392 0 -4.5806e-06
iB00_1462_v n1_800352_1146992 0 -2.587e-07
iB00_1463_v n1_800352_1146832 0 2.587e-07
iB00_1464_v n1_838048_1146912 0 -7.60227e-07
iB00_1465_v n1_761440_1146992 0 -3.70885e-07
iB00_1466_v n1_761440_1146832 0 3.70885e-07
iB00_1467_v n1_761440_1183472 0 -3.1569e-07
iB00_1468_v n1_761440_1183312 0 3.1569e-07
iB00_1469_v n1_838048_1183392 0 -9.75445e-07
iB00_1470_v n1_800352_1183472 0 -2.00434e-07
iB00_1471_v n1_800352_1183312 0 2.00434e-07
iB00_1472_v n1_800352_1222304 0 -5.09407e-06
iB00_1473_v n1_800352_1261216 0 -5.590000000000001e-06
iB00_1474_v n1_800352_1222384 0 -1.4365100000000002e-07
iB00_1475_v n1_800352_1222224 0 1.4365100000000002e-07
iB00_1476_v n1_838048_1222304 0 -1.29614e-06
iB00_1477_v n1_761440_1222384 0 -3.47636e-07
iB00_1478_v n1_761440_1222224 0 3.47636e-07
iB00_1479_v n1_761440_1261296 0 -3.5041899999999996e-07
iB00_1480_v n1_761440_1261136 0 3.5041899999999996e-07
iB00_1481_v n1_838048_1261216 0 -1.70337e-06
iB00_1482_v n1_800352_1261296 0 -1.31416e-07
iB00_1483_v n1_800352_1261136 0 1.31416e-07
iB00_1484_v n1_800352_1297696 0 -6.14315e-06
iB00_1485_v n1_800352_1297776 0 -1.6185700000000002e-07
iB00_1486_v n1_800352_1297616 0 1.6185700000000002e-07
iB00_1487_v n1_838048_1297696 0 -2.1957e-06
iB00_1488_v n1_761440_1297776 0 -2.95382e-07
iB00_1489_v n1_761440_1297616 0 2.95382e-07
iB00_1490_v n1_761440_1336688 0 -3.8983099999999997e-07
iB00_1491_v n1_761440_1336528 0 3.8983099999999997e-07
iB00_1492_v n1_800352_1336688 0 -1.33669e-07
iB00_1493_v n1_800352_1336528 0 1.33669e-07
iB00_1494_v n1_838048_1336688 0 1.2949599999999998e-07
iB00_1495_v n1_838048_1336528 0 -1.2949599999999998e-07
iB00_1496_v n1_838048_1297776 0 7.33184e-08
iB00_1497_v n1_838048_1297616 0 -7.33184e-08
iB00_1498_v n1_876960_1297696 0 -2.12238e-06
iB00_1499_v n1_914656_1297696 0 -1.77188e-06
iB00_1500_v n1_876960_1297776 0 3.5050100000000005e-07
iB00_1501_v n1_876960_1297616 0 -3.5050100000000005e-07
iB00_1502_v n1_876960_1261216 0 8.01902e-06
iB00_1503_v n1_876960_1336688 0 3.02545e-07
iB00_1504_v n1_876960_1336528 0 -3.02545e-07
iB00_1505_v n1_914656_1336688 0 7.51694e-07
iB00_1506_v n1_914656_1336528 0 -7.51694e-07
iB00_1507_v n1_914656_1261216 0 8.6322e-06
iB00_1508_v n1_914656_1297776 0 4.80108e-07
iB00_1509_v n1_914656_1297616 0 -4.80108e-07
iB00_1510_v n1_952352_1297696 0 -1.29177e-06
iB00_1511_v n1_991264_1297696 0 -6.43303e-07
iB00_1512_v n1_952352_1297776 0 6.48469e-07
iB00_1513_v n1_952352_1297616 0 -6.48469e-07
iB00_1514_v n1_952352_1261216 0 9.051760000000001e-06
iB00_1515_v n1_952352_1336688 0 8.70338e-07
iB00_1516_v n1_952352_1336528 0 -8.70338e-07
iB00_1517_v n1_991264_1336688 0 1.01391e-06
iB00_1518_v n1_991264_1336528 0 -1.01391e-06
iB00_1519_v n1_991264_1261216 0 9.07401e-06
iB00_1520_v n1_991264_1297776 0 7.89071e-07
iB00_1521_v n1_991264_1297616 0 -7.89071e-07
iB00_1522_v n1_1028960_1297696 0 1.4576899999999999e-07
iB00_1523_v n1_1067872_1297696 0 5.71462e-07
iB00_1524_v n1_1028960_1297776 0 4.2569299999999997e-07
iB00_1525_v n1_1028960_1297616 0 -4.2569299999999997e-07
iB00_1526_v n1_1028960_1261216 0 8.87019e-06
iB00_1527_v n1_1028960_1336688 0 7.93527e-07
iB00_1528_v n1_1028960_1336528 0 -7.93527e-07
iB00_1529_v n1_1067872_1336688 0 5.37406e-07
iB00_1530_v n1_1067872_1336528 0 -5.37406e-07
iB00_1531_v n1_1067872_1261216 0 8.07972e-06
iB00_1532_v n1_1067872_1297776 0 4.75168e-07
iB00_1533_v n1_1067872_1297616 0 -4.75168e-07
iB00_1534_v n1_1105568_1297696 0 1.04663e-06
iB00_1535_v n1_1144480_1297696 0 1.2643299999999999e-06
iB00_1536_v n1_1105568_1297776 0 2.17705e-07
iB00_1537_v n1_1105568_1297616 0 -2.17705e-07
iB00_1538_v n1_1105568_1261216 0 7.28096e-06
iB00_1539_v n1_1105568_1336688 0 3.1400299999999996e-07
iB00_1540_v n1_1105568_1336528 0 -3.1400299999999996e-07
iB00_1541_v n1_1144480_1336688 0 -1.09676e-08
iB00_1542_v n1_1144480_1336528 0 1.09676e-08
iB00_1543_v n1_1144480_1261216 0 6.16521e-06
iB00_1544_v n1_1144480_1297776 0 -9.74915e-10
iB00_1545_v n1_1144480_1297616 0 9.74915e-10
iB00_1546_v n1_1182176_1297696 0 1.26336e-06
iB00_1547_v n1_1219872_1297696 0 1.13772e-06
iB00_1548_v n1_1182176_1297776 0 -1.25638e-07
iB00_1549_v n1_1182176_1297616 0 1.25638e-07
iB00_1550_v n1_1182176_1261216 0 5.33034e-06
iB00_1551_v n1_1182176_1336688 0 -2.0741e-07
iB00_1552_v n1_1182176_1336528 0 2.0741e-07
iB00_1553_v n1_1219872_1336688 0 -3.31025e-07
iB00_1554_v n1_1219872_1336528 0 3.31025e-07
iB00_1555_v n1_1219872_1261216 0 4.2678899999999996e-06
iB00_1556_v n1_1219872_1297776 0 -1.87154e-07
iB00_1557_v n1_1219872_1297616 0 1.87154e-07
iB00_1558_v n1_1258784_1297696 0 9.50568e-07
iB00_1559_v n1_1296480_1297696 0 4.33447e-07
iB00_1560_v n1_1258784_1297776 0 -5.17122e-07
iB00_1561_v n1_1258784_1297616 0 5.17122e-07
iB00_1562_v n1_1258784_1261216 0 3.26015e-06
iB00_1563_v n1_1258784_1336688 0 -5.25392e-07
iB00_1564_v n1_1258784_1336528 0 5.25392e-07
iB00_1565_v n1_1296480_1336688 0 -5.12523e-07
iB00_1566_v n1_1296480_1336528 0 5.12523e-07
iB00_1567_v n1_1296480_1261216 0 2.5754799999999996e-06
iB00_1568_v n1_1296480_1297776 0 -4.7929e-07
iB00_1569_v n1_1296480_1297616 0 4.7929e-07
iB00_1570_v n1_1335392_1297696 0 -4.58432e-08
iB00_1571_v n1_1373088_1297696 0 -5.61662e-07
iB00_1572_v n1_1335392_1297776 0 -5.15819e-07
iB00_1573_v n1_1335392_1297616 0 5.15819e-07
iB00_1574_v n1_1335392_1261216 0 1.88192e-06
iB00_1575_v n1_1335392_1336688 0 -6.15885e-07
iB00_1576_v n1_1335392_1336528 0 6.15885e-07
iB00_1577_v n1_1373088_1336688 0 -5.62531e-07
iB00_1578_v n1_1373088_1336528 0 5.62531e-07
iB00_1579_v n1_1373088_1261216 0 1.4215e-06
iB00_1580_v n1_1373088_1297776 0 -3.84134e-07
iB00_1581_v n1_1373088_1297616 0 3.84134e-07
iB00_1582_v n1_1412000_1297696 0 -9.45796e-07
iB00_1583_v n1_1449696_1297696 0 -1.32292e-06
iB00_1584_v n1_1412000_1297776 0 -3.77126e-07
iB00_1585_v n1_1412000_1297616 0 3.77126e-07
iB00_1586_v n1_1412000_1261216 0 1.07775e-06
iB00_1587_v n1_1412000_1336688 0 -4.848750000000001e-07
iB00_1588_v n1_1412000_1336528 0 4.848750000000001e-07
iB00_1589_v n1_1449696_1336688 0 -4.9414e-07
iB00_1590_v n1_1449696_1336528 0 4.9414e-07
iB00_1591_v n1_1449696_1261216 0 9.50785e-07
iB00_1592_v n1_1449696_1297776 0 -4.823079999999999e-07
iB00_1593_v n1_1449696_1297616 0 4.823079999999999e-07
iB00_1594_v n1_1487392_1297696 0 -1.8052299999999999e-06
iB00_1595_v n1_1526304_1297696 0 -2.06801e-06
iB00_1596_v n1_1487392_1297776 0 -2.6278000000000003e-07
iB00_1597_v n1_1487392_1297616 0 2.6278000000000003e-07
iB00_1598_v n1_1487392_1261216 0 8.71301e-07
iB00_1599_v n1_1487392_1336688 0 -2.99484e-07
iB00_1600_v n1_1487392_1336528 0 2.99484e-07
iB00_1601_v n1_1526304_1336688 0 -2.07553e-07
iB00_1602_v n1_1526304_1336528 0 2.07553e-07
iB00_1603_v n1_1526304_1261216 0 8.97455e-07
iB00_1604_v n1_1526304_1297776 0 -1.93126e-07
iB00_1605_v n1_1526304_1297616 0 1.93126e-07
iB00_1606_v n1_1564000_1297696 0 -2.26114e-06
iB00_1607_v n1_1602912_1297696 0 -2.27685e-06
iB00_1608_v n1_1564000_1297776 0 -1.5715200000000003e-08
iB00_1609_v n1_1564000_1297616 0 1.5715200000000003e-08
iB00_1610_v n1_1564000_1261216 0 9.39766e-07
iB00_1611_v n1_1564000_1336688 0 -1.43361e-07
iB00_1612_v n1_1564000_1336528 0 1.43361e-07
iB00_1613_v n1_1641180_1336608 0 -2.27936e-06
iB00_1614_v n1_1602912_1336688 0 1.86225e-07
iB00_1615_v n1_1602912_1336528 0 -1.86225e-07
iB00_1616_v n1_1602912_1261216 0 1.01457e-06
iB00_1617_v n1_1602912_1297776 0 5.68112e-08
iB00_1618_v n1_1602912_1297616 0 -5.68112e-08
iB00_1619_v n1_1641180_1297696 0 -2.2200399999999998e-06
iB00_1620_v n1_1641290_1297696 0 0.0
iB00_1621_v n1_1641070_1297696 0 2.2200399999999998e-06
iB00_1622_v n1_1641180_1261216 0 2.37602e-06
iB00_1623_v n1_1641070_1336608 0 2.27935e-06
iB00_1624_v n1_1641290_1336608 0 -2.27935e-06
iB00_1625_v n1_1641070_1373088 0 2.41208e-06
iB00_1626_v n1_1641290_1373088 0 -2.41208e-06
iB00_1627_v n1_1641180_1222304 0 2.41864e-07
iB00_1628_v n1_1641070_1261216 0 2.13415e-06
iB00_1629_v n1_1641290_1261216 0 -2.13415e-06
iB00_1630_v n1_1602912_1261296 0 1.0626800000000001e-07
iB00_1631_v n1_1602912_1261136 0 -1.0626800000000001e-07
iB00_1632_v n1_1602912_1222304 0 2.51853e-08
iB00_1633_v n1_1602912_1183392 0 -9.37908e-07
iB00_1634_v n1_1602912_1222384 0 1.31543e-07
iB00_1635_v n1_1602912_1222224 0 -1.31543e-07
iB00_1636_v n1_1564000_1222304 0 2.2151200000000003e-06
iB00_1637_v n1_1526304_1222304 0 2.2519e-06
iB00_1638_v n1_1564000_1222384 0 3.6776500000000005e-08
iB00_1639_v n1_1564000_1222224 0 -3.6776500000000005e-08
iB00_1640_v n1_1564000_1183392 0 -9.699869999999999e-07
iB00_1641_v n1_1564000_1261296 0 -5.54418e-10
iB00_1642_v n1_1564000_1261136 0 5.54418e-10
iB00_1643_v n1_1526304_1261296 0 -1.8459300000000002e-07
iB00_1644_v n1_1526304_1261136 0 1.8459300000000002e-07
iB00_1645_v n1_1526304_1183392 0 -7.40036e-07
iB00_1646_v n1_1526304_1222384 0 -1.07681e-07
iB00_1647_v n1_1526304_1222224 0 1.07681e-07
iB00_1648_v n1_1487392_1222304 0 2.14422e-06
iB00_1649_v n1_1449696_1222304 0 1.91718e-06
iB00_1650_v n1_1487392_1222384 0 -2.27032e-07
iB00_1651_v n1_1487392_1222224 0 2.27032e-07
iB00_1652_v n1_1487392_1183392 0 -5.994480000000001e-07
iB00_1653_v n1_1487392_1261296 0 -2.10084e-07
iB00_1654_v n1_1487392_1261136 0 2.10084e-07
iB00_1655_v n1_1449696_1261296 0 -4.58437e-07
iB00_1656_v n1_1449696_1261136 0 4.58437e-07
iB00_1657_v n1_1449696_1183392 0 -3.78243e-07
iB00_1658_v n1_1449696_1222384 0 -3.51516e-07
iB00_1659_v n1_1449696_1222224 0 3.51516e-07
iB00_1660_v n1_1412000_1222304 0 1.56567e-06
iB00_1661_v n1_1373088_1222304 0 1.31799e-06
iB00_1662_v n1_1412000_1222384 0 -2.4767499999999997e-07
iB00_1663_v n1_1412000_1222224 0 2.4767499999999997e-07
iB00_1664_v n1_1412000_1183392 0 5.47983e-08
iB00_1665_v n1_1412000_1261296 0 -2.73546e-07
iB00_1666_v n1_1412000_1261136 0 2.73546e-07
iB00_1667_v n1_1373088_1261296 0 -3.20084e-07
iB00_1668_v n1_1373088_1261136 0 3.20084e-07
iB00_1669_v n1_1373088_1183392 0 5.880189999999999e-07
iB00_1670_v n1_1373088_1222384 0 -2.60164e-07
iB00_1671_v n1_1373088_1222224 0 2.60164e-07
iB00_1672_v n1_1335392_1222304 0 1.05783e-06
iB00_1673_v n1_1296480_1222304 0 7.417940000000001e-07
iB00_1674_v n1_1335392_1222384 0 -3.16035e-07
iB00_1675_v n1_1335392_1222224 0 3.16035e-07
iB00_1676_v n1_1335392_1183392 0 1.11039e-06
iB00_1677_v n1_1335392_1261296 0 -4.09504e-07
iB00_1678_v n1_1335392_1261136 0 4.09504e-07
iB00_1679_v n1_1296480_1261296 0 -4.7286799999999997e-07
iB00_1680_v n1_1296480_1261136 0 4.7286799999999997e-07
iB00_1681_v n1_1296480_1183392 0 1.62735e-06
iB00_1682_v n1_1296480_1222384 0 -5.15785e-07
iB00_1683_v n1_1296480_1222224 0 5.15785e-07
iB00_1684_v n1_1258784_1222304 0 2.2601000000000002e-07
iB00_1685_v n1_1219872_1222304 0 -3.6019600000000002e-09
iB00_1686_v n1_1258784_1222384 0 -2.29612e-07
iB00_1687_v n1_1258784_1222224 0 2.29612e-07
iB00_1688_v n1_1258784_1183392 0 2.49161e-06
iB00_1689_v n1_1258784_1261296 0 -3.70541e-07
iB00_1690_v n1_1258784_1261136 0 3.70541e-07
iB00_1691_v n1_1219872_1261296 0 -1.4381100000000002e-07
iB00_1692_v n1_1219872_1261136 0 1.4381100000000002e-07
iB00_1693_v n1_1219872_1183392 0 3.16994e-06
iB00_1694_v n1_1219872_1222384 0 -1.9013100000000002e-07
iB00_1695_v n1_1219872_1222224 0 1.9013100000000002e-07
iB00_1696_v n1_1182176_1222304 0 -1.93733e-07
iB00_1697_v n1_1144480_1222304 0 -3.4186399999999997e-07
iB00_1698_v n1_1182176_1222384 0 -1.4813200000000002e-07
iB00_1699_v n1_1182176_1222224 0 1.4813200000000002e-07
iB00_1700_v n1_1182176_1183392 0 3.90505e-06
iB00_1701_v n1_1182176_1261296 0 -2.40054e-07
iB00_1702_v n1_1182176_1261136 0 2.40054e-07
iB00_1703_v n1_1144480_1261296 0 1.2270499999999999e-07
iB00_1704_v n1_1144480_1261136 0 -1.2270499999999999e-07
iB00_1705_v n1_1144480_1183392 0 4.69538e-06
iB00_1706_v n1_1144480_1222384 0 9.45435e-08
iB00_1707_v n1_1144480_1222224 0 -9.45435e-08
iB00_1708_v n1_1105568_1222304 0 -2.4731999999999997e-07
iB00_1709_v n1_1067872_1222304 0 -2.37891e-07
iB00_1710_v n1_1105568_1222384 0 9.42892e-09
iB00_1711_v n1_1105568_1222224 0 -9.42892e-09
iB00_1712_v n1_1105568_1183392 0 5.3597000000000005e-06
iB00_1713_v n1_1105568_1261296 0 7.58716e-08
iB00_1714_v n1_1105568_1261136 0 -7.58716e-08
iB00_1715_v n1_1067872_1261296 0 4.58584e-07
iB00_1716_v n1_1067872_1261136 0 -4.58584e-07
iB00_1717_v n1_1067872_1183392 0 6.06273e-06
iB00_1718_v n1_1067872_1222384 0 2.73628e-07
iB00_1719_v n1_1067872_1222224 0 -2.73628e-07
iB00_1720_v n1_1028960_1222304 0 3.57375e-08
iB00_1721_v n1_991264_1222304 0 2.0870400000000001e-07
iB00_1722_v n1_1028960_1222384 0 1.7296600000000002e-07
iB00_1723_v n1_1028960_1222224 0 -1.7296600000000002e-07
iB00_1724_v n1_1028960_1183392 0 6.430370000000001e-06
iB00_1725_v n1_1028960_1261296 0 1.4318800000000002e-07
iB00_1726_v n1_1028960_1261136 0 -1.4318800000000002e-07
iB00_1727_v n1_991264_1261296 0 6.75767e-07
iB00_1728_v n1_991264_1261136 0 -6.75767e-07
iB00_1729_v n1_991264_1183392 0 6.80433e-06
iB00_1730_v n1_991264_1222384 0 4.04517e-07
iB00_1731_v n1_991264_1222224 0 -4.04517e-07
iB00_1732_v n1_952352_1222304 0 6.13221e-07
iB00_1733_v n1_914656_1222304 0 9.02865e-07
iB00_1734_v n1_952352_1222384 0 2.89644e-07
iB00_1735_v n1_952352_1222224 0 -2.89644e-07
iB00_1736_v n1_952352_1183392 0 6.768780000000001e-06
iB00_1737_v n1_952352_1261296 0 4.4838700000000003e-07
iB00_1738_v n1_952352_1261136 0 -4.4838700000000003e-07
iB00_1739_v n1_914656_1261296 0 3.82772e-07
iB00_1740_v n1_914656_1261136 0 -3.82772e-07
iB00_1741_v n1_914656_1183392 0 6.67967e-06
iB00_1742_v n1_914656_1222384 0 3.02364e-07
iB00_1743_v n1_914656_1222224 0 -3.02364e-07
iB00_1744_v n1_876960_1222304 0 1.20523e-06
iB00_1745_v n1_876960_1222384 0 9.085610000000001e-08
iB00_1746_v n1_876960_1222224 0 -9.085610000000001e-08
iB00_1747_v n1_876960_1183392 0 6.26452e-06
iB00_1748_v n1_876960_1261296 0 2.22126e-07
iB00_1749_v n1_876960_1261136 0 -2.22126e-07
iB00_1750_v n1_838048_1261296 0 1.7621999999999997e-08
iB00_1751_v n1_838048_1261136 0 -1.7621999999999997e-08
iB00_1752_v n1_838048_1222384 0 6.03684e-11
iB00_1753_v n1_838048_1222224 0 -6.03684e-11
iB00_1754_v n1_838048_1183472 0 -2.32925e-08
iB00_1755_v n1_838048_1183312 0 2.32925e-08
iB00_1756_v n1_876960_1183472 0 1.6131199999999998e-08
iB00_1757_v n1_876960_1183312 0 -1.6131199999999998e-08
iB00_1758_v n1_876960_1146912 0 5.528179999999999e-06
iB00_1759_v n1_876960_1108000 0 4.8977e-06
iB00_1760_v n1_876960_1146992 0 -7.50927e-08
iB00_1761_v n1_876960_1146832 0 7.50927e-08
iB00_1762_v n1_914656_1146912 0 -8.2084e-07
iB00_1763_v n1_838048_1146992 0 1.44787e-08
iB00_1764_v n1_838048_1146832 0 -1.44787e-08
iB00_1765_v n1_838048_1108080 0 -1.89373e-08
iB00_1766_v n1_838048_1107920 0 1.89373e-08
iB00_1767_v n1_914656_1108000 0 -6.96145e-07
iB00_1768_v n1_876960_1108080 0 -1.28607e-07
iB00_1769_v n1_876960_1107920 0 1.28607e-07
iB00_1770_v n1_876960_1071520 0 4.27809e-06
iB00_1771_v n1_876960_1032608 0 3.81919e-06
iB00_1772_v n1_876960_1071600 0 -1.23328e-07
iB00_1773_v n1_876960_1071440 0 1.23328e-07
iB00_1774_v n1_914656_1071520 0 -6.002950000000001e-07
iB00_1775_v n1_838048_1071600 0 -1.07938e-07
iB00_1776_v n1_838048_1071440 0 1.07938e-07
iB00_1777_v n1_838048_1032688 0 -2.11676e-07
iB00_1778_v n1_838048_1032528 0 2.11676e-07
iB00_1779_v n1_914656_1032608 0 -5.32103e-07
iB00_1780_v n1_876960_1032688 0 -1.37982e-07
iB00_1781_v n1_876960_1032528 0 1.37982e-07
iB00_1782_v n1_876960_993696 0 3.3002299999999997e-06
iB00_1783_v n1_876960_957216 0 2.8668000000000002e-06
iB00_1784_v n1_876960_993776 0 -2.09769e-07
iB00_1785_v n1_876960_993616 0 2.09769e-07
iB00_1786_v n1_914656_993696 0 -5.40905e-07
iB00_1787_v n1_838048_993776 0 -2.36595e-07
iB00_1788_v n1_838048_993616 0 2.36595e-07
iB00_1789_v n1_838048_957296 0 -2.7536500000000003e-07
iB00_1790_v n1_838048_957136 0 2.7536500000000003e-07
iB00_1791_v n1_914656_957216 0 -5.726149999999999e-07
iB00_1792_v n1_876960_957296 0 -2.83366e-07
iB00_1793_v n1_876960_957136 0 2.83366e-07
iB00_1794_v n1_876960_918304 0 2.47263e-06
iB00_1795_v n1_876960_881824 0 2.08384e-06
iB00_1796_v n1_876960_918384 0 -3.26665e-07
iB00_1797_v n1_876960_918224 0 3.26665e-07
iB00_1798_v n1_914656_918304 0 -6.06607e-07
iB00_1799_v n1_838048_918384 0 -3.25594e-07
iB00_1800_v n1_838048_918224 0 3.25594e-07
iB00_1801_v n1_838048_881904 0 -2.9158800000000003e-07
iB00_1802_v n1_838048_881744 0 2.9158800000000003e-07
iB00_1803_v n1_914656_881824 0 -6.073199999999999e-07
iB00_1804_v n1_876960_881904 0 -3.35646e-07
iB00_1805_v n1_876960_881744 0 3.35646e-07
iB00_1806_v n1_876960_842912 0 1.7596599999999998e-06
iB00_1807_v n1_876960_804000 0 1.34069e-06
iB00_1808_v n1_876960_842992 0 -3.33916e-07
iB00_1809_v n1_876960_842832 0 3.33916e-07
iB00_1810_v n1_914656_842912 0 -6.348810000000001e-07
iB00_1811_v n1_838048_842992 0 -3.44301e-07
iB00_1812_v n1_838048_842832 0 3.44301e-07
iB00_1813_v n1_838048_767520 0 1.1592e-06
iB00_1814_v n1_838048_804080 0 -3.58529e-07
iB00_1815_v n1_838048_803920 0 3.58529e-07
iB00_1816_v n1_914656_804000 0 -6.59957e-07
iB00_1817_v n1_876960_804080 0 -2.92757e-07
iB00_1818_v n1_876960_803920 0 2.92757e-07
iB00_1819_v n1_876960_767520 0 1.0584800000000002e-06
iB00_1820_v n1_876960_728608 0 7.75336e-07
iB00_1821_v n1_876960_767600 0 -3.31246e-07
iB00_1822_v n1_876960_767440 0 3.31246e-07
iB00_1823_v n1_914656_767520 0 -7.47499e-07
iB00_1824_v n1_838048_767600 0 -3.10497e-07
iB00_1825_v n1_838048_767440 0 3.10497e-07
iB00_1826_v n1_838048_728608 0 9.33015e-07
iB00_1827_v n1_838048_692128 0 6.26062e-07
iB00_1828_v n1_838048_728688 0 -3.65915e-07
iB00_1829_v n1_838048_728528 0 3.65915e-07
iB00_1830_v n1_800352_728608 0 1.32248e-07
iB00_1831_v n1_800352_728688 0 -3.81329e-07
iB00_1832_v n1_800352_728528 0 3.81329e-07
iB00_1833_v n1_800352_692128 0 8.09018e-07
iB00_1834_v n1_800352_767600 0 -4.29334e-07
iB00_1835_v n1_800352_767440 0 4.29334e-07
iB00_1836_v n1_800352_653216 0 3.12496e-07
iB00_1837_v n1_800352_692208 0 -4.72088e-07
iB00_1838_v n1_800352_692048 0 4.72088e-07
iB00_1839_v n1_761440_692208 0 -2.84573e-07
iB00_1840_v n1_761440_692048 0 2.84573e-07
iB00_1841_v n1_761440_728688 0 -3.9007e-07
iB00_1842_v n1_761440_728528 0 3.9007e-07
iB00_1843_v n1_761440_653296 0 -2.81651e-07
iB00_1844_v n1_761440_653136 0 2.81651e-07
iB00_1845_v n1_838048_653216 0 -2.6585399999999997e-07
iB00_1846_v n1_800352_653296 0 -4.17576e-07
iB00_1847_v n1_800352_653136 0 4.17576e-07
iB00_1848_v n1_800352_614304 0 3.52023e-08
iB00_1849_v n1_800352_577824 0 -1.99385e-07
iB00_1850_v n1_800352_614384 0 -3.43275e-07
iB00_1851_v n1_800352_614224 0 3.43275e-07
iB00_1852_v n1_838048_614304 0 -3.06454e-07
iB00_1853_v n1_761440_614384 0 -2.85647e-07
iB00_1854_v n1_761440_614224 0 2.85647e-07
iB00_1855_v n1_761440_577904 0 -3.49236e-07
iB00_1856_v n1_761440_577744 0 3.49236e-07
iB00_1857_v n1_838048_577824 0 -3.34404e-07
iB00_1858_v n1_800352_577904 0 -2.68606e-07
iB00_1859_v n1_800352_577744 0 2.68606e-07
iB00_1860_v n1_800352_538912 0 -4.20228e-07
iB00_1861_v n1_800352_502432 0 -6.37381e-07
iB00_1862_v n1_800352_538992 0 -2.7708900000000003e-07
iB00_1863_v n1_800352_538832 0 2.7708900000000003e-07
iB00_1864_v n1_838048_538912 0 -3.88378e-07
iB00_1865_v n1_761440_538992 0 -2.9248099999999996e-07
iB00_1866_v n1_761440_538832 0 2.9248099999999996e-07
iB00_1867_v n1_761440_480880 0 -5.61448e-07
iB00_1868_v n1_761440_502512 0 -2.64285e-07
iB00_1869_v n1_761440_502352 0 2.64285e-07
iB00_1870_v n1_838048_502432 0 -4.84663e-07
iB00_1871_v n1_800352_502512 0 -3.5300700000000003e-07
iB00_1872_v n1_800352_502352 0 3.5300700000000003e-07
iB00_1873_v n1_800352_480880 0 -6.584130000000001e-07
iB00_1874_v n1_800352_480720 0 -2.38524e-17
iB00_1875_v n1_800352_481040 0 -6.584130000000001e-07
iB00_1876_v n1_838048_480880 0 -9.77524e-07
iB00_1877_v n1_761440_481040 0 -5.61447e-07
iB00_1878_v n1_761440_480720 0 5.61447e-07
iB00_1879_v n1_723744_481040 0 -5.228589999999999e-07
iB00_1880_v n1_723744_480720 0 5.228589999999999e-07
iB00_1881_v n1_876960_480880 0 -1.6497400000000001e-06
iB00_1882_v n1_838048_481040 0 -6.72214e-07
iB00_1883_v n1_838048_480720 0 6.72214e-07
iB00_1884_v n1_838048_502512 0 -3.17237e-07
iB00_1885_v n1_838048_502352 0 3.17237e-07
iB00_1886_v n1_876960_502432 0 -8.019e-07
iB00_1887_v n1_914656_502432 0 -1.18763e-06
iB00_1888_v n1_876960_502512 0 -3.85732e-07
iB00_1889_v n1_876960_502352 0 3.85732e-07
iB00_1890_v n1_876960_538912 0 8.63301e-07
iB00_1891_v n1_876960_577824 0 5.522e-07
iB00_1892_v n1_876960_538992 0 -3.8115099999999997e-07
iB00_1893_v n1_876960_538832 0 3.8115099999999997e-07
iB00_1894_v n1_914656_538912 0 -1.1663000000000002e-06
iB00_1895_v n1_838048_538992 0 -3.96772e-07
iB00_1896_v n1_838048_538832 0 3.96772e-07
iB00_1897_v n1_838048_577904 0 -4.34475e-07
iB00_1898_v n1_838048_577744 0 4.34475e-07
iB00_1899_v n1_914656_577824 0 -1.09284e-06
iB00_1900_v n1_876960_577904 0 -3.23959e-07
iB00_1901_v n1_876960_577744 0 3.23959e-07
iB00_1902_v n1_876960_614304 0 3.80966e-07
iB00_1903_v n1_876960_653216 0 1.89663e-07
iB00_1904_v n1_876960_614384 0 -3.13386e-07
iB00_1905_v n1_876960_614224 0 3.13386e-07
iB00_1906_v n1_914656_614304 0 -1.0209100000000001e-06
iB00_1907_v n1_838048_614384 0 -4.0107000000000003e-07
iB00_1908_v n1_838048_614224 0 4.0107000000000003e-07
iB00_1909_v n1_838048_653296 0 -3.64189e-07
iB00_1910_v n1_838048_653136 0 3.64189e-07
iB00_1911_v n1_914656_653216 0 -9.60679e-07
iB00_1912_v n1_876960_653296 0 -3.30637e-07
iB00_1913_v n1_876960_653136 0 3.30637e-07
iB00_1914_v n1_876960_692128 0 -1.2023600000000002e-07
iB00_1915_v n1_876960_692208 0 -3.438e-07
iB00_1916_v n1_876960_692048 0 3.438e-07
iB00_1917_v n1_914656_692128 0 -9.14296e-07
iB00_1918_v n1_838048_692208 0 -3.46273e-07
iB00_1919_v n1_838048_692048 0 3.46273e-07
iB00_1920_v n1_952352_692128 0 -1.2456200000000001e-06
iB00_1921_v n1_914656_692208 0 -3.31327e-07
iB00_1922_v n1_914656_692048 0 3.31327e-07
iB00_1923_v n1_914656_728608 0 -3.48331e-07
iB00_1924_v n1_914656_728688 0 -2.98048e-07
iB00_1925_v n1_914656_728528 0 2.98048e-07
iB00_1926_v n1_952352_728608 0 -1.1473900000000002e-06
iB00_1927_v n1_876960_728688 0 -3.51179e-07
iB00_1928_v n1_876960_728528 0 3.51179e-07
iB00_1929_v n1_991264_728608 0 -1.53743e-06
iB00_1930_v n1_952352_728688 0 -3.90037e-07
iB00_1931_v n1_952352_728528 0 3.90037e-07
iB00_1932_v n1_952352_767520 0 -4.84197e-07
iB00_1933_v n1_952352_804000 0 -7.56669e-07
iB00_1934_v n1_952352_767600 0 -3.17174e-07
iB00_1935_v n1_952352_767440 0 3.17174e-07
iB00_1936_v n1_991264_767520 0 -1.41029e-06
iB00_1937_v n1_914656_767600 0 -3.4561200000000004e-07
iB00_1938_v n1_914656_767440 0 3.4561200000000004e-07
iB00_1939_v n1_914656_804080 0 -3.6896699999999997e-07
iB00_1940_v n1_914656_803920 0 3.6896699999999997e-07
iB00_1941_v n1_991264_804000 0 -1.32464e-06
iB00_1942_v n1_952352_804080 0 -2.95714e-07
iB00_1943_v n1_952352_803920 0 2.95714e-07
iB00_1944_v n1_952352_842912 0 -1.14951e-06
iB00_1945_v n1_952352_881824 0 -1.50879e-06
iB00_1946_v n1_952352_842992 0 -2.92963e-07
iB00_1947_v n1_952352_842832 0 2.92963e-07
iB00_1948_v n1_991264_842912 0 -1.2444400000000002e-06
iB00_1949_v n1_914656_842992 0 -3.16597e-07
iB00_1950_v n1_914656_842832 0 3.16597e-07
iB00_1951_v n1_914656_881904 0 -2.3719e-07
iB00_1952_v n1_914656_881744 0 2.3719e-07
iB00_1953_v n1_991264_881824 0 -1.07964e-06
iB00_1954_v n1_952352_881904 0 -2.35126e-07
iB00_1955_v n1_952352_881744 0 2.35126e-07
iB00_1956_v n1_952352_918304 0 -1.93023e-06
iB00_1957_v n1_952352_957216 0 -2.38379e-06
iB00_1958_v n1_952352_918384 0 -2.40494e-07
iB00_1959_v n1_952352_918224 0 2.40494e-07
iB00_1960_v n1_991264_918304 0 -1.0084899999999999e-06
iB00_1961_v n1_914656_918384 0 -1.6139e-07
iB00_1962_v n1_914656_918224 0 1.6139e-07
iB00_1963_v n1_914656_957296 0 -1.81734e-07
iB00_1964_v n1_914656_957136 0 1.81734e-07
iB00_1965_v n1_991264_957216 0 -9.39272e-07
iB00_1966_v n1_952352_957296 0 -1.84924e-07
iB00_1967_v n1_952352_957136 0 1.84924e-07
iB00_1968_v n1_952352_993696 0 -2.81292e-06
iB00_1969_v n1_952352_1032608 0 -3.2829600000000003e-06
iB00_1970_v n1_952352_993776 0 -1.4003600000000002e-07
iB00_1971_v n1_952352_993616 0 1.4003600000000002e-07
iB00_1972_v n1_991264_993696 0 -8.99012e-07
iB00_1973_v n1_914656_993776 0 -2.18071e-07
iB00_1974_v n1_914656_993616 0 2.18071e-07
iB00_1975_v n1_914656_1032688 0 -2.26412e-07
iB00_1976_v n1_914656_1032528 0 2.26412e-07
iB00_1977_v n1_991264_1032608 0 -8.62227e-07
iB00_1978_v n1_952352_1032688 0 -1.03713e-07
iB00_1979_v n1_952352_1032528 0 1.03713e-07
iB00_1980_v n1_952352_1071520 0 -3.88829e-06
iB00_1981_v n1_952352_1108000 0 -4.488619999999999e-06
iB00_1982_v n1_952352_1071600 0 -3.50851e-08
iB00_1983_v n1_952352_1071440 0 3.50851e-08
iB00_1984_v n1_991264_1071520 0 -7.6246e-07
iB00_1985_v n1_914656_1071600 0 -1.2708e-07
iB00_1986_v n1_914656_1071440 0 1.2708e-07
iB00_1987_v n1_914656_1108080 0 -4.1217000000000004e-08
iB00_1988_v n1_914656_1107920 0 4.1217000000000004e-08
iB00_1989_v n1_991264_1108000 0 -7.16677e-07
iB00_1990_v n1_952352_1108080 0 2.06848e-08
iB00_1991_v n1_952352_1107920 0 -2.06848e-08
iB00_1992_v n1_952352_1146912 0 -5.20023e-06
iB00_1993_v n1_952352_1146992 0 1.10754e-07
iB00_1994_v n1_952352_1146832 0 -1.10754e-07
iB00_1995_v n1_991264_1146912 0 -6.64138e-07
iB00_1996_v n1_914656_1146992 0 4.59476e-08
iB00_1997_v n1_914656_1146832 0 -4.59476e-08
iB00_1998_v n1_914656_1183472 0 1.27525e-07
iB00_1999_v n1_914656_1183312 0 -1.27525e-07
iB00_2000_v n1_952352_1183472 0 2.60326e-07
iB00_2001_v n1_952352_1183312 0 -2.60326e-07
iB00_2002_v n1_991264_1183472 0 1.85517e-07
iB00_2003_v n1_991264_1183312 0 -1.85517e-07
iB00_2004_v n1_991264_1146992 0 1.1445799999999999e-07
iB00_2005_v n1_991264_1146832 0 -1.1445799999999999e-07
iB00_2006_v n1_1028960_1146912 0 -5.49679e-07
iB00_2007_v n1_1067872_1146912 0 -4.71181e-07
iB00_2008_v n1_1028960_1146992 0 7.8498e-08
iB00_2009_v n1_1028960_1146832 0 -7.8498e-08
iB00_2010_v n1_1028960_1108000 0 4.77919e-06
iB00_2011_v n1_1028960_1183472 0 1.8252e-07
iB00_2012_v n1_1028960_1183312 0 -1.8252e-07
iB00_2013_v n1_1067872_1183472 0 8.76153e-08
iB00_2014_v n1_1067872_1183312 0 -8.76153e-08
iB00_2015_v n1_1067872_1108000 0 4.4961899999999996e-06
iB00_2016_v n1_1067872_1146992 0 8.771769999999999e-08
iB00_2017_v n1_1067872_1146832 0 -8.771769999999999e-08
iB00_2018_v n1_1105568_1146912 0 -3.83463e-07
iB00_2019_v n1_1144480_1146912 0 -3.48274e-07
iB00_2020_v n1_1105568_1146992 0 3.51889e-08
iB00_2021_v n1_1105568_1146832 0 -3.51889e-08
iB00_2022_v n1_1105568_1108000 0 4.008270000000001e-06
iB00_2023_v n1_1105568_1183472 0 4.13239e-08
iB00_2024_v n1_1105568_1183312 0 -4.13239e-08
iB00_2025_v n1_1144480_1183472 0 1.58314e-08
iB00_2026_v n1_1144480_1183312 0 -1.58314e-08
iB00_2027_v n1_1144480_1108000 0 3.42954e-06
iB00_2028_v n1_1144480_1146992 0 -6.948819999999999e-08
iB00_2029_v n1_1144480_1146832 0 6.948819999999999e-08
iB00_2030_v n1_1182176_1146912 0 -4.17762e-07
iB00_2031_v n1_1219872_1146912 0 -5.85589e-07
iB00_2032_v n1_1182176_1146992 0 -1.67827e-07
iB00_2033_v n1_1182176_1146832 0 1.67827e-07
iB00_2034_v n1_1182176_1108000 0 2.83689e-06
iB00_2035_v n1_1182176_1183472 0 -1.1851100000000001e-07
iB00_2036_v n1_1182176_1183312 0 1.1851100000000001e-07
iB00_2037_v n1_1219872_1183472 0 -1.48325e-07
iB00_2038_v n1_1219872_1183312 0 1.48325e-07
iB00_2039_v n1_1219872_1108000 0 2.21278e-06
iB00_2040_v n1_1219872_1146992 0 -1.0893200000000001e-07
iB00_2041_v n1_1219872_1146832 0 1.0893200000000001e-07
iB00_2042_v n1_1258784_1146912 0 -6.9452e-07
iB00_2043_v n1_1296480_1146912 0 -1.04808e-06
iB00_2044_v n1_1258784_1146992 0 -3.53557e-07
iB00_2045_v n1_1258784_1146832 0 3.53557e-07
iB00_2046_v n1_1258784_1108000 0 1.46963e-06
iB00_2047_v n1_1258784_1183472 0 -3.4067499999999997e-07
iB00_2048_v n1_1258784_1183312 0 3.4067499999999997e-07
iB00_2049_v n1_1296480_1183472 0 -3.2089199999999996e-07
iB00_2050_v n1_1296480_1183312 0 3.2089199999999996e-07
iB00_2051_v n1_1296480_1108000 0 7.66973e-07
iB00_2052_v n1_1296480_1146992 0 -2.89153e-07
iB00_2053_v n1_1296480_1146832 0 2.89153e-07
iB00_2054_v n1_1335392_1146912 0 -1.33723e-06
iB00_2055_v n1_1373088_1146912 0 -1.5819e-06
iB00_2056_v n1_1335392_1146992 0 -2.44666e-07
iB00_2057_v n1_1335392_1146832 0 2.44666e-07
iB00_2058_v n1_1335392_1108000 0 2.49501e-08
iB00_2059_v n1_1335392_1183472 0 -3.27595e-07
iB00_2060_v n1_1335392_1183312 0 3.27595e-07
iB00_2061_v n1_1373088_1183472 0 -2.57049e-07
iB00_2062_v n1_1373088_1183312 0 2.57049e-07
iB00_2063_v n1_1373088_1108000 0 -7.3246e-07
iB00_2064_v n1_1373088_1146992 0 -3.4705400000000003e-07
iB00_2065_v n1_1373088_1146832 0 3.4705400000000003e-07
iB00_2066_v n1_1412000_1146912 0 -1.92895e-06
iB00_2067_v n1_1449696_1146912 0 -2.08025e-06
iB00_2068_v n1_1412000_1146992 0 -1.51302e-07
iB00_2069_v n1_1412000_1146832 0 1.51302e-07
iB00_2070_v n1_1412000_1108000 0 -1.2584899999999998e-06
iB00_2071_v n1_1412000_1183472 0 -2.0289e-07
iB00_2072_v n1_1412000_1183312 0 2.0289e-07
iB00_2073_v n1_1449696_1183472 0 -2.37922e-07
iB00_2074_v n1_1449696_1183312 0 2.37922e-07
iB00_2075_v n1_1449696_1108000 0 -1.84383e-06
iB00_2076_v n1_1449696_1146992 0 -5.03979e-08
iB00_2077_v n1_1449696_1146832 0 5.03979e-08
iB00_2078_v n1_1487392_1146912 0 -2.13065e-06
iB00_2079_v n1_1526304_1146912 0 -2.44598e-06
iB00_2080_v n1_1487392_1146992 0 -3.1532700000000003e-07
iB00_2081_v n1_1487392_1146832 0 3.1532700000000003e-07
iB00_2082_v n1_1487392_1108000 0 -2.41028e-06
iB00_2083_v n1_1487392_1183472 0 -1.81447e-07
iB00_2084_v n1_1487392_1183312 0 1.81447e-07
iB00_2085_v n1_1526304_1183472 0 -1.57957e-07
iB00_2086_v n1_1526304_1183312 0 1.57957e-07
iB00_2087_v n1_1526304_1108000 0 -2.62884e-06
iB00_2088_v n1_1526304_1146992 0 3.6674800000000005e-08
iB00_2089_v n1_1526304_1146832 0 -3.6674800000000005e-08
iB00_2090_v n1_1564000_1146912 0 -2.4093e-06
iB00_2091_v n1_1602912_1146912 0 -2.2554e-06
iB00_2092_v n1_1564000_1146992 0 1.53905e-07
iB00_2093_v n1_1564000_1146832 0 -1.53905e-07
iB00_2094_v n1_1564000_1108000 0 -2.79895e-06
iB00_2095_v n1_1564000_1183472 0 1.7675e-07
iB00_2096_v n1_1564000_1183312 0 -1.7675e-07
iB00_2097_v n1_1641180_1183392 0 -2.07457e-06
iB00_2098_v n1_1602912_1183472 0 1.23886e-07
iB00_2099_v n1_1602912_1183312 0 -1.23886e-07
iB00_2100_v n1_1602912_1108000 0 -3.0210900000000003e-06
iB00_2101_v n1_1602912_1146992 0 2.1099099999999999e-07
iB00_2102_v n1_1602912_1146832 0 -2.1099099999999999e-07
iB00_2103_v n1_1641180_1146912 0 -2.04441e-06
iB00_2104_v n1_1641290_1146912 0 0.0
iB00_2105_v n1_1641070_1146912 0 2.04441e-06
iB00_2106_v n1_1641180_1108000 0 -5.9606900000000005e-06
iB00_2107_v n1_1641070_1183392 0 2.07457e-06
iB00_2108_v n1_1641290_1183392 0 -2.07457e-06
iB00_2109_v n1_1641070_1222304 0 2.0835799999999997e-06
iB00_2110_v n1_1641290_1222304 0 -2.0835799999999997e-06
iB00_2111_v n1_1641180_1071520 0 -7.98357e-06
iB00_2112_v n1_1641070_1108000 0 2.02288e-06
iB00_2113_v n1_1641290_1108000 0 -2.02288e-06
iB00_2114_v n1_1602912_1108080 0 3.4790899999999997e-07
iB00_2115_v n1_1602912_1107920 0 -3.4790899999999997e-07
iB00_2116_v n1_1602912_1071520 0 -3.97139e-06
iB00_2117_v n1_1602912_1032608 0 -4.75172e-06
iB00_2118_v n1_1602912_1071600 0 4.40468e-07
iB00_2119_v n1_1602912_1071440 0 -4.40468e-07
iB00_2120_v n1_1564000_1071520 0 2.47345e-06
iB00_2121_v n1_1526304_1071520 0 2.65541e-06
iB00_2122_v n1_1564000_1071600 0 1.81956e-07
iB00_2123_v n1_1564000_1071440 0 -1.81956e-07
iB00_2124_v n1_1564000_1032608 0 -4.53909e-06
iB00_2125_v n1_1564000_1108080 0 1.29729e-07
iB00_2126_v n1_1564000_1107920 0 -1.29729e-07
iB00_2127_v n1_1526304_1108080 0 5.89879e-08
iB00_2128_v n1_1526304_1107920 0 -5.89879e-08
iB00_2129_v n1_1526304_1032608 0 -4.14368e-06
iB00_2130_v n1_1526304_1071600 0 1.10541e-07
iB00_2131_v n1_1526304_1071440 0 -1.10541e-07
iB00_2132_v n1_1487392_1071520 0 2.76595e-06
iB00_2133_v n1_1449696_1071520 0 2.7459099999999997e-06
iB00_2134_v n1_1487392_1071600 0 -2.00433e-08
iB00_2135_v n1_1487392_1071440 0 2.00433e-08
iB00_2136_v n1_1487392_1032608 0 -3.6761300000000002e-06
iB00_2137_v n1_1487392_1108080 0 -1.25105e-07
iB00_2138_v n1_1487392_1107920 0 1.25105e-07
iB00_2139_v n1_1449696_1108080 0 -4.02716e-08
iB00_2140_v n1_1449696_1107920 0 4.02716e-08
iB00_2141_v n1_1449696_1032608 0 -3.13742e-06
iB00_2142_v n1_1449696_1071600 0 -9.24202e-08
iB00_2143_v n1_1449696_1071440 0 9.24202e-08
iB00_2144_v n1_1412000_1071520 0 2.6534900000000002e-06
iB00_2145_v n1_1373088_1071520 0 2.48881e-06
iB00_2146_v n1_1412000_1071600 0 -1.64672e-07
iB00_2147_v n1_1412000_1071440 0 1.64672e-07
iB00_2148_v n1_1412000_1032608 0 -2.45668e-06
iB00_2149_v n1_1412000_1108080 0 -1.91925e-07
iB00_2150_v n1_1412000_1107920 0 1.91925e-07
iB00_2151_v n1_1373088_1108080 0 -2.14161e-07
iB00_2152_v n1_1373088_1107920 0 2.14161e-07
iB00_2153_v n1_1373088_1032608 0 -1.7306500000000001e-06
iB00_2154_v n1_1373088_1071600 0 -1.66151e-07
iB00_2155_v n1_1373088_1071440 0 1.66151e-07
iB00_2156_v n1_1335392_1071520 0 2.32266e-06
iB00_2157_v n1_1296480_1071520 0 2.09179e-06
iB00_2158_v n1_1335392_1071600 0 -2.3087699999999998e-07
iB00_2159_v n1_1335392_1071440 0 2.3087699999999998e-07
iB00_2160_v n1_1335392_1032608 0 -1.05726e-06
iB00_2161_v n1_1335392_1108080 0 -2.65352e-07
iB00_2162_v n1_1335392_1107920 0 2.65352e-07
iB00_2163_v n1_1296480_1108080 0 -2.97826e-07
iB00_2164_v n1_1296480_1107920 0 2.97826e-07
iB00_2165_v n1_1296480_1032608 0 -3.0409e-07
iB00_2166_v n1_1296480_1071600 0 -3.3078300000000003e-07
iB00_2167_v n1_1296480_1071440 0 3.3078300000000003e-07
iB00_2168_v n1_1258784_1071520 0 1.761e-06
iB00_2169_v n1_1219872_1071520 0 1.42144e-06
iB00_2170_v n1_1258784_1071600 0 -3.39565e-07
iB00_2171_v n1_1258784_1071440 0 3.39565e-07
iB00_2172_v n1_1258784_1032608 0 3.53497e-07
iB00_2173_v n1_1258784_1108080 0 -3.44298e-07
iB00_2174_v n1_1258784_1107920 0 3.44298e-07
iB00_2175_v n1_1219872_1108080 0 -1.60316e-07
iB00_2176_v n1_1219872_1107920 0 1.60316e-07
iB00_2177_v n1_1219872_1032608 0 1.08313e-06
iB00_2178_v n1_1219872_1071600 0 -1.23595e-07
iB00_2179_v n1_1219872_1071440 0 1.23595e-07
iB00_2180_v n1_1182176_1071520 0 1.29784e-06
iB00_2181_v n1_1144480_1071520 0 1.05245e-06
iB00_2182_v n1_1182176_1071600 0 -2.45389e-07
iB00_2183_v n1_1182176_1071440 0 2.45389e-07
iB00_2184_v n1_1182176_1032608 0 1.66728e-06
iB00_2185_v n1_1182176_1108080 0 -1.84694e-07
iB00_2186_v n1_1182176_1107920 0 1.84694e-07
iB00_2187_v n1_1144480_1108080 0 -8.665079999999999e-08
iB00_2188_v n1_1144480_1107920 0 8.665079999999999e-08
iB00_2189_v n1_1144480_1032608 0 2.33863e-06
iB00_2190_v n1_1144480_1071600 0 -1.35017e-07
iB00_2191_v n1_1144480_1071440 0 1.35017e-07
iB00_2192_v n1_1105568_1071520 0 9.17437e-07
iB00_2193_v n1_1067872_1071520 0 8.80855e-07
iB00_2194_v n1_1105568_1071600 0 -3.6581800000000005e-08
iB00_2195_v n1_1105568_1071440 0 3.6581800000000005e-08
iB00_2196_v n1_1105568_1032608 0 2.83647e-06
iB00_2197_v n1_1105568_1108080 0 -3.80737e-09
iB00_2198_v n1_1105568_1107920 0 3.80737e-09
iB00_2199_v n1_1067872_1108080 0 -2.69132e-08
iB00_2200_v n1_1067872_1107920 0 2.69132e-08
iB00_2201_v n1_1067872_1032608 0 3.23268e-06
iB00_2202_v n1_1067872_1071600 0 -1.1152899999999999e-07
iB00_2203_v n1_1067872_1071440 0 1.1152899999999999e-07
iB00_2204_v n1_1028960_1071520 0 7.69327e-07
iB00_2205_v n1_1028960_1071600 0 4.99878e-08
iB00_2206_v n1_1028960_1071440 0 -4.99878e-08
iB00_2207_v n1_1028960_1032608 0 3.5955e-06
iB00_2208_v n1_1028960_1108080 0 1.03028e-07
iB00_2209_v n1_1028960_1107920 0 -1.03028e-07
iB00_2210_v n1_991264_1108080 0 -4.5460199999999996e-09
iB00_2211_v n1_991264_1107920 0 4.5460199999999996e-09
iB00_2212_v n1_991264_1071600 0 -5.6854899999999996e-08
iB00_2213_v n1_991264_1071440 0 5.6854899999999996e-08
iB00_2214_v n1_991264_1032688 0 -1.1105e-08
iB00_2215_v n1_991264_1032528 0 1.1105e-08
iB00_2216_v n1_1028960_1032688 0 -8.447269999999999e-08
iB00_2217_v n1_1028960_1032528 0 8.447269999999999e-08
iB00_2218_v n1_1028960_993696 0 3.11679e-06
iB00_2219_v n1_1028960_957216 0 2.42761e-06
iB00_2220_v n1_1028960_993776 0 -2.3519599999999998e-07
iB00_2221_v n1_1028960_993616 0 2.3519599999999998e-07
iB00_2222_v n1_1067872_993696 0 -1.15966e-06
iB00_2223_v n1_991264_993776 0 -2.54553e-08
iB00_2224_v n1_991264_993616 0 2.54553e-08
iB00_2225_v n1_991264_957296 0 -1.3733899999999998e-07
iB00_2226_v n1_991264_957136 0 1.3733899999999998e-07
iB00_2227_v n1_1067872_957216 0 -1.2978e-06
iB00_2228_v n1_1028960_957296 0 -2.21188e-07
iB00_2229_v n1_1028960_957136 0 2.21188e-07
iB00_2230_v n1_1028960_918304 0 1.9543e-06
iB00_2231_v n1_1028960_881824 0 1.5231e-06
iB00_2232_v n1_1028960_918384 0 -2.1759599999999999e-07
iB00_2233_v n1_1028960_918224 0 2.1759599999999999e-07
iB00_2234_v n1_1067872_918304 0 -1.4530599999999999e-06
iB00_2235_v n1_991264_918384 0 -2.26974e-07
iB00_2236_v n1_991264_918224 0 2.26974e-07
iB00_2237_v n1_991264_881904 0 -2.8706400000000004e-07
iB00_2238_v n1_991264_881744 0 2.8706400000000004e-07
iB00_2239_v n1_1067872_881824 0 -1.6196400000000002e-06
iB00_2240_v n1_1028960_881904 0 -2.5294e-07
iB00_2241_v n1_1028960_881744 0 2.5294e-07
iB00_2242_v n1_1028960_842912 0 9.97957e-07
iB00_2243_v n1_1028960_804000 0 6.996609999999999e-07
iB00_2244_v n1_1028960_842992 0 -2.74833e-07
iB00_2245_v n1_1028960_842832 0 2.74833e-07
iB00_2246_v n1_1067872_842912 0 -1.7453399999999999e-06
iB00_2247_v n1_991264_842992 0 -2.2605999999999997e-07
iB00_2248_v n1_991264_842832 0 2.2605999999999997e-07
iB00_2249_v n1_991264_804080 0 -3.0430499999999997e-07
iB00_2250_v n1_991264_803920 0 3.0430499999999997e-07
iB00_2251_v n1_1067872_804000 0 -1.93781e-06
iB00_2252_v n1_1028960_804080 0 -3.08866e-07
iB00_2253_v n1_1028960_803920 0 3.08866e-07
iB00_2254_v n1_1028960_767520 0 3.2233799999999996e-07
iB00_2255_v n1_1028960_728608 0 2.35493e-08
iB00_2256_v n1_1028960_767600 0 -3.32999e-07
iB00_2257_v n1_1028960_767440 0 3.32999e-07
iB00_2258_v n1_1067872_767520 0 -2.09188e-06
iB00_2259_v n1_991264_767600 0 -3.4859600000000003e-07
iB00_2260_v n1_991264_767440 0 3.4859600000000003e-07
iB00_2261_v n1_991264_692128 0 8.27432e-09
iB00_2262_v n1_991264_728688 0 -3.3723100000000004e-07
iB00_2263_v n1_991264_728528 0 3.3723100000000004e-07
iB00_2264_v n1_1067872_728608 0 -2.27926e-06
iB00_2265_v n1_1028960_728688 0 -4.04599e-07
iB00_2266_v n1_1028960_728528 0 4.04599e-07
iB00_2267_v n1_1028960_692128 0 -2.62553e-07
iB00_2268_v n1_1028960_653216 0 -5.12496e-07
iB00_2269_v n1_1028960_692208 0 -4.07348e-07
iB00_2270_v n1_1028960_692048 0 4.07348e-07
iB00_2271_v n1_1067872_692128 0 -2.4181599999999997e-06
iB00_2272_v n1_991264_692208 0 -4.02935e-07
iB00_2273_v n1_991264_692048 0 4.02935e-07
iB00_2274_v n1_991264_653216 0 -3.38118e-07
iB00_2275_v n1_991264_614304 0 -6.34538e-07
iB00_2276_v n1_991264_653296 0 -4.17123e-07
iB00_2277_v n1_991264_653136 0 4.17123e-07
iB00_2278_v n1_952352_653216 0 1.68719e-06
iB00_2279_v n1_952352_653296 0 -3.2404e-07
iB00_2280_v n1_952352_653136 0 3.2404e-07
iB00_2281_v n1_952352_614304 0 -4.48453e-07
iB00_2282_v n1_952352_692208 0 -3.62249e-07
iB00_2283_v n1_952352_692048 0 3.62249e-07
iB00_2284_v n1_952352_577824 0 -6.64987e-07
iB00_2285_v n1_952352_614384 0 -3.42166e-07
iB00_2286_v n1_952352_614224 0 3.42166e-07
iB00_2287_v n1_914656_614384 0 -4.20784e-07
iB00_2288_v n1_914656_614224 0 4.20784e-07
iB00_2289_v n1_914656_653296 0 -4.0247200000000003e-07
iB00_2290_v n1_914656_653136 0 4.0247200000000003e-07
iB00_2291_v n1_914656_577904 0 -4.19711e-07
iB00_2292_v n1_914656_577744 0 4.19711e-07
iB00_2293_v n1_991264_577824 0 -1.82949e-06
iB00_2294_v n1_952352_577904 0 -3.1694600000000004e-07
iB00_2295_v n1_952352_577744 0 3.1694600000000004e-07
iB00_2296_v n1_952352_538912 0 -6.90794e-07
iB00_2297_v n1_952352_502432 0 -1.05151e-06
iB00_2298_v n1_952352_538992 0 -4.39702e-07
iB00_2299_v n1_952352_538832 0 4.39702e-07
iB00_2300_v n1_991264_538912 0 -1.9531100000000003e-06
iB00_2301_v n1_914656_538992 0 -3.47105e-07
iB00_2302_v n1_914656_538832 0 3.47105e-07
iB00_2303_v n1_914656_480880 0 -7.96688e-07
iB00_2304_v n1_914656_502512 0 -3.9905799999999997e-07
iB00_2305_v n1_914656_502352 0 3.9905799999999997e-07
iB00_2306_v n1_991264_502432 0 -1.99607e-06
iB00_2307_v n1_952352_502512 0 -4.09377e-07
iB00_2308_v n1_952352_502352 0 4.09377e-07
iB00_2309_v n1_952352_480880 0 -8.38926e-07
iB00_2310_v n1_952352_480720 0 -2.38524e-17
iB00_2311_v n1_952352_481040 0 -8.38926e-07
iB00_2312_v n1_991264_480880 0 -4.0374e-06
iB00_2313_v n1_914656_481040 0 -7.96688e-07
iB00_2314_v n1_914656_480720 0 7.96688e-07
iB00_2315_v n1_876960_481040 0 -7.52045e-07
iB00_2316_v n1_876960_480720 0 7.52045e-07
iB00_2317_v n1_1028960_480880 0 -4.95498e-06
iB00_2318_v n1_991264_481040 0 -9.175830000000001e-07
iB00_2319_v n1_991264_480720 0 9.175830000000001e-07
iB00_2320_v n1_991264_502512 0 -4.6036e-07
iB00_2321_v n1_991264_502352 0 4.6036e-07
iB00_2322_v n1_1028960_502432 0 -2.45643e-06
iB00_2323_v n1_1067872_502432 0 -2.93569e-06
iB00_2324_v n1_1028960_502512 0 -4.79259e-07
iB00_2325_v n1_1028960_502352 0 4.79259e-07
iB00_2326_v n1_1028960_538912 0 1.17775e-06
iB00_2327_v n1_1028960_577824 0 1.12577e-06
iB00_2328_v n1_1028960_538992 0 -4.4941700000000003e-07
iB00_2329_v n1_1028960_538832 0 4.4941700000000003e-07
iB00_2330_v n1_1067872_538912 0 -2.8867300000000002e-06
iB00_2331_v n1_991264_538992 0 -4.84202e-07
iB00_2332_v n1_991264_538832 0 4.84202e-07
iB00_2333_v n1_991264_577904 0 -5.02168e-07
iB00_2334_v n1_991264_577744 0 5.02168e-07
iB00_2335_v n1_1067872_577824 0 -2.81934e-06
iB00_2336_v n1_1028960_577904 0 -4.87682e-07
iB00_2337_v n1_1028960_577744 0 4.87682e-07
iB00_2338_v n1_1028960_614304 0 9.02089e-07
iB00_2339_v n1_1028960_614384 0 -4.43645e-07
iB00_2340_v n1_1028960_614224 0 4.43645e-07
iB00_2341_v n1_1067872_614304 0 -2.70322e-06
iB00_2342_v n1_991264_614384 0 -4.75713e-07
iB00_2343_v n1_991264_614224 0 4.75713e-07
iB00_2344_v n1_1105568_614304 0 -3.187e-06
iB00_2345_v n1_1067872_614384 0 -4.837849999999999e-07
iB00_2346_v n1_1067872_614224 0 4.837849999999999e-07
iB00_2347_v n1_1067872_653216 0 1.16034e-06
iB00_2348_v n1_1067872_653296 0 -4.68172e-07
iB00_2349_v n1_1067872_653136 0 4.68172e-07
iB00_2350_v n1_1105568_653216 0 -3.04865e-06
iB00_2351_v n1_1028960_653296 0 -4.7616500000000003e-07
iB00_2352_v n1_1028960_653136 0 4.7616500000000003e-07
iB00_2353_v n1_1144480_653216 0 -3.5732e-06
iB00_2354_v n1_1105568_653296 0 -5.24546e-07
iB00_2355_v n1_1105568_653136 0 5.24546e-07
iB00_2356_v n1_1105568_692128 0 1.0731300000000001e-06
iB00_2357_v n1_1105568_728608 0 9.95072e-07
iB00_2358_v n1_1105568_692208 0 -4.66594e-07
iB00_2359_v n1_1105568_692048 0 4.66594e-07
iB00_2360_v n1_1144480_692128 0 -3.38217e-06
iB00_2361_v n1_1067872_692208 0 -4.97424e-07
iB00_2362_v n1_1067872_692048 0 4.97424e-07
iB00_2363_v n1_1067872_728688 0 -4.11452e-07
iB00_2364_v n1_1067872_728528 0 4.11452e-07
iB00_2365_v n1_1144480_728608 0 -3.1728199999999996e-06
iB00_2366_v n1_1105568_728688 0 -4.82118e-07
iB00_2367_v n1_1105568_728528 0 4.82118e-07
iB00_2368_v n1_1105568_767520 0 7.04208e-07
iB00_2369_v n1_1105568_804000 0 4.54619e-07
iB00_2370_v n1_1105568_767600 0 -4.59707e-07
iB00_2371_v n1_1105568_767440 0 4.59707e-07
iB00_2372_v n1_1144480_767520 0 -2.95358e-06
iB00_2373_v n1_1067872_767600 0 -4.0199399999999997e-07
iB00_2374_v n1_1067872_767440 0 4.0199399999999997e-07
iB00_2375_v n1_1067872_804080 0 -3.24515e-07
iB00_2376_v n1_1067872_803920 0 3.24515e-07
iB00_2377_v n1_1144480_804000 0 -2.71668e-06
iB00_2378_v n1_1105568_804080 0 -4.54353e-07
iB00_2379_v n1_1105568_803920 0 4.54353e-07
iB00_2380_v n1_1105568_842912 0 1.2686500000000002e-07
iB00_2381_v n1_1105568_881824 0 -4.09085e-07
iB00_2382_v n1_1105568_842992 0 -4.88433e-07
iB00_2383_v n1_1105568_842832 0 4.88433e-07
iB00_2384_v n1_1144480_842912 0 -2.50622e-06
iB00_2385_v n1_1067872_842992 0 -2.7245600000000004e-07
iB00_2386_v n1_1067872_842832 0 2.7245600000000004e-07
iB00_2387_v n1_1067872_881904 0 -2.12126e-07
iB00_2388_v n1_1067872_881744 0 2.12126e-07
iB00_2389_v n1_1144480_881824 0 -2.24601e-06
iB00_2390_v n1_1105568_881904 0 -4.14243e-07
iB00_2391_v n1_1105568_881744 0 4.14243e-07
iB00_2392_v n1_1105568_918304 0 -8.147480000000001e-07
iB00_2393_v n1_1105568_957216 0 -1.34691e-06
iB00_2394_v n1_1105568_918384 0 -3.4969500000000004e-07
iB00_2395_v n1_1105568_918224 0 3.4969500000000004e-07
iB00_2396_v n1_1144480_918304 0 -1.9973099999999998e-06
iB00_2397_v n1_1067872_918384 0 -1.9455e-07
iB00_2398_v n1_1067872_918224 0 1.9455e-07
iB00_2399_v n1_1067872_957296 0 -1.8438e-07
iB00_2400_v n1_1067872_957136 0 1.8438e-07
iB00_2401_v n1_1144480_957216 0 -1.71085e-06
iB00_2402_v n1_1105568_957296 0 -2.28675e-07
iB00_2403_v n1_1105568_957136 0 2.28675e-07
iB00_2404_v n1_1105568_993696 0 -1.8131200000000002e-06
iB00_2405_v n1_1105568_993776 0 -1.52404e-07
iB00_2406_v n1_1105568_993616 0 1.52404e-07
iB00_2407_v n1_1144480_993696 0 -1.4682499999999999e-06
iB00_2408_v n1_1067872_993776 0 -1.56188e-07
iB00_2409_v n1_1067872_993616 0 1.56188e-07
iB00_2410_v n1_1067872_1032688 0 -1.35511e-07
iB00_2411_v n1_1067872_1032528 0 1.35511e-07
iB00_2412_v n1_1105568_1032688 0 -8.2739e-08
iB00_2413_v n1_1105568_1032528 0 8.2739e-08
iB00_2414_v n1_1144480_1032688 0 -2.36405e-07
iB00_2415_v n1_1144480_1032528 0 2.36405e-07
iB00_2416_v n1_1144480_993776 0 -2.3340500000000002e-07
iB00_2417_v n1_1144480_993616 0 2.3340500000000002e-07
iB00_2418_v n1_1182176_993696 0 -1.7016600000000001e-06
iB00_2419_v n1_1219872_993696 0 -1.93507e-06
iB00_2420_v n1_1182176_993776 0 -2.33411e-07
iB00_2421_v n1_1182176_993616 0 2.33411e-07
iB00_2422_v n1_1182176_957216 0 7.67236e-07
iB00_2423_v n1_1182176_1032688 0 -1.9862300000000002e-07
iB00_2424_v n1_1182176_1032528 0 1.9862300000000002e-07
iB00_2425_v n1_1219872_1032688 0 -1.89386e-07
iB00_2426_v n1_1219872_1032528 0 1.89386e-07
iB00_2427_v n1_1219872_957216 0 1.55329e-07
iB00_2428_v n1_1219872_993776 0 -2.3101799999999998e-07
iB00_2429_v n1_1219872_993616 0 2.3101799999999998e-07
iB00_2430_v n1_1258784_993696 0 -2.16609e-06
iB00_2431_v n1_1296480_993696 0 -2.51863e-06
iB00_2432_v n1_1258784_993776 0 -3.52543e-07
iB00_2433_v n1_1258784_993616 0 3.52543e-07
iB00_2434_v n1_1258784_957216 0 -6.20324e-07
iB00_2435_v n1_1258784_1032688 0 -3.13157e-07
iB00_2436_v n1_1258784_1032528 0 3.13157e-07
iB00_2437_v n1_1296480_1032688 0 -3.69418e-07
iB00_2438_v n1_1296480_1032528 0 3.69418e-07
iB00_2439_v n1_1296480_957216 0 -1.28179e-06
iB00_2440_v n1_1296480_993776 0 -3.33099e-07
iB00_2441_v n1_1296480_993616 0 3.33099e-07
iB00_2442_v n1_1335392_993696 0 -2.8517299999999997e-06
iB00_2443_v n1_1373088_993696 0 -3.0391200000000004e-06
iB00_2444_v n1_1335392_993776 0 -1.87388e-07
iB00_2445_v n1_1335392_993616 0 1.87388e-07
iB00_2446_v n1_1335392_957216 0 -2.0353599999999998e-06
iB00_2447_v n1_1335392_1032688 0 -2.0071699999999998e-07
iB00_2448_v n1_1335392_1032528 0 2.0071699999999998e-07
iB00_2449_v n1_1373088_1032688 0 -1.8221200000000002e-07
iB00_2450_v n1_1373088_1032528 0 1.8221200000000002e-07
iB00_2451_v n1_1373088_957216 0 -2.84301e-06
iB00_2452_v n1_1373088_993776 0 -2.4337499999999997e-07
iB00_2453_v n1_1373088_993616 0 2.4337499999999997e-07
iB00_2454_v n1_1412000_993696 0 -3.28249e-06
iB00_2455_v n1_1449696_993696 0 -3.42426e-06
iB00_2456_v n1_1412000_993776 0 -1.41773e-07
iB00_2457_v n1_1412000_993616 0 1.41773e-07
iB00_2458_v n1_1412000_957216 0 -3.6068699999999997e-06
iB00_2459_v n1_1412000_1032688 0 -1.52548e-07
iB00_2460_v n1_1412000_1032528 0 1.52548e-07
iB00_2461_v n1_1449696_1032688 0 -1.6264099999999998e-08
iB00_2462_v n1_1449696_1032528 0 1.6264099999999998e-08
iB00_2463_v n1_1449696_957216 0 -4.28166e-06
iB00_2464_v n1_1449696_993776 0 8.30409e-08
iB00_2465_v n1_1449696_993616 0 -8.30409e-08
iB00_2466_v n1_1487392_993696 0 -3.34122e-06
iB00_2467_v n1_1526304_993696 0 -3.31209e-06
iB00_2468_v n1_1487392_993776 0 2.91302e-08
iB00_2469_v n1_1487392_993616 0 -2.91302e-08
iB00_2470_v n1_1487392_957216 0 -5.1555200000000006e-06
iB00_2471_v n1_1487392_1032688 0 2.5951800000000002e-08
iB00_2472_v n1_1487392_1032528 0 -2.5951800000000002e-08
iB00_2473_v n1_1526304_1032688 0 1.4138900000000002e-07
iB00_2474_v n1_1526304_1032528 0 -1.4138900000000002e-07
iB00_2475_v n1_1526304_957216 0 -5.7828200000000005e-06
iB00_2476_v n1_1526304_993776 0 1.6001200000000002e-07
iB00_2477_v n1_1526304_993616 0 -1.6001200000000002e-07
iB00_2478_v n1_1564000_993696 0 -3.1520799999999997e-06
iB00_2479_v n1_1602912_993696 0 -2.7848199999999997e-06
iB00_2480_v n1_1564000_993776 0 3.67263e-07
iB00_2481_v n1_1564000_993616 0 -3.67263e-07
iB00_2482_v n1_1564000_957216 0 -6.38154e-06
iB00_2483_v n1_1564000_1032688 0 2.83538e-07
iB00_2484_v n1_1564000_1032528 0 -2.83538e-07
iB00_2485_v n1_1641180_1032608 0 -2.1684999999999997e-06
iB00_2486_v n1_1602912_1032688 0 4.1540000000000003e-07
iB00_2487_v n1_1602912_1032528 0 -4.1540000000000003e-07
iB00_2488_v n1_1602912_957216 0 -6.96208e-06
iB00_2489_v n1_1602912_993776 0 4.910850000000001e-07
iB00_2490_v n1_1602912_993616 0 -4.910850000000001e-07
iB00_2491_v n1_1641180_993696 0 -2.2937299999999997e-06
iB00_2492_v n1_1641290_993696 0 0.0
iB00_2493_v n1_1641070_993696 0 2.2937299999999997e-06
iB00_2494_v n1_1641180_957216 0 -1.44788e-05
iB00_2495_v n1_1641070_1032608 0 2.1684999999999997e-06
iB00_2496_v n1_1641290_1032608 0 -2.1684999999999997e-06
iB00_2497_v n1_1641070_1071520 0 2.03298e-06
iB00_2498_v n1_1641290_1071520 0 -2.03298e-06
iB00_2499_v n1_1641180_918304 0 -1.69098e-05
iB00_2500_v n1_1641070_957216 0 2.43106e-06
iB00_2501_v n1_1641290_957216 0 -2.43106e-06
iB00_2502_v n1_1602912_957296 0 6.36489e-07
iB00_2503_v n1_1602912_957136 0 -6.36489e-07
iB00_2504_v n1_1602912_918304 0 -8.00893e-06
iB00_2505_v n1_1602912_881824 0 -9.24584e-06
iB00_2506_v n1_1602912_918384 0 7.165309999999999e-07
iB00_2507_v n1_1602912_918224 0 -7.165309999999999e-07
iB00_2508_v n1_1564000_918304 0 3.38317e-06
iB00_2509_v n1_1526304_918304 0 3.76343e-06
iB00_2510_v n1_1564000_918384 0 3.80251e-07
iB00_2511_v n1_1564000_918224 0 -3.80251e-07
iB00_2512_v n1_1564000_881824 0 -8.680979999999999e-06
iB00_2513_v n1_1564000_957296 0 3.85518e-07
iB00_2514_v n1_1564000_957136 0 -3.85518e-07
iB00_2515_v n1_1526304_957296 0 1.6453099999999998e-07
iB00_2516_v n1_1526304_957136 0 -1.6453099999999998e-07
iB00_2517_v n1_1526304_881824 0 -7.76016e-06
iB00_2518_v n1_1526304_918384 0 3.5361e-07
iB00_2519_v n1_1526304_918224 0 -3.5361e-07
iB00_2520_v n1_1487392_918304 0 4.11704e-06
iB00_2521_v n1_1449696_918304 0 4.26205e-06
iB00_2522_v n1_1487392_918384 0 1.45016e-07
iB00_2523_v n1_1487392_918224 0 -1.45016e-07
iB00_2524_v n1_1487392_881824 0 -6.852170000000001e-06
iB00_2525_v n1_1487392_957296 0 1.62931e-07
iB00_2526_v n1_1487392_957136 0 -1.62931e-07
iB00_2527_v n1_1449696_957296 0 -1.7030499999999998e-08
iB00_2528_v n1_1449696_957136 0 1.7030499999999998e-08
iB00_2529_v n1_1449696_881824 0 -5.92943e-06
iB00_2530_v n1_1449696_918384 0 -1.0839300000000001e-07
iB00_2531_v n1_1449696_918224 0 1.0839300000000001e-07
iB00_2532_v n1_1412000_918304 0 4.15366e-06
iB00_2533_v n1_1373088_918304 0 4.11336e-06
iB00_2534_v n1_1412000_918384 0 -4.02945e-08
iB00_2535_v n1_1412000_918224 0 4.02945e-08
iB00_2536_v n1_1412000_881824 0 -4.71428e-06
iB00_2537_v n1_1412000_957296 0 -1.0899599999999999e-07
iB00_2538_v n1_1412000_957136 0 1.0899599999999999e-07
iB00_2539_v n1_1373088_957296 0 -2.09364e-07
iB00_2540_v n1_1373088_957136 0 2.09364e-07
iB00_2541_v n1_1373088_881824 0 -3.81986e-06
iB00_2542_v n1_1373088_918384 0 -1.68725e-07
iB00_2543_v n1_1373088_918224 0 1.68725e-07
iB00_2544_v n1_1335392_918304 0 3.94464e-06
iB00_2545_v n1_1296480_918304 0 3.59426e-06
iB00_2546_v n1_1335392_918384 0 -3.5038e-07
iB00_2547_v n1_1335392_918224 0 3.5038e-07
iB00_2548_v n1_1335392_881824 0 -2.8864e-06
iB00_2549_v n1_1335392_957296 0 -2.26414e-07
iB00_2550_v n1_1335392_957136 0 2.26414e-07
iB00_2551_v n1_1296480_957296 0 -3.6756e-07
iB00_2552_v n1_1296480_957136 0 3.6756e-07
iB00_2553_v n1_1296480_881824 0 -2.1580900000000003e-06
iB00_2554_v n1_1296480_918384 0 -3.54692e-07
iB00_2555_v n1_1296480_918224 0 3.54692e-07
iB00_2556_v n1_1258784_918304 0 3.2395700000000003e-06
iB00_2557_v n1_1219872_918304 0 2.91129e-06
iB00_2558_v n1_1258784_918384 0 -3.28281e-07
iB00_2559_v n1_1258784_918224 0 3.28281e-07
iB00_2560_v n1_1258784_881824 0 -1.37596e-06
iB00_2561_v n1_1258784_957296 0 -3.07325e-07
iB00_2562_v n1_1258784_957136 0 3.07325e-07
iB00_2563_v n1_1219872_957296 0 -3.01151e-07
iB00_2564_v n1_1219872_957136 0 3.01151e-07
iB00_2565_v n1_1219872_881824 0 -7.421599999999999e-07
iB00_2566_v n1_1219872_918384 0 -3.99912e-07
iB00_2567_v n1_1219872_918224 0 3.99912e-07
iB00_2568_v n1_1182176_918304 0 2.5113700000000002e-06
iB00_2569_v n1_1182176_918384 0 -2.3368200000000001e-07
iB00_2570_v n1_1182176_918224 0 2.3368200000000001e-07
iB00_2571_v n1_1182176_881824 0 -2.0260899999999998e-07
iB00_2572_v n1_1182176_957296 0 -2.6566300000000004e-07
iB00_2573_v n1_1182176_957136 0 2.6566300000000004e-07
iB00_2574_v n1_1144480_957296 0 -2.66174e-07
iB00_2575_v n1_1144480_957136 0 2.66174e-07
iB00_2576_v n1_1144480_918384 0 -2.80385e-07
iB00_2577_v n1_1144480_918224 0 2.80385e-07
iB00_2578_v n1_1144480_881904 0 -2.86409e-07
iB00_2579_v n1_1144480_881744 0 2.86409e-07
iB00_2580_v n1_1182176_881904 0 -2.5020100000000003e-07
iB00_2581_v n1_1182176_881744 0 2.5020100000000003e-07
iB00_2582_v n1_1182176_842912 0 -6.29497e-07
iB00_2583_v n1_1182176_804000 0 -1.0623799999999999e-06
iB00_2584_v n1_1182176_842992 0 -2.7868e-07
iB00_2585_v n1_1182176_842832 0 2.7868e-07
iB00_2586_v n1_1219872_842912 0 -3.09942e-06
iB00_2587_v n1_1144480_842992 0 -3.14513e-07
iB00_2588_v n1_1144480_842832 0 3.14513e-07
iB00_2589_v n1_1144480_804080 0 -3.88482e-07
iB00_2590_v n1_1144480_803920 0 3.88482e-07
iB00_2591_v n1_1219872_804000 0 -3.4351999999999997e-06
iB00_2592_v n1_1182176_804080 0 -3.30041e-07
iB00_2593_v n1_1182176_803920 0 3.30041e-07
iB00_2594_v n1_1182176_767520 0 -1.42676e-06
iB00_2595_v n1_1182176_728608 0 -1.79472e-06
iB00_2596_v n1_1182176_767600 0 -4.3423499999999997e-07
iB00_2597_v n1_1182176_767440 0 4.3423499999999997e-07
iB00_2598_v n1_1219872_767520 0 -3.7835600000000002e-06
iB00_2599_v n1_1144480_767600 0 -3.95744e-07
iB00_2600_v n1_1144480_767440 0 3.95744e-07
iB00_2601_v n1_1144480_728688 0 -5.349620000000001e-07
iB00_2602_v n1_1144480_728528 0 5.349620000000001e-07
iB00_2603_v n1_1219872_728608 0 -4.0564e-06
iB00_2604_v n1_1182176_728688 0 -3.4861e-07
iB00_2605_v n1_1182176_728528 0 3.4861e-07
iB00_2606_v n1_1182176_692128 0 -1.7856700000000001e-06
iB00_2607_v n1_1182176_653216 0 -1.9012899999999998e-06
iB00_2608_v n1_1182176_692208 0 -4.39747e-07
iB00_2609_v n1_1182176_692048 0 4.39747e-07
iB00_2610_v n1_1219872_692128 0 -4.3288800000000005e-06
iB00_2611_v n1_1144480_692208 0 -5.06962e-07
iB00_2612_v n1_1144480_692048 0 5.06962e-07
iB00_2613_v n1_1144480_614304 0 -1.6768200000000001e-06
iB00_2614_v n1_1144480_653296 0 -5.62844e-07
iB00_2615_v n1_1144480_653136 0 5.62844e-07
iB00_2616_v n1_1219872_653216 0 -4.62891e-06
iB00_2617_v n1_1182176_653296 0 -4.92868e-07
iB00_2618_v n1_1182176_653136 0 4.92868e-07
iB00_2619_v n1_1182176_614304 0 -1.9723599999999997e-06
iB00_2620_v n1_1182176_577824 0 -2.02733e-06
iB00_2621_v n1_1182176_614384 0 -5.766820000000001e-07
iB00_2622_v n1_1182176_614224 0 5.766820000000001e-07
iB00_2623_v n1_1219872_614304 0 -4.8712e-06
iB00_2624_v n1_1144480_614384 0 -5.870460000000001e-07
iB00_2625_v n1_1144480_614224 0 5.870460000000001e-07
iB00_2626_v n1_1144480_577824 0 -1.59419e-06
iB00_2627_v n1_1144480_538912 0 -1.76361e-06
iB00_2628_v n1_1144480_577904 0 -7.10327e-07
iB00_2629_v n1_1144480_577744 0 7.10327e-07
iB00_2630_v n1_1105568_577824 0 3.80195e-06
iB00_2631_v n1_1105568_577904 0 -4.84405e-07
iB00_2632_v n1_1105568_577744 0 4.84405e-07
iB00_2633_v n1_1105568_538912 0 -1.3789e-06
iB00_2634_v n1_1105568_614384 0 -5.20475e-07
iB00_2635_v n1_1105568_614224 0 5.20475e-07
iB00_2636_v n1_1105568_502432 0 -1.49129e-06
iB00_2637_v n1_1105568_538992 0 -6.18075e-07
iB00_2638_v n1_1105568_538832 0 6.18075e-07
iB00_2639_v n1_1067872_538992 0 -4.96999e-07
iB00_2640_v n1_1067872_538832 0 4.96999e-07
iB00_2641_v n1_1067872_577904 0 -4.981989999999999e-07
iB00_2642_v n1_1067872_577744 0 4.981989999999999e-07
iB00_2643_v n1_1067872_480880 0 -1.1138e-06
iB00_2644_v n1_1067872_502512 0 -5.55124e-07
iB00_2645_v n1_1067872_502352 0 5.55124e-07
iB00_2646_v n1_1144480_502432 0 -4.130639999999999e-06
iB00_2647_v n1_1105568_502512 0 -6.398340000000001e-07
iB00_2648_v n1_1105568_502352 0 6.398340000000001e-07
iB00_2649_v n1_1105568_480880 0 -1.24116e-06
iB00_2650_v n1_1105568_480720 0 -2.38524e-17
iB00_2651_v n1_1105568_481040 0 -1.24116e-06
iB00_2652_v n1_1144480_480880 0 -8.298440000000001e-06
iB00_2653_v n1_1067872_481040 0 -1.1138e-06
iB00_2654_v n1_1067872_480720 0 1.1138e-06
iB00_2655_v n1_1028960_481040 0 -9.884990000000001e-07
iB00_2656_v n1_1028960_480720 0 9.884990000000001e-07
iB00_2657_v n1_1182176_480880 0 -9.60415e-06
iB00_2658_v n1_1144480_481040 0 -1.30572e-06
iB00_2659_v n1_1144480_480720 0 1.30572e-06
iB00_2660_v n1_1144480_502512 0 -6.1702e-07
iB00_2661_v n1_1144480_502352 0 6.1702e-07
iB00_2662_v n1_1182176_502432 0 -4.74766e-06
iB00_2663_v n1_1219872_502432 0 -5.48253e-06
iB00_2664_v n1_1182176_502512 0 -7.34864e-07
iB00_2665_v n1_1182176_502352 0 7.34864e-07
iB00_2666_v n1_1182176_538912 0 1.93377e-06
iB00_2667_v n1_1182176_538992 0 -6.568159999999999e-07
iB00_2668_v n1_1182176_538832 0 6.568159999999999e-07
iB00_2669_v n1_1219872_538912 0 -5.31503e-06
iB00_2670_v n1_1144480_538992 0 -6.564179999999999e-07
iB00_2671_v n1_1144480_538832 0 6.564179999999999e-07
iB00_2672_v n1_1258784_538912 0 -6.15924e-06
iB00_2673_v n1_1219872_538992 0 -8.44205e-07
iB00_2674_v n1_1219872_538832 0 8.44205e-07
iB00_2675_v n1_1219872_577824 0 2.3543e-06
iB00_2676_v n1_1219872_577904 0 -7.356659999999999e-07
iB00_2677_v n1_1219872_577744 0 7.356659999999999e-07
iB00_2678_v n1_1258784_577824 0 -5.8798899999999995e-06
iB00_2679_v n1_1182176_577904 0 -6.31952e-07
iB00_2680_v n1_1182176_577744 0 6.31952e-07
iB00_2681_v n1_1296480_577824 0 -6.80821e-06
iB00_2682_v n1_1258784_577904 0 -9.283209999999999e-07
iB00_2683_v n1_1258784_577744 0 9.283209999999999e-07
iB00_2684_v n1_1258784_614304 0 3.06531e-06
iB00_2685_v n1_1258784_653216 0 3.1039599999999996e-06
iB00_2686_v n1_1258784_614384 0 -8.49016e-07
iB00_2687_v n1_1258784_614224 0 8.49016e-07
iB00_2688_v n1_1296480_614304 0 -6.4878899999999995e-06
iB00_2689_v n1_1219872_614384 0 -7.6767e-07
iB00_2690_v n1_1219872_614224 0 7.6767e-07
iB00_2691_v n1_1219872_653296 0 -6.56845e-07
iB00_2692_v n1_1219872_653136 0 6.56845e-07
iB00_2693_v n1_1296480_653216 0 -6.079850000000001e-06
iB00_2694_v n1_1258784_653296 0 -7.94092e-07
iB00_2695_v n1_1258784_653136 0 7.94092e-07
iB00_2696_v n1_1258784_692128 0 3.0897e-06
iB00_2697_v n1_1258784_728608 0 3.10744e-06
iB00_2698_v n1_1258784_692208 0 -6.34776e-07
iB00_2699_v n1_1258784_692048 0 6.34776e-07
iB00_2700_v n1_1296480_692128 0 -5.59382e-06
iB00_2701_v n1_1219872_692208 0 -6.30166e-07
iB00_2702_v n1_1219872_692048 0 6.30166e-07
iB00_2703_v n1_1219872_728688 0 -5.22904e-07
iB00_2704_v n1_1219872_728528 0 5.22904e-07
iB00_2705_v n1_1296480_728608 0 -5.21787e-06
iB00_2706_v n1_1258784_728688 0 -6.38566e-07
iB00_2707_v n1_1258784_728528 0 6.38566e-07
iB00_2708_v n1_1258784_767520 0 2.96374e-06
iB00_2709_v n1_1258784_804000 0 2.7109299999999997e-06
iB00_2710_v n1_1258784_767600 0 -5.813730000000001e-07
iB00_2711_v n1_1258784_767440 0 5.813730000000001e-07
iB00_2712_v n1_1296480_767520 0 -4.8177000000000005e-06
iB00_2713_v n1_1219872_767600 0 -4.52764e-07
iB00_2714_v n1_1219872_767440 0 4.52764e-07
iB00_2715_v n1_1219872_804080 0 -5.13199e-07
iB00_2716_v n1_1219872_803920 0 5.13199e-07
iB00_2717_v n1_1296480_804000 0 -4.40738e-06
iB00_2718_v n1_1258784_804080 0 -4.58984e-07
iB00_2719_v n1_1258784_803920 0 4.58984e-07
iB00_2720_v n1_1258784_842912 0 2.35498e-06
iB00_2721_v n1_1258784_842992 0 -3.84357e-07
iB00_2722_v n1_1258784_842832 0 3.84357e-07
iB00_2723_v n1_1296480_842912 0 -3.98656e-06
iB00_2724_v n1_1219872_842992 0 -5.02789e-07
iB00_2725_v n1_1219872_842832 0 5.02789e-07
iB00_2726_v n1_1219872_881904 0 -4.37335e-07
iB00_2727_v n1_1219872_881744 0 4.37335e-07
iB00_2728_v n1_1258784_881904 0 -4.1281100000000003e-07
iB00_2729_v n1_1258784_881744 0 4.1281100000000003e-07
iB00_2730_v n1_1296480_881904 0 -3.1619200000000003e-07
iB00_2731_v n1_1296480_881744 0 3.1619200000000003e-07
iB00_2732_v n1_1296480_842992 0 -3.70968e-07
iB00_2733_v n1_1296480_842832 0 3.70968e-07
iB00_2734_v n1_1335392_842912 0 -4.35753e-06
iB00_2735_v n1_1373088_842912 0 -4.8405699999999995e-06
iB00_2736_v n1_1335392_842992 0 -4.83042e-07
iB00_2737_v n1_1335392_842832 0 4.83042e-07
iB00_2738_v n1_1335392_804000 0 -4.07086e-06
iB00_2739_v n1_1335392_881904 0 -4.64951e-07
iB00_2740_v n1_1335392_881744 0 4.64951e-07
iB00_2741_v n1_1373088_881904 0 -1.35052e-07
iB00_2742_v n1_1373088_881744 0 1.35052e-07
iB00_2743_v n1_1373088_804000 0 -4.83202e-06
iB00_2744_v n1_1373088_842992 0 -2.35073e-07
iB00_2745_v n1_1373088_842832 0 2.35073e-07
iB00_2746_v n1_1412000_842912 0 -5.07564e-06
iB00_2747_v n1_1449696_842912 0 -5.4564e-06
iB00_2748_v n1_1412000_842992 0 -3.8075e-07
iB00_2749_v n1_1412000_842832 0 3.8075e-07
iB00_2750_v n1_1412000_804000 0 -6.01193e-06
iB00_2751_v n1_1412000_881904 0 -2.15586e-07
iB00_2752_v n1_1412000_881744 0 2.15586e-07
iB00_2753_v n1_1449696_881904 0 3.8610799999999997e-08
iB00_2754_v n1_1449696_881744 0 -3.8610799999999997e-08
iB00_2755_v n1_1449696_804000 0 -7.2226e-06
iB00_2756_v n1_1449696_842992 0 1.20614e-07
iB00_2757_v n1_1449696_842832 0 -1.20614e-07
iB00_2758_v n1_1487392_842912 0 -5.33578e-06
iB00_2759_v n1_1526304_842912 0 -5.1152100000000004e-06
iB00_2760_v n1_1487392_842992 0 2.20571e-07
iB00_2761_v n1_1487392_842832 0 -2.20571e-07
iB00_2762_v n1_1487392_804000 0 -8.611519999999998e-06
iB00_2763_v n1_1487392_881904 0 1.6669100000000002e-07
iB00_2764_v n1_1487392_881744 0 -1.6669100000000002e-07
iB00_2765_v n1_1526304_881904 0 3.32899e-07
iB00_2766_v n1_1526304_881744 0 -3.32899e-07
iB00_2767_v n1_1526304_804000 0 -9.911e-06
iB00_2768_v n1_1526304_842992 0 3.22791e-07
iB00_2769_v n1_1526304_842832 0 -3.22791e-07
iB00_2770_v n1_1564000_842912 0 -4.792420000000001e-06
iB00_2771_v n1_1602912_842912 0 -4.09379e-06
iB00_2772_v n1_1564000_842992 0 6.98626e-07
iB00_2773_v n1_1564000_842832 0 -6.98626e-07
iB00_2774_v n1_1564000_804000 0 -1.09768e-05
iB00_2775_v n1_1564000_881904 0 5.68073e-07
iB00_2776_v n1_1564000_881744 0 -5.68073e-07
iB00_2777_v n1_1641180_881824 0 -2.93525e-06
iB00_2778_v n1_1602912_881904 0 7.23023e-07
iB00_2779_v n1_1602912_881744 0 -7.23023e-07
iB00_2780_v n1_1602912_804000 0 -1.21009e-05
iB00_2781_v n1_1602912_842992 0 8.140299999999999e-07
iB00_2782_v n1_1602912_842832 0 -8.140299999999999e-07
iB00_2783_v n1_1641180_842912 0 -3.27976e-06
iB00_2784_v n1_1641290_842912 0 0.0
iB00_2785_v n1_1641070_842912 0 3.27976e-06
iB00_2786_v n1_1641180_804000 0 -2.57915e-05
iB00_2787_v n1_1641070_881824 0 2.93525e-06
iB00_2788_v n1_1641290_881824 0 -2.93525e-06
iB00_2789_v n1_1641070_918304 0 2.6666400000000003e-06
iB00_2790_v n1_1641290_918304 0 -2.6666400000000003e-06
iB00_2791_v n1_1641180_767520 0 -2.94911e-05
iB00_2792_v n1_1641070_804000 0 3.69961e-06
iB00_2793_v n1_1641290_804000 0 -3.69961e-06
iB00_2794_v n1_1602912_804080 0 9.78156e-07
iB00_2795_v n1_1602912_803920 0 -9.78156e-07
iB00_2796_v n1_1602912_767520 0 -1.3815300000000001e-05
iB00_2797_v n1_1602912_728608 0 -1.56811e-05
iB00_2798_v n1_1602912_767600 0 1.16403e-06
iB00_2799_v n1_1602912_767440 0 -1.16403e-06
iB00_2800_v n1_1564000_767520 0 5.32429e-06
iB00_2801_v n1_1526304_767520 0 6.14026e-06
iB00_2802_v n1_1564000_767600 0 8.159699999999999e-07
iB00_2803_v n1_1564000_767440 0 -8.159699999999999e-07
iB00_2804_v n1_1564000_728608 0 -1.3953e-05
iB00_2805_v n1_1564000_804080 0 6.8617e-07
iB00_2806_v n1_1564000_803920 0 -6.8617e-07
iB00_2807_v n1_1526304_804080 0 4.26335e-07
iB00_2808_v n1_1526304_803920 0 -4.26335e-07
iB00_2809_v n1_1526304_728608 0 -1.2116899999999999e-05
iB00_2810_v n1_1526304_767600 0 4.07662e-07
iB00_2811_v n1_1526304_767440 0 -4.07662e-07
iB00_2812_v n1_1487392_767520 0 6.547919999999999e-06
iB00_2813_v n1_1449696_767520 0 6.81634e-06
iB00_2814_v n1_1487392_767600 0 2.68416e-07
iB00_2815_v n1_1487392_767440 0 -2.68416e-07
iB00_2816_v n1_1487392_728608 0 -1.01224e-05
iB00_2817_v n1_1487392_804080 0 2.90304e-07
iB00_2818_v n1_1487392_803920 0 -2.90304e-07
iB00_2819_v n1_1449696_804080 0 2.50303e-08
iB00_2820_v n1_1449696_803920 0 -2.50303e-08
iB00_2821_v n1_1449696_728608 0 -8.57838e-06
iB00_2822_v n1_1449696_767600 0 -1.45675e-07
iB00_2823_v n1_1449696_767440 0 1.45675e-07
iB00_2824_v n1_1412000_767520 0 6.67066e-06
iB00_2825_v n1_1373088_767520 0 6.38267e-06
iB00_2826_v n1_1412000_767600 0 -2.87987e-07
iB00_2827_v n1_1412000_767440 0 2.87987e-07
iB00_2828_v n1_1412000_728608 0 -7.14099e-06
iB00_2829_v n1_1412000_804080 0 -4.1701500000000003e-07
iB00_2830_v n1_1412000_803920 0 4.1701500000000003e-07
iB00_2831_v n1_1373088_804080 0 -4.3984900000000004e-07
iB00_2832_v n1_1373088_803920 0 4.3984900000000004e-07
iB00_2833_v n1_1373088_728608 0 -5.89042e-06
iB00_2834_v n1_1373088_767600 0 -6.34971e-07
iB00_2835_v n1_1373088_767440 0 6.34971e-07
iB00_2836_v n1_1335392_767520 0 5.7477e-06
iB00_2837_v n1_1335392_767600 0 -4.89864e-07
iB00_2838_v n1_1335392_767440 0 4.89864e-07
iB00_2839_v n1_1335392_728608 0 -4.6543000000000005e-06
iB00_2840_v n1_1335392_804080 0 -4.0751200000000003e-07
iB00_2841_v n1_1335392_803920 0 4.0751200000000003e-07
iB00_2842_v n1_1296480_804080 0 -4.33847e-07
iB00_2843_v n1_1296480_803920 0 4.33847e-07
iB00_2844_v n1_1296480_767600 0 -4.40141e-07
iB00_2845_v n1_1296480_767440 0 4.40141e-07
iB00_2846_v n1_1296480_728688 0 -5.30524e-07
iB00_2847_v n1_1296480_728528 0 5.30524e-07
iB00_2848_v n1_1335392_728688 0 -6.62173e-07
iB00_2849_v n1_1335392_728528 0 6.62173e-07
iB00_2850_v n1_1335392_692128 0 -4.9521e-06
iB00_2851_v n1_1335392_653216 0 -4.87442e-06
iB00_2852_v n1_1335392_692208 0 -6.75963e-07
iB00_2853_v n1_1335392_692048 0 6.75963e-07
iB00_2854_v n1_1373088_692128 0 -6.95852e-06
iB00_2855_v n1_1296480_692208 0 -6.88728e-07
iB00_2856_v n1_1296480_692048 0 6.88728e-07
iB00_2857_v n1_1296480_653296 0 -6.59001e-07
iB00_2858_v n1_1296480_653136 0 6.59001e-07
iB00_2859_v n1_1373088_653216 0 -7.5881e-06
iB00_2860_v n1_1335392_653296 0 -8.49251e-07
iB00_2861_v n1_1335392_653136 0 8.49251e-07
iB00_2862_v n1_1335392_614304 0 -4.88938e-06
iB00_2863_v n1_1335392_577824 0 -4.6411e-06
iB00_2864_v n1_1335392_614384 0 -9.07942e-07
iB00_2865_v n1_1335392_614224 0 9.07942e-07
iB00_2866_v n1_1373088_614304 0 -8.17899e-06
iB00_2867_v n1_1296480_614384 0 -7.831570000000001e-07
iB00_2868_v n1_1296480_614224 0 7.831570000000001e-07
iB00_2869_v n1_1296480_538912 0 -3.43794e-06
iB00_2870_v n1_1296480_577904 0 -9.1995e-07
iB00_2871_v n1_1296480_577744 0 9.1995e-07
iB00_2872_v n1_1373088_577824 0 -8.69838e-06
iB00_2873_v n1_1335392_577904 0 -9.70215e-07
iB00_2874_v n1_1335392_577744 0 9.70215e-07
iB00_2875_v n1_1335392_538912 0 -4.10757e-06
iB00_2876_v n1_1335392_502432 0 -3.71687e-06
iB00_2877_v n1_1335392_538992 0 -1.2195599999999999e-06
iB00_2878_v n1_1335392_538832 0 1.2195599999999999e-06
iB00_2879_v n1_1373088_538912 0 -9.29558e-06
iB00_2880_v n1_1296480_538992 0 -9.75078e-07
iB00_2881_v n1_1296480_538832 0 9.75078e-07
iB00_2882_v n1_1296480_502432 0 -3.02036e-06
iB00_2883_v n1_1296480_480880 0 -2.2584300000000002e-06
iB00_2884_v n1_1296480_502512 0 -1.09604e-06
iB00_2885_v n1_1296480_502352 0 1.09604e-06
iB00_2886_v n1_1258784_502432 0 7.3191899999999995e-06
iB00_2887_v n1_1258784_502512 0 -1.00446e-06
iB00_2888_v n1_1258784_502352 0 1.00446e-06
iB00_2889_v n1_1258784_480880 0 -1.99648e-06
iB00_2890_v n1_1258784_538992 0 -9.41709e-07
iB00_2891_v n1_1258784_538832 0 9.41709e-07
iB00_2892_v n1_1258784_480720 0 -2.38524e-17
iB00_2893_v n1_1258784_481040 0 -1.99648e-06
iB00_2894_v n1_1219872_480880 0 1.2797499999999999e-05
iB00_2895_v n1_1219872_481040 0 -1.70444e-06
iB00_2896_v n1_1219872_480720 0 1.70444e-06
iB00_2897_v n1_1219872_502512 0 -8.32205e-07
iB00_2898_v n1_1219872_502352 0 8.32205e-07
iB00_2899_v n1_1182176_481040 0 -1.48892e-06
iB00_2900_v n1_1182176_480720 0 1.48892e-06
iB00_2901_v n1_1335392_480880 0 -1.70524e-05
iB00_2902_v n1_1296480_481040 0 -2.2584300000000002e-06
iB00_2903_v n1_1296480_480720 0 2.2584300000000002e-06
iB00_2904_v n1_1373088_480880 0 -1.96966e-05
iB00_2905_v n1_1335392_481040 0 -2.64415e-06
iB00_2906_v n1_1335392_480720 0 2.64415e-06
iB00_2907_v n1_1335392_502512 0 -1.25771e-06
iB00_2908_v n1_1335392_502352 0 1.25771e-06
iB00_2909_v n1_1373088_502432 0 -9.67295e-06
iB00_2910_v n1_1412000_502432 0 -1.1219899999999999e-05
iB00_2911_v n1_1373088_502512 0 -1.54693e-06
iB00_2912_v n1_1373088_502352 0 1.54693e-06
iB00_2913_v n1_1373088_538992 0 -1.3135099999999999e-06
iB00_2914_v n1_1373088_538832 0 1.3135099999999999e-06
iB00_2915_v n1_1412000_538912 0 -1.06091e-05
iB00_2916_v n1_1449696_538912 0 -1.23152e-05
iB00_2917_v n1_1412000_538992 0 -1.70612e-06
iB00_2918_v n1_1412000_538832 0 1.70612e-06
iB00_2919_v n1_1412000_577824 0 6.46998e-06
iB00_2920_v n1_1412000_614304 0 7.13051e-06
iB00_2921_v n1_1412000_577904 0 -1.3179000000000001e-06
iB00_2922_v n1_1412000_577744 0 1.3179000000000001e-06
iB00_2923_v n1_1449696_577824 0 -1.12783e-05
iB00_2924_v n1_1373088_577904 0 -1.26203e-06
iB00_2925_v n1_1373088_577744 0 1.26203e-06
iB00_2926_v n1_1373088_614384 0 -1.0721999999999999e-06
iB00_2927_v n1_1373088_614224 0 1.0721999999999999e-06
iB00_2928_v n1_1449696_614304 0 -1.0307e-05
iB00_2929_v n1_1412000_614384 0 -1.05583e-06
iB00_2930_v n1_1412000_614224 0 1.05583e-06
iB00_2931_v n1_1412000_653216 0 7.465560000000001e-06
iB00_2932_v n1_1412000_692128 0 7.63652e-06
iB00_2933_v n1_1412000_653296 0 -7.055810000000001e-07
iB00_2934_v n1_1412000_653136 0 7.055810000000001e-07
iB00_2935_v n1_1449696_653216 0 -9.19092e-06
iB00_2936_v n1_1373088_653296 0 -8.972369999999999e-07
iB00_2937_v n1_1373088_653136 0 8.972369999999999e-07
iB00_2938_v n1_1373088_692208 0 -7.018680000000001e-07
iB00_2939_v n1_1373088_692048 0 7.018680000000001e-07
iB00_2940_v n1_1449696_692128 0 -8.28372e-06
iB00_2941_v n1_1412000_692208 0 -6.233309999999999e-07
iB00_2942_v n1_1412000_692048 0 6.233309999999999e-07
iB00_2943_v n1_1412000_728688 0 -4.0912e-07
iB00_2944_v n1_1412000_728528 0 4.0912e-07
iB00_2945_v n1_1373088_728688 0 -6.2176e-07
iB00_2946_v n1_1373088_728528 0 6.2176e-07
iB00_2947_v n1_1449696_728688 0 -2.02857e-07
iB00_2948_v n1_1449696_728528 0 2.02857e-07
iB00_2949_v n1_1449696_692208 0 -2.6355500000000003e-07
iB00_2950_v n1_1449696_692048 0 2.6355500000000003e-07
iB00_2951_v n1_1487392_692128 0 -8.54727e-06
iB00_2952_v n1_1526304_692128 0 -8.753250000000001e-06
iB00_2953_v n1_1487392_692208 0 -2.0597700000000002e-07
iB00_2954_v n1_1487392_692048 0 2.0597700000000002e-07
iB00_2955_v n1_1487392_653216 0 -1.16329e-05
iB00_2956_v n1_1487392_728688 0 6.02476e-08
iB00_2957_v n1_1487392_728528 0 -6.02476e-08
iB00_2958_v n1_1526304_728688 0 4.5925000000000004e-07
iB00_2959_v n1_1526304_728528 0 -4.5925000000000004e-07
iB00_2960_v n1_1526304_653216 0 -1.4293300000000001e-05
iB00_2961_v n1_1526304_692208 0 4.36874e-07
iB00_2962_v n1_1526304_692048 0 -4.36874e-07
iB00_2963_v n1_1564000_692128 0 -8.31637e-06
iB00_2964_v n1_1602912_692128 0 -7.24876e-06
iB00_2965_v n1_1564000_692208 0 1.06762e-06
iB00_2966_v n1_1564000_692048 0 -1.06762e-06
iB00_2967_v n1_1564000_653216 0 -1.72651e-05
iB00_2968_v n1_1564000_728688 0 9.02778e-07
iB00_2969_v n1_1564000_728528 0 -9.02778e-07
iB00_2970_v n1_1641180_728608 0 -4.76485e-06
iB00_2971_v n1_1602912_728688 0 1.45718e-06
iB00_2972_v n1_1602912_728528 0 -1.45718e-06
iB00_2973_v n1_1602912_653216 0 -2.00676e-05
iB00_2974_v n1_1602912_692208 0 1.7284100000000001e-06
iB00_2975_v n1_1602912_692048 0 -1.7284100000000001e-06
iB00_2976_v n1_1641180_692128 0 -5.520340000000001e-06
iB00_2977_v n1_1641290_692128 0 0.0
iB00_2978_v n1_1641070_692128 0 5.520340000000001e-06
iB00_2979_v n1_1641180_653216 0 -4.39365e-05
iB00_2980_v n1_1641070_728608 0 4.76485e-06
iB00_2981_v n1_1641290_728608 0 -4.76485e-06
iB00_2982_v n1_1641070_767520 0 4.16025e-06
iB00_2983_v n1_1641290_767520 0 -4.16025e-06
iB00_2984_v n1_1641180_614304 0 -5.04609e-05
iB00_2985_v n1_1641070_653216 0 6.5243e-06
iB00_2986_v n1_1641290_653216 0 -6.5243e-06
iB00_2987_v n1_1602912_653296 0 2.1802900000000003e-06
iB00_2988_v n1_1602912_653136 0 -2.1802900000000003e-06
iB00_2989_v n1_1602912_614304 0 -2.29367e-05
iB00_2990_v n1_1602912_577824 0 -2.66091e-05
iB00_2991_v n1_1602912_614384 0 2.93859e-06
iB00_2992_v n1_1602912_614224 0 -2.93859e-06
iB00_2993_v n1_1564000_614304 0 1.06745e-05
iB00_2994_v n1_1526304_614304 0 1.19481e-05
iB00_2995_v n1_1564000_614384 0 1.27362e-06
iB00_2996_v n1_1564000_614224 0 -1.27362e-06
iB00_2997_v n1_1564000_577824 0 -2.1128500000000003e-05
iB00_2998_v n1_1564000_653296 0 1.20539e-06
iB00_2999_v n1_1564000_653136 0 -1.20539e-06
iB00_3000_v n1_1526304_653296 0 2.2528500000000002e-07
iB00_3001_v n1_1526304_653136 0 -2.2528500000000002e-07
iB00_3002_v n1_1526304_577824 0 -1.6127599999999998e-05
iB00_3003_v n1_1526304_614384 0 -6.44313e-08
iB00_3004_v n1_1526304_614224 0 6.44313e-08
iB00_3005_v n1_1487392_614304 0 1.1883700000000001e-05
iB00_3006_v n1_1487392_614384 0 -7.96998e-07
iB00_3007_v n1_1487392_614224 0 7.96998e-07
iB00_3008_v n1_1487392_577824 0 -1.20283e-05
iB00_3009_v n1_1487392_653296 0 -3.52192e-07
iB00_3010_v n1_1487392_653136 0 3.52192e-07
iB00_3011_v n1_1449696_653296 0 -5.92165e-07
iB00_3012_v n1_1449696_653136 0 5.92165e-07
iB00_3013_v n1_1449696_614384 0 -7.79696e-07
iB00_3014_v n1_1449696_614224 0 7.79696e-07
iB00_3015_v n1_1449696_577904 0 -1.2993200000000001e-06
iB00_3016_v n1_1449696_577744 0 1.2993200000000001e-06
iB00_3017_v n1_1487392_577904 0 -1.30252e-06
iB00_3018_v n1_1487392_577744 0 1.30252e-06
iB00_3019_v n1_1487392_538912 0 -1.13471e-05
iB00_3020_v n1_1487392_502432 0 -1.00869e-05
iB00_3021_v n1_1487392_538992 0 -2.16949e-06
iB00_3022_v n1_1487392_538832 0 2.16949e-06
iB00_3023_v n1_1526304_538912 0 -1.6325499999999998e-05
iB00_3024_v n1_1449696_538992 0 -1.84084e-06
iB00_3025_v n1_1449696_538832 0 1.84084e-06
iB00_3026_v n1_1449696_502432 0 -7.41629e-06
iB00_3027_v n1_1449696_480880 0 -5.24175e-06
iB00_3028_v n1_1449696_502512 0 -2.3314999999999996e-06
iB00_3029_v n1_1449696_502352 0 2.3314999999999996e-06
iB00_3030_v n1_1412000_502512 0 -1.9472599999999997e-06
iB00_3031_v n1_1412000_502352 0 1.9472599999999997e-06
iB00_3032_v n1_1412000_480880 0 -4.08833e-06
iB00_3033_v n1_1412000_480720 0 -2.38524e-17
iB00_3034_v n1_1412000_481040 0 -4.08833e-06
iB00_3035_v n1_1373088_481040 0 -3.23451e-06
iB00_3036_v n1_1373088_480720 0 3.23451e-06
iB00_3037_v n1_1487392_480880 0 -3.2261199999999995e-05
iB00_3038_v n1_1449696_481040 0 -5.24175e-06
iB00_3039_v n1_1449696_480720 0 5.24175e-06
iB00_3040_v n1_1526304_480880 0 -3.96307e-05
iB00_3041_v n1_1487392_481040 0 -7.3695e-06
iB00_3042_v n1_1487392_480720 0 7.3695e-06
iB00_3043_v n1_1487392_502512 0 -3.15755e-06
iB00_3044_v n1_1487392_502352 0 3.15755e-06
iB00_3045_v n1_1526304_502432 0 -1.8656200000000003e-05
iB00_3046_v n1_1564000_502432 0 -2.26447e-05
iB00_3047_v n1_1526304_502512 0 -3.9884700000000005e-06
iB00_3048_v n1_1526304_502352 0 3.9884700000000005e-06
iB00_3049_v n1_1526304_538992 0 -1.81596e-06
iB00_3050_v n1_1526304_538832 0 1.81596e-06
iB00_3051_v n1_1564000_538912 0 -1.8141500000000002e-05
iB00_3052_v n1_1602912_538912 0 -1.78751e-05
iB00_3053_v n1_1564000_538992 0 2.6639e-07
iB00_3054_v n1_1564000_538832 0 -2.6639e-07
iB00_3055_v n1_1564000_577904 0 1.11855e-06
iB00_3056_v n1_1564000_577744 0 -1.11855e-06
iB00_3057_v n1_1526304_577904 0 -5.82048e-07
iB00_3058_v n1_1526304_577744 0 5.82048e-07
iB00_3059_v n1_1641180_577824 0 -8.96864e-06
iB00_3060_v n1_1602912_577904 0 4.3750000000000005e-06
iB00_3061_v n1_1602912_577744 0 -4.3750000000000005e-06
iB00_3062_v n1_1602912_502432 0 -4.00289e-05
iB00_3063_v n1_1602912_538992 0 7.8797e-06
iB00_3064_v n1_1602912_538832 0 -7.8797e-06
iB00_3065_v n1_1641180_538912 0 -9.99541e-06
iB00_3066_v n1_1641290_538912 0 0.0
iB00_3067_v n1_1641070_538912 0 9.99541e-06
iB00_3068_v n1_1641180_502432 0 -7.71608e-05
iB00_3069_v n1_1641070_577824 0 8.96864e-06
iB00_3070_v n1_1641290_577824 0 -8.96864e-06
iB00_3071_v n1_1641070_614304 0 7.73592e-06
iB00_3072_v n1_1641290_614304 0 -7.73592e-06
iB00_3073_v n1_1641180_480880 0 -8.64389e-05
iB00_3074_v n1_1641070_502432 0 9.27811e-06
iB00_3075_v n1_1641290_502432 0 -9.27811e-06
iB00_3076_v n1_1602912_502512 0 1.64861e-05
iB00_3077_v n1_1602912_502352 0 -1.64861e-05
iB00_3078_v n1_1602912_480880 0 -5.67915e-05
iB00_3079_v n1_1602912_480720 0 -1.19262e-17
iB00_3080_v n1_1602912_481040 0 -5.67915e-05
iB00_3081_v n1_1620161_480880 0 -0.000128881
iB00_3082_v n1_1564000_480880 0 7.20895e-05
iB00_3083_v n1_1564000_481040 0 -2.10606e-05
iB00_3084_v n1_1564000_480720 0 2.10606e-05
iB00_3085_v n1_1564000_502512 0 -3.11952e-06
iB00_3086_v n1_1564000_502352 0 3.11952e-06
iB00_3087_v n1_1526304_481040 0 -1.13982e-05
iB00_3088_v n1_1526304_480720 0 1.13982e-05
iB00_3089_v n1_1620161_481040 0 -0.00021532000000000002
iB00_3090_v n1_1620161_480720 0 0.00021532000000000002
iB00_3091_v n1_1620161_300000 0 -0.00021532000000000002
iB00_3092_v n1_1620161_295000 0 -0.000129322
iB00_3093_v n1_1641290_480880 0 0.0
iB00_3094_v n1_1641180_481040 0 -8.64389e-05
iB00_3095_v n1_1641180_480720 0 8.64389e-05
.end
