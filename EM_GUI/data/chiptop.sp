v0 n1_625064_28 0 1.8
v1 n1_625064_46000 0 1.8
v2 n1_625064_624152 0 1.8
v3 n1_625064_670124 0 1.8
v4 n1_46000_28 0 1.8
v5 n1_46000_46000 0 1.8
v6 n1_46000_624152 0 1.8
v7 n1_46000_670124 0 1.8
R14-100-100 n1_625064_28 n1_625064_0 7e-05
R14-101-100 n1_625064_46000 n1_625064_28 0.11493
R14-102-100 n1_625064_50000 n1_625064_46000 0.01
R14-103-100 n1_625064_53344 n1_625064_50000 0.00836
R14-104-100 n1_625064_56688 n1_625064_53344 0.00836
R14-105-100 n1_625064_60032 n1_625064_56688 0.00836
R14-106-100 n1_625064_63376 n1_625064_60032 0.00836
R14-107-100 n1_625064_66720 n1_625064_63376 0.00836
R14-108-100 n1_625064_67278 n1_625064_66720 0.001395
R14-109-100 n1_625064_70064 n1_625064_67278 0.006965000000000001
R14-110-100 n1_625064_73408 n1_625064_70064 0.00836
R14-111-100 n1_625064_76752 n1_625064_73408 0.00836
R14-112-100 n1_625064_80096 n1_625064_76752 0.00836
R14-113-100 n1_625064_83440 n1_625064_80096 0.00836
R14-114-100 n1_625064_86784 n1_625064_83440 0.00836
R14-115-100 n1_625064_89166 n1_625064_86784 0.005955
R14-116-100 n1_625064_90128 n1_625064_89166 0.002405
R14-117-100 n1_625064_93472 n1_625064_90128 0.00836
R14-118-100 n1_625064_96816 n1_625064_93472 0.00836
R14-119-100 n1_625064_100160 n1_625064_96816 0.00836
R14-120-100 n1_625064_103504 n1_625064_100160 0.00836
R14-121-100 n1_625064_106848 n1_625064_103504 0.00836
R14-122-100 n1_625064_110192 n1_625064_106848 0.00836
R14-123-100 n1_625064_111662 n1_625064_110192 0.003675
R14-124-100 n1_625064_113536 n1_625064_111662 0.004685
R14-125-100 n1_625064_116880 n1_625064_113536 0.00836
R14-126-100 n1_625064_120224 n1_625064_116880 0.00836
R14-127-100 n1_625064_123568 n1_625064_120224 0.00836
R14-128-100 n1_625064_126912 n1_625064_123568 0.00836
R14-129-100 n1_625064_130256 n1_625064_126912 0.00836
R14-130-100 n1_625064_133550 n1_625064_130256 0.008235000000000001
R14-131-100 n1_625064_133600 n1_625064_133550 0.000125
R14-132-100 n1_625064_136944 n1_625064_133600 0.00836
R14-133-100 n1_625064_140288 n1_625064_136944 0.00836
R14-134-100 n1_625064_143632 n1_625064_140288 0.00836
R14-135-100 n1_625064_146976 n1_625064_143632 0.00836
R14-136-100 n1_625064_150320 n1_625064_146976 0.00836
R14-137-100 n1_625064_153664 n1_625064_150320 0.00836
R14-138-100 n1_625064_156046 n1_625064_153664 0.005955
R14-139-100 n1_625064_157008 n1_625064_156046 0.002405
R14-140-100 n1_625064_160352 n1_625064_157008 0.00836
R14-141-100 n1_625064_163696 n1_625064_160352 0.00836
R14-142-100 n1_625064_167040 n1_625064_163696 0.00836
R14-143-100 n1_625064_170384 n1_625064_167040 0.00836
R14-144-100 n1_625064_173728 n1_625064_170384 0.00836
R14-145-100 n1_625064_177072 n1_625064_173728 0.00836
R14-146-100 n1_625064_177934 n1_625064_177072 0.002155
R14-147-100 n1_625064_180416 n1_625064_177934 0.0062050000000000004
R14-148-100 n1_625064_183760 n1_625064_180416 0.00836
R14-149-100 n1_625064_187104 n1_625064_183760 0.00836
R14-150-100 n1_625064_190448 n1_625064_187104 0.00836
R14-151-100 n1_625064_193792 n1_625064_190448 0.00836
R14-152-100 n1_625064_197136 n1_625064_193792 0.00836
R14-153-100 n1_625064_200430 n1_625064_197136 0.008235000000000001
R14-154-100 n1_625064_200480 n1_625064_200430 0.000125
R14-155-100 n1_625064_203824 n1_625064_200480 0.00836
R14-156-100 n1_625064_207168 n1_625064_203824 0.00836
R14-157-100 n1_625064_210512 n1_625064_207168 0.00836
R14-158-100 n1_625064_213856 n1_625064_210512 0.00836
R14-159-100 n1_625064_217200 n1_625064_213856 0.00836
R14-160-100 n1_625064_220544 n1_625064_217200 0.00836
R14-161-100 n1_625064_222318 n1_625064_220544 0.004435
R14-162-100 n1_625064_223888 n1_625064_222318 0.003925
R14-163-100 n1_625064_227232 n1_625064_223888 0.00836
R14-164-100 n1_625064_230576 n1_625064_227232 0.00836
R14-165-100 n1_625064_233920 n1_625064_230576 0.00836
R14-166-100 n1_625064_237264 n1_625064_233920 0.00836
R14-167-100 n1_625064_240608 n1_625064_237264 0.00836
R14-168-100 n1_625064_243952 n1_625064_240608 0.00836
R14-169-100 n1_625064_244814 n1_625064_243952 0.002155
R14-170-100 n1_625064_247296 n1_625064_244814 0.0062050000000000004
R14-171-100 n1_625064_250640 n1_625064_247296 0.00836
R14-172-100 n1_625064_253984 n1_625064_250640 0.00836
R14-173-100 n1_625064_257328 n1_625064_253984 0.00836
R14-174-100 n1_625064_260672 n1_625064_257328 0.00836
R14-175-100 n1_625064_264016 n1_625064_260672 0.00836
R14-176-100 n1_625064_266702 n1_625064_264016 0.0067150000000000005
R14-177-100 n1_625064_267360 n1_625064_266702 0.001645
R14-178-100 n1_625064_270704 n1_625064_267360 0.00836
R14-179-100 n1_625064_274048 n1_625064_270704 0.00836
R14-180-100 n1_625064_277392 n1_625064_274048 0.00836
R14-181-100 n1_625064_280736 n1_625064_277392 0.00836
R14-182-100 n1_625064_284080 n1_625064_280736 0.00836
R14-183-100 n1_625064_287424 n1_625064_284080 0.00836
R14-184-100 n1_625064_288590 n1_625064_287424 0.002915
R14-185-100 n1_625064_290768 n1_625064_288590 0.005445
R14-186-100 n1_625064_294112 n1_625064_290768 0.00836
R14-187-100 n1_625064_297456 n1_625064_294112 0.00836
R14-188-100 n1_625064_300800 n1_625064_297456 0.00836
R14-189-100 n1_625064_304144 n1_625064_300800 0.00836
R14-190-100 n1_625064_307488 n1_625064_304144 0.00836
R14-191-100 n1_625064_310832 n1_625064_307488 0.00836
R14-192-100 n1_625064_311086 n1_625064_310832 0.0006349999999999999
R14-193-100 n1_625064_314176 n1_625064_311086 0.007725
R14-194-100 n1_625064_317520 n1_625064_314176 0.00836
R14-195-100 n1_625064_320864 n1_625064_317520 0.00836
R14-196-100 n1_625064_324208 n1_625064_320864 0.00836
R14-197-100 n1_625064_327552 n1_625064_324208 0.00836
R14-198-100 n1_625064_330896 n1_625064_327552 0.00836
R14-199-100 n1_625064_332974 n1_625064_330896 0.005195
R14-200-100 n1_625064_334240 n1_625064_332974 0.003165
R14-201-100 n1_625064_337584 n1_625064_334240 0.00836
R14-202-100 n1_625064_340928 n1_625064_337584 0.00836
R14-203-100 n1_625064_344272 n1_625064_340928 0.00836
R14-204-100 n1_625064_347616 n1_625064_344272 0.00836
R14-205-100 n1_625064_350960 n1_625064_347616 0.00836
R14-206-100 n1_625064_354304 n1_625064_350960 0.00836
R14-207-100 n1_625064_355470 n1_625064_354304 0.002915
R14-208-100 n1_625064_357648 n1_625064_355470 0.005445
R14-209-100 n1_625064_360992 n1_625064_357648 0.00836
R14-210-100 n1_625064_364336 n1_625064_360992 0.00836
R14-211-100 n1_625064_367680 n1_625064_364336 0.00836
R14-212-100 n1_625064_371024 n1_625064_367680 0.00836
R14-213-100 n1_625064_374368 n1_625064_371024 0.00836
R14-214-100 n1_625064_377358 n1_625064_374368 0.007475
R14-215-100 n1_625064_377712 n1_625064_377358 0.000885
R14-216-100 n1_625064_381056 n1_625064_377712 0.00836
R14-217-100 n1_625064_384400 n1_625064_381056 0.00836
R14-218-100 n1_625064_387744 n1_625064_384400 0.00836
R14-219-100 n1_625064_391088 n1_625064_387744 0.00836
R14-220-100 n1_625064_394432 n1_625064_391088 0.00836
R14-221-100 n1_625064_397776 n1_625064_394432 0.00836
R14-222-100 n1_625064_399854 n1_625064_397776 0.005195
R14-223-100 n1_625064_401120 n1_625064_399854 0.003165
R14-224-100 n1_625064_404464 n1_625064_401120 0.00836
R14-225-100 n1_625064_407808 n1_625064_404464 0.00836
R14-226-100 n1_625064_411152 n1_625064_407808 0.00836
R14-227-100 n1_625064_414496 n1_625064_411152 0.00836
R14-228-100 n1_625064_417840 n1_625064_414496 0.00836
R14-229-100 n1_625064_421184 n1_625064_417840 0.00836
R14-230-100 n1_625064_421742 n1_625064_421184 0.001395
R14-231-100 n1_625064_424528 n1_625064_421742 0.006965000000000001
R14-232-100 n1_625064_427872 n1_625064_424528 0.00836
R14-233-100 n1_625064_431216 n1_625064_427872 0.00836
R14-234-100 n1_625064_434560 n1_625064_431216 0.00836
R14-235-100 n1_625064_437904 n1_625064_434560 0.00836
R14-236-100 n1_625064_441248 n1_625064_437904 0.00836
R14-237-100 n1_625064_444238 n1_625064_441248 0.007475
R14-238-100 n1_625064_444592 n1_625064_444238 0.000885
R14-239-100 n1_625064_447936 n1_625064_444592 0.00836
R14-240-100 n1_625064_451280 n1_625064_447936 0.00836
R14-241-100 n1_625064_454624 n1_625064_451280 0.00836
R14-242-100 n1_625064_457968 n1_625064_454624 0.00836
R14-243-100 n1_625064_461312 n1_625064_457968 0.00836
R14-244-100 n1_625064_464656 n1_625064_461312 0.00836
R14-245-100 n1_625064_466126 n1_625064_464656 0.003675
R14-246-100 n1_625064_468000 n1_625064_466126 0.004685
R14-247-100 n1_625064_471344 n1_625064_468000 0.00836
R14-248-100 n1_625064_474688 n1_625064_471344 0.00836
R14-249-100 n1_625064_478032 n1_625064_474688 0.00836
R14-250-100 n1_625064_481376 n1_625064_478032 0.00836
R14-251-100 n1_625064_484720 n1_625064_481376 0.00836
R14-252-100 n1_625064_488064 n1_625064_484720 0.00836
R14-253-100 n1_625064_488622 n1_625064_488064 0.001395
R14-254-100 n1_625064_491408 n1_625064_488622 0.006965000000000001
R14-255-100 n1_625064_494752 n1_625064_491408 0.00836
R14-256-100 n1_625064_498096 n1_625064_494752 0.00836
R14-257-100 n1_625064_501440 n1_625064_498096 0.00836
R14-258-100 n1_625064_504784 n1_625064_501440 0.00836
R14-259-100 n1_625064_508128 n1_625064_504784 0.00836
R14-260-100 n1_625064_510510 n1_625064_508128 0.005955
R14-261-100 n1_625064_511472 n1_625064_510510 0.002405
R14-262-100 n1_625064_514816 n1_625064_511472 0.00836
R14-263-100 n1_625064_518160 n1_625064_514816 0.00836
R14-264-100 n1_625064_521504 n1_625064_518160 0.00836
R14-265-100 n1_625064_524848 n1_625064_521504 0.00836
R14-266-100 n1_625064_528192 n1_625064_524848 0.00836
R14-267-100 n1_625064_531536 n1_625064_528192 0.00836
R14-268-100 n1_625064_532398 n1_625064_531536 0.002155
R14-269-100 n1_625064_534880 n1_625064_532398 0.0062050000000000004
R14-270-100 n1_625064_538224 n1_625064_534880 0.00836
R14-271-100 n1_625064_541568 n1_625064_538224 0.00836
R14-272-100 n1_625064_544912 n1_625064_541568 0.00836
R14-273-100 n1_625064_548256 n1_625064_544912 0.00836
R14-274-100 n1_625064_551600 n1_625064_548256 0.00836
R14-275-100 n1_625064_554894 n1_625064_551600 0.008235000000000001
R14-276-100 n1_625064_554944 n1_625064_554894 0.000125
R14-277-100 n1_625064_558288 n1_625064_554944 0.00836
R14-278-100 n1_625064_561632 n1_625064_558288 0.00836
R14-279-100 n1_625064_564976 n1_625064_561632 0.00836
R14-280-100 n1_625064_568320 n1_625064_564976 0.00836
R14-281-100 n1_625064_571664 n1_625064_568320 0.00836
R14-282-100 n1_625064_575008 n1_625064_571664 0.00836
R14-283-100 n1_625064_576782 n1_625064_575008 0.004435
R14-284-100 n1_625064_578352 n1_625064_576782 0.003925
R14-285-100 n1_625064_581696 n1_625064_578352 0.00836
R14-286-100 n1_625064_585040 n1_625064_581696 0.00836
R14-287-100 n1_625064_588384 n1_625064_585040 0.00836
R14-288-100 n1_625064_591728 n1_625064_588384 0.00836
R14-289-100 n1_625064_595072 n1_625064_591728 0.00836
R14-290-100 n1_625064_598416 n1_625064_595072 0.00836
R14-291-100 n1_625064_599278 n1_625064_598416 0.002155
R14-292-100 n1_625064_601760 n1_625064_599278 0.0062050000000000004
R14-293-100 n1_625064_605104 n1_625064_601760 0.00836
R14-294-100 n1_625064_608448 n1_625064_605104 0.00836
R14-295-100 n1_625064_611792 n1_625064_608448 0.00836
R14-296-100 n1_625064_615136 n1_625064_611792 0.00836
R14-297-100 n1_625064_618480 n1_625064_615136 0.00836
R14-298-100 n1_625064_624152 n1_625064_618480 0.014180000000000002
R14-299-100 n1_625064_670124 n1_625064_624152 0.11493
R14-300-100 n1_625064_670152 n1_625064_670124 7e-05
R14-301-100 n1_601546_46000 n1_601546_44000 0.00657895
R14-302-100 n1_601546_50000 n1_601546_46000 0.0131579
R14-303-100 n1_601546_53344 n1_601546_50000 0.011
R14-304-100 n1_601546_56688 n1_601546_53344 0.011
R14-305-100 n1_601546_60032 n1_601546_56688 0.011
R14-306-100 n1_601546_63376 n1_601546_60032 0.011
R14-307-100 n1_601546_66720 n1_601546_63376 0.011
R14-308-100 n1_601546_67278 n1_601546_66720 0.0018355300000000001
R14-309-100 n1_601546_70064 n1_601546_67278 0.00916447
R14-310-100 n1_601546_73408 n1_601546_70064 0.011
R14-311-100 n1_601546_76752 n1_601546_73408 0.011
R14-312-100 n1_601546_80096 n1_601546_76752 0.011
R14-313-100 n1_601546_83440 n1_601546_80096 0.011
R14-314-100 n1_601546_86784 n1_601546_83440 0.011
R14-315-100 n1_601546_89166 n1_601546_86784 0.00783553
R14-316-100 n1_601546_90128 n1_601546_89166 0.00316447
R14-317-100 n1_601546_93472 n1_601546_90128 0.011
R14-318-100 n1_601546_96816 n1_601546_93472 0.011
R14-319-100 n1_601546_100160 n1_601546_96816 0.011
R14-320-100 n1_601546_103504 n1_601546_100160 0.011
R14-321-100 n1_601546_106848 n1_601546_103504 0.011
R14-322-100 n1_601546_110192 n1_601546_106848 0.011
R14-323-100 n1_601546_111662 n1_601546_110192 0.004835529999999999
R14-324-100 n1_601546_113536 n1_601546_111662 0.00616447
R14-325-100 n1_601546_116880 n1_601546_113536 0.011
R14-326-100 n1_601546_120224 n1_601546_116880 0.011
R14-327-100 n1_601546_123568 n1_601546_120224 0.011
R14-328-100 n1_601546_126912 n1_601546_123568 0.011
R14-329-100 n1_601546_130256 n1_601546_126912 0.011
R14-330-100 n1_601546_133550 n1_601546_130256 0.010835500000000001
R14-331-100 n1_601546_133600 n1_601546_133550 0.000164474
R14-332-100 n1_601546_136944 n1_601546_133600 0.011
R14-333-100 n1_601546_140288 n1_601546_136944 0.011
R14-334-100 n1_601546_143632 n1_601546_140288 0.011
R14-335-100 n1_601546_146976 n1_601546_143632 0.011
R14-336-100 n1_601546_150320 n1_601546_146976 0.011
R14-337-100 n1_601546_153664 n1_601546_150320 0.011
R14-338-100 n1_601546_156046 n1_601546_153664 0.00783553
R14-339-100 n1_601546_157008 n1_601546_156046 0.00316447
R14-340-100 n1_601546_160352 n1_601546_157008 0.011
R14-341-100 n1_601546_163696 n1_601546_160352 0.011
R14-342-100 n1_601546_167040 n1_601546_163696 0.011
R14-343-100 n1_601546_170384 n1_601546_167040 0.011
R14-344-100 n1_601546_173728 n1_601546_170384 0.011
R14-345-100 n1_601546_177072 n1_601546_173728 0.011
R14-346-100 n1_601546_177934 n1_601546_177072 0.00283553
R14-347-100 n1_601546_180416 n1_601546_177934 0.00816447
R14-348-100 n1_601546_183760 n1_601546_180416 0.011
R14-349-100 n1_601546_187104 n1_601546_183760 0.011
R14-350-100 n1_601546_190448 n1_601546_187104 0.011
R14-351-100 n1_601546_193792 n1_601546_190448 0.011
R14-352-100 n1_601546_197136 n1_601546_193792 0.011
R14-353-100 n1_601546_200430 n1_601546_197136 0.010835500000000001
R14-354-100 n1_601546_200480 n1_601546_200430 0.000164474
R14-355-100 n1_601546_203824 n1_601546_200480 0.011
R14-356-100 n1_601546_207168 n1_601546_203824 0.011
R14-357-100 n1_601546_210512 n1_601546_207168 0.011
R14-358-100 n1_601546_213856 n1_601546_210512 0.011
R14-359-100 n1_601546_217200 n1_601546_213856 0.011
R14-360-100 n1_601546_220544 n1_601546_217200 0.011
R14-361-100 n1_601546_222318 n1_601546_220544 0.00583553
R14-362-100 n1_601546_223888 n1_601546_222318 0.00516447
R14-363-100 n1_601546_227232 n1_601546_223888 0.011
R14-364-100 n1_601546_230576 n1_601546_227232 0.011
R14-365-100 n1_601546_233920 n1_601546_230576 0.011
R14-366-100 n1_601546_237264 n1_601546_233920 0.011
R14-367-100 n1_601546_240608 n1_601546_237264 0.011
R14-368-100 n1_601546_243952 n1_601546_240608 0.011
R14-369-100 n1_601546_244814 n1_601546_243952 0.00283553
R14-370-100 n1_601546_247296 n1_601546_244814 0.00816447
R14-371-100 n1_601546_250640 n1_601546_247296 0.011
R14-372-100 n1_601546_253984 n1_601546_250640 0.011
R14-373-100 n1_601546_257328 n1_601546_253984 0.011
R14-374-100 n1_601546_260672 n1_601546_257328 0.011
R14-375-100 n1_601546_264016 n1_601546_260672 0.011
R14-376-100 n1_601546_266702 n1_601546_264016 0.00883553
R14-377-100 n1_601546_267360 n1_601546_266702 0.00216447
R14-378-100 n1_601546_270704 n1_601546_267360 0.011
R14-379-100 n1_601546_274048 n1_601546_270704 0.011
R14-380-100 n1_601546_277392 n1_601546_274048 0.011
R14-381-100 n1_601546_280736 n1_601546_277392 0.011
R14-382-100 n1_601546_284080 n1_601546_280736 0.011
R14-383-100 n1_601546_287424 n1_601546_284080 0.011
R14-384-100 n1_601546_288590 n1_601546_287424 0.00383553
R14-385-100 n1_601546_290768 n1_601546_288590 0.007164470000000001
R14-386-100 n1_601546_294112 n1_601546_290768 0.011
R14-387-100 n1_601546_297456 n1_601546_294112 0.011
R14-388-100 n1_601546_300800 n1_601546_297456 0.011
R14-389-100 n1_601546_304144 n1_601546_300800 0.011
R14-390-100 n1_601546_307488 n1_601546_304144 0.011
R14-391-100 n1_601546_310832 n1_601546_307488 0.011
R14-392-100 n1_601546_311086 n1_601546_310832 0.000835526
R14-393-100 n1_601546_314176 n1_601546_311086 0.0101645
R14-394-100 n1_601546_317520 n1_601546_314176 0.011
R14-395-100 n1_601546_320864 n1_601546_317520 0.011
R14-396-100 n1_601546_324208 n1_601546_320864 0.011
R14-397-100 n1_601546_327552 n1_601546_324208 0.011
R14-398-100 n1_601546_330896 n1_601546_327552 0.011
R14-399-100 n1_601546_332974 n1_601546_330896 0.006835529999999999
R14-400-100 n1_601546_334240 n1_601546_332974 0.00416447
R14-401-100 n1_601546_337584 n1_601546_334240 0.011
R14-402-100 n1_601546_340928 n1_601546_337584 0.011
R14-403-100 n1_601546_344272 n1_601546_340928 0.011
R14-404-100 n1_601546_347616 n1_601546_344272 0.011
R14-405-100 n1_601546_350960 n1_601546_347616 0.011
R14-406-100 n1_601546_354304 n1_601546_350960 0.011
R14-407-100 n1_601546_355470 n1_601546_354304 0.00383553
R14-408-100 n1_601546_357648 n1_601546_355470 0.007164470000000001
R14-409-100 n1_601546_360992 n1_601546_357648 0.011
R14-410-100 n1_601546_364336 n1_601546_360992 0.011
R14-411-100 n1_601546_367680 n1_601546_364336 0.011
R14-412-100 n1_601546_371024 n1_601546_367680 0.011
R14-413-100 n1_601546_374368 n1_601546_371024 0.011
R14-414-100 n1_601546_377358 n1_601546_374368 0.00983553
R14-415-100 n1_601546_377712 n1_601546_377358 0.00116447
R14-416-100 n1_601546_381056 n1_601546_377712 0.011
R14-417-100 n1_601546_384400 n1_601546_381056 0.011
R14-418-100 n1_601546_387744 n1_601546_384400 0.011
R14-419-100 n1_601546_391088 n1_601546_387744 0.011
R14-420-100 n1_601546_394432 n1_601546_391088 0.011
R14-421-100 n1_601546_397776 n1_601546_394432 0.011
R14-422-100 n1_601546_399854 n1_601546_397776 0.006835529999999999
R14-423-100 n1_601546_401120 n1_601546_399854 0.00416447
R14-424-100 n1_601546_404464 n1_601546_401120 0.011
R14-425-100 n1_601546_407808 n1_601546_404464 0.011
R14-426-100 n1_601546_411152 n1_601546_407808 0.011
R14-427-100 n1_601546_414496 n1_601546_411152 0.011
R14-428-100 n1_601546_417840 n1_601546_414496 0.011
R14-429-100 n1_601546_421184 n1_601546_417840 0.011
R14-430-100 n1_601546_421742 n1_601546_421184 0.0018355300000000001
R14-431-100 n1_601546_424528 n1_601546_421742 0.00916447
R14-432-100 n1_601546_427872 n1_601546_424528 0.011
R14-433-100 n1_601546_431216 n1_601546_427872 0.011
R14-434-100 n1_601546_434560 n1_601546_431216 0.011
R14-435-100 n1_601546_437904 n1_601546_434560 0.011
R14-436-100 n1_601546_441248 n1_601546_437904 0.011
R14-437-100 n1_601546_444238 n1_601546_441248 0.00983553
R14-438-100 n1_601546_444592 n1_601546_444238 0.00116447
R14-439-100 n1_601546_447936 n1_601546_444592 0.011
R14-440-100 n1_601546_451280 n1_601546_447936 0.011
R14-441-100 n1_601546_454624 n1_601546_451280 0.011
R14-442-100 n1_601546_457968 n1_601546_454624 0.011
R14-443-100 n1_601546_461312 n1_601546_457968 0.011
R14-444-100 n1_601546_464656 n1_601546_461312 0.011
R14-445-100 n1_601546_466126 n1_601546_464656 0.004835529999999999
R14-446-100 n1_601546_468000 n1_601546_466126 0.00616447
R14-447-100 n1_601546_471344 n1_601546_468000 0.011
R14-448-100 n1_601546_474688 n1_601546_471344 0.011
R14-449-100 n1_601546_478032 n1_601546_474688 0.011
R14-450-100 n1_601546_481376 n1_601546_478032 0.011
R14-451-100 n1_601546_484720 n1_601546_481376 0.011
R14-452-100 n1_601546_488064 n1_601546_484720 0.011
R14-453-100 n1_601546_488622 n1_601546_488064 0.0018355300000000001
R14-454-100 n1_601546_491408 n1_601546_488622 0.00916447
R14-455-100 n1_601546_494752 n1_601546_491408 0.011
R14-456-100 n1_601546_498096 n1_601546_494752 0.011
R14-457-100 n1_601546_501440 n1_601546_498096 0.011
R14-458-100 n1_601546_504784 n1_601546_501440 0.011
R14-459-100 n1_601546_508128 n1_601546_504784 0.011
R14-460-100 n1_601546_510510 n1_601546_508128 0.00783553
R14-461-100 n1_601546_511472 n1_601546_510510 0.00316447
R14-462-100 n1_601546_514816 n1_601546_511472 0.011
R14-463-100 n1_601546_518160 n1_601546_514816 0.011
R14-464-100 n1_601546_521504 n1_601546_518160 0.011
R14-465-100 n1_601546_524848 n1_601546_521504 0.011
R14-466-100 n1_601546_528192 n1_601546_524848 0.011
R14-467-100 n1_601546_531536 n1_601546_528192 0.011
R14-468-100 n1_601546_532398 n1_601546_531536 0.00283553
R14-469-100 n1_601546_534880 n1_601546_532398 0.00816447
R14-470-100 n1_601546_538224 n1_601546_534880 0.011
R14-471-100 n1_601546_541568 n1_601546_538224 0.011
R14-472-100 n1_601546_544912 n1_601546_541568 0.011
R14-473-100 n1_601546_548256 n1_601546_544912 0.011
R14-474-100 n1_601546_551600 n1_601546_548256 0.011
R14-475-100 n1_601546_554894 n1_601546_551600 0.010835500000000001
R14-476-100 n1_601546_554944 n1_601546_554894 0.000164474
R14-477-100 n1_601546_558288 n1_601546_554944 0.011
R14-478-100 n1_601546_561632 n1_601546_558288 0.011
R14-479-100 n1_601546_564976 n1_601546_561632 0.011
R14-480-100 n1_601546_568320 n1_601546_564976 0.011
R14-481-100 n1_601546_571664 n1_601546_568320 0.011
R14-482-100 n1_601546_575008 n1_601546_571664 0.011
R14-483-100 n1_601546_576782 n1_601546_575008 0.00583553
R14-484-100 n1_601546_578352 n1_601546_576782 0.00516447
R14-485-100 n1_601546_581696 n1_601546_578352 0.011
R14-486-100 n1_601546_585040 n1_601546_581696 0.011
R14-487-100 n1_601546_588384 n1_601546_585040 0.011
R14-488-100 n1_601546_591728 n1_601546_588384 0.011
R14-489-100 n1_601546_595072 n1_601546_591728 0.011
R14-490-100 n1_601546_598416 n1_601546_595072 0.011
R14-491-100 n1_601546_599278 n1_601546_598416 0.00283553
R14-492-100 n1_601546_601760 n1_601546_599278 0.00816447
R14-493-100 n1_601546_605104 n1_601546_601760 0.011
R14-494-100 n1_601546_608448 n1_601546_605104 0.011
R14-495-100 n1_601546_611792 n1_601546_608448 0.011
R14-496-100 n1_601546_615136 n1_601546_611792 0.011
R14-497-100 n1_601546_618480 n1_601546_615136 0.011
R14-498-100 n1_601546_624152 n1_601546_618480 0.018657899999999998
R14-499-100 n1_601546_626152 n1_601546_624152 0.00657895
R14-500-100 n1_579050_46000 n1_579050_44000 0.00657895
R14-501-100 n1_579050_50000 n1_579050_46000 0.0131579
R14-502-100 n1_579050_53344 n1_579050_50000 0.011
R14-503-100 n1_579050_56688 n1_579050_53344 0.011
R14-504-100 n1_579050_60032 n1_579050_56688 0.011
R14-505-100 n1_579050_63376 n1_579050_60032 0.011
R14-506-100 n1_579050_66720 n1_579050_63376 0.011
R14-507-100 n1_579050_67278 n1_579050_66720 0.0018355300000000001
R14-508-100 n1_579050_70064 n1_579050_67278 0.00916447
R14-509-100 n1_579050_73408 n1_579050_70064 0.011
R14-510-100 n1_579050_76752 n1_579050_73408 0.011
R14-511-100 n1_579050_80096 n1_579050_76752 0.011
R14-512-100 n1_579050_83440 n1_579050_80096 0.011
R14-513-100 n1_579050_86784 n1_579050_83440 0.011
R14-514-100 n1_579050_89166 n1_579050_86784 0.00783553
R14-515-100 n1_579050_90128 n1_579050_89166 0.00316447
R14-516-100 n1_579050_93472 n1_579050_90128 0.011
R14-517-100 n1_579050_96816 n1_579050_93472 0.011
R14-518-100 n1_579050_100160 n1_579050_96816 0.011
R14-519-100 n1_579050_103504 n1_579050_100160 0.011
R14-520-100 n1_579050_106848 n1_579050_103504 0.011
R14-521-100 n1_579050_110192 n1_579050_106848 0.011
R14-522-100 n1_579050_111662 n1_579050_110192 0.004835529999999999
R14-523-100 n1_579050_113536 n1_579050_111662 0.00616447
R14-524-100 n1_579050_116880 n1_579050_113536 0.011
R14-525-100 n1_579050_120224 n1_579050_116880 0.011
R14-526-100 n1_579050_123568 n1_579050_120224 0.011
R14-527-100 n1_579050_126912 n1_579050_123568 0.011
R14-528-100 n1_579050_130256 n1_579050_126912 0.011
R14-529-100 n1_579050_133550 n1_579050_130256 0.010835500000000001
R14-530-100 n1_579050_133600 n1_579050_133550 0.000164474
R14-531-100 n1_579050_136944 n1_579050_133600 0.011
R14-532-100 n1_579050_140288 n1_579050_136944 0.011
R14-533-100 n1_579050_143632 n1_579050_140288 0.011
R14-534-100 n1_579050_146976 n1_579050_143632 0.011
R14-535-100 n1_579050_150320 n1_579050_146976 0.011
R14-536-100 n1_579050_153664 n1_579050_150320 0.011
R14-537-100 n1_579050_156046 n1_579050_153664 0.00783553
R14-538-100 n1_579050_157008 n1_579050_156046 0.00316447
R14-539-100 n1_579050_160352 n1_579050_157008 0.011
R14-540-100 n1_579050_163696 n1_579050_160352 0.011
R14-541-100 n1_579050_167040 n1_579050_163696 0.011
R14-542-100 n1_579050_170384 n1_579050_167040 0.011
R14-543-100 n1_579050_173728 n1_579050_170384 0.011
R14-544-100 n1_579050_177072 n1_579050_173728 0.011
R14-545-100 n1_579050_177934 n1_579050_177072 0.00283553
R14-546-100 n1_579050_180416 n1_579050_177934 0.00816447
R14-547-100 n1_579050_183760 n1_579050_180416 0.011
R14-548-100 n1_579050_187104 n1_579050_183760 0.011
R14-549-100 n1_579050_190448 n1_579050_187104 0.011
R14-550-100 n1_579050_193792 n1_579050_190448 0.011
R14-551-100 n1_579050_197136 n1_579050_193792 0.011
R14-552-100 n1_579050_200430 n1_579050_197136 0.010835500000000001
R14-553-100 n1_579050_200480 n1_579050_200430 0.000164474
R14-554-100 n1_579050_203824 n1_579050_200480 0.011
R14-555-100 n1_579050_207168 n1_579050_203824 0.011
R14-556-100 n1_579050_210512 n1_579050_207168 0.011
R14-557-100 n1_579050_213856 n1_579050_210512 0.011
R14-558-100 n1_579050_217200 n1_579050_213856 0.011
R14-559-100 n1_579050_220544 n1_579050_217200 0.011
R14-560-100 n1_579050_222318 n1_579050_220544 0.00583553
R14-561-100 n1_579050_223888 n1_579050_222318 0.00516447
R14-562-100 n1_579050_227232 n1_579050_223888 0.011
R14-563-100 n1_579050_230576 n1_579050_227232 0.011
R14-564-100 n1_579050_233920 n1_579050_230576 0.011
R14-565-100 n1_579050_237264 n1_579050_233920 0.011
R14-566-100 n1_579050_240608 n1_579050_237264 0.011
R14-567-100 n1_579050_243952 n1_579050_240608 0.011
R14-568-100 n1_579050_244814 n1_579050_243952 0.00283553
R14-569-100 n1_579050_247296 n1_579050_244814 0.00816447
R14-570-100 n1_579050_250640 n1_579050_247296 0.011
R14-571-100 n1_579050_253984 n1_579050_250640 0.011
R14-572-100 n1_579050_257328 n1_579050_253984 0.011
R14-573-100 n1_579050_260672 n1_579050_257328 0.011
R14-574-100 n1_579050_264016 n1_579050_260672 0.011
R14-575-100 n1_579050_266702 n1_579050_264016 0.00883553
R14-576-100 n1_579050_267360 n1_579050_266702 0.00216447
R14-577-100 n1_579050_270704 n1_579050_267360 0.011
R14-578-100 n1_579050_274048 n1_579050_270704 0.011
R14-579-100 n1_579050_277392 n1_579050_274048 0.011
R14-580-100 n1_579050_280736 n1_579050_277392 0.011
R14-581-100 n1_579050_284080 n1_579050_280736 0.011
R14-582-100 n1_579050_287424 n1_579050_284080 0.011
R14-583-100 n1_579050_288590 n1_579050_287424 0.00383553
R14-584-100 n1_579050_290768 n1_579050_288590 0.007164470000000001
R14-585-100 n1_579050_294112 n1_579050_290768 0.011
R14-586-100 n1_579050_297456 n1_579050_294112 0.011
R14-587-100 n1_579050_300800 n1_579050_297456 0.011
R14-588-100 n1_579050_304144 n1_579050_300800 0.011
R14-589-100 n1_579050_307488 n1_579050_304144 0.011
R14-590-100 n1_579050_310832 n1_579050_307488 0.011
R14-591-100 n1_579050_311086 n1_579050_310832 0.000835526
R14-592-100 n1_579050_314176 n1_579050_311086 0.0101645
R14-593-100 n1_579050_317520 n1_579050_314176 0.011
R14-594-100 n1_579050_320864 n1_579050_317520 0.011
R14-595-100 n1_579050_324208 n1_579050_320864 0.011
R14-596-100 n1_579050_327552 n1_579050_324208 0.011
R14-597-100 n1_579050_330896 n1_579050_327552 0.011
R14-598-100 n1_579050_332974 n1_579050_330896 0.006835529999999999
R14-599-100 n1_579050_334240 n1_579050_332974 0.00416447
R14-600-100 n1_579050_337584 n1_579050_334240 0.011
R14-601-100 n1_579050_340928 n1_579050_337584 0.011
R14-602-100 n1_579050_344272 n1_579050_340928 0.011
R14-603-100 n1_579050_347616 n1_579050_344272 0.011
R14-604-100 n1_579050_350960 n1_579050_347616 0.011
R14-605-100 n1_579050_354304 n1_579050_350960 0.011
R14-606-100 n1_579050_355470 n1_579050_354304 0.00383553
R14-607-100 n1_579050_357648 n1_579050_355470 0.007164470000000001
R14-608-100 n1_579050_360992 n1_579050_357648 0.011
R14-609-100 n1_579050_364336 n1_579050_360992 0.011
R14-610-100 n1_579050_367680 n1_579050_364336 0.011
R14-611-100 n1_579050_371024 n1_579050_367680 0.011
R14-612-100 n1_579050_374368 n1_579050_371024 0.011
R14-613-100 n1_579050_377358 n1_579050_374368 0.00983553
R14-614-100 n1_579050_377712 n1_579050_377358 0.00116447
R14-615-100 n1_579050_381056 n1_579050_377712 0.011
R14-616-100 n1_579050_384400 n1_579050_381056 0.011
R14-617-100 n1_579050_387744 n1_579050_384400 0.011
R14-618-100 n1_579050_391088 n1_579050_387744 0.011
R14-619-100 n1_579050_394432 n1_579050_391088 0.011
R14-620-100 n1_579050_397776 n1_579050_394432 0.011
R14-621-100 n1_579050_399854 n1_579050_397776 0.006835529999999999
R14-622-100 n1_579050_401120 n1_579050_399854 0.00416447
R14-623-100 n1_579050_404464 n1_579050_401120 0.011
R14-624-100 n1_579050_407808 n1_579050_404464 0.011
R14-625-100 n1_579050_411152 n1_579050_407808 0.011
R14-626-100 n1_579050_414496 n1_579050_411152 0.011
R14-627-100 n1_579050_417840 n1_579050_414496 0.011
R14-628-100 n1_579050_421184 n1_579050_417840 0.011
R14-629-100 n1_579050_421742 n1_579050_421184 0.0018355300000000001
R14-630-100 n1_579050_424528 n1_579050_421742 0.00916447
R14-631-100 n1_579050_427872 n1_579050_424528 0.011
R14-632-100 n1_579050_431216 n1_579050_427872 0.011
R14-633-100 n1_579050_434560 n1_579050_431216 0.011
R14-634-100 n1_579050_437904 n1_579050_434560 0.011
R14-635-100 n1_579050_441248 n1_579050_437904 0.011
R14-636-100 n1_579050_444238 n1_579050_441248 0.00983553
R14-637-100 n1_579050_444592 n1_579050_444238 0.00116447
R14-638-100 n1_579050_447936 n1_579050_444592 0.011
R14-639-100 n1_579050_451280 n1_579050_447936 0.011
R14-640-100 n1_579050_454624 n1_579050_451280 0.011
R14-641-100 n1_579050_457968 n1_579050_454624 0.011
R14-642-100 n1_579050_461312 n1_579050_457968 0.011
R14-643-100 n1_579050_464656 n1_579050_461312 0.011
R14-644-100 n1_579050_466126 n1_579050_464656 0.004835529999999999
R14-645-100 n1_579050_468000 n1_579050_466126 0.00616447
R14-646-100 n1_579050_471344 n1_579050_468000 0.011
R14-647-100 n1_579050_474688 n1_579050_471344 0.011
R14-648-100 n1_579050_478032 n1_579050_474688 0.011
R14-649-100 n1_579050_481376 n1_579050_478032 0.011
R14-650-100 n1_579050_484720 n1_579050_481376 0.011
R14-651-100 n1_579050_488064 n1_579050_484720 0.011
R14-652-100 n1_579050_488622 n1_579050_488064 0.0018355300000000001
R14-653-100 n1_579050_491408 n1_579050_488622 0.00916447
R14-654-100 n1_579050_494752 n1_579050_491408 0.011
R14-655-100 n1_579050_498096 n1_579050_494752 0.011
R14-656-100 n1_579050_501440 n1_579050_498096 0.011
R14-657-100 n1_579050_504784 n1_579050_501440 0.011
R14-658-100 n1_579050_508128 n1_579050_504784 0.011
R14-659-100 n1_579050_510510 n1_579050_508128 0.00783553
R14-660-100 n1_579050_511472 n1_579050_510510 0.00316447
R14-661-100 n1_579050_514816 n1_579050_511472 0.011
R14-662-100 n1_579050_518160 n1_579050_514816 0.011
R14-663-100 n1_579050_521504 n1_579050_518160 0.011
R14-664-100 n1_579050_524848 n1_579050_521504 0.011
R14-665-100 n1_579050_528192 n1_579050_524848 0.011
R14-666-100 n1_579050_531536 n1_579050_528192 0.011
R14-667-100 n1_579050_532398 n1_579050_531536 0.00283553
R14-668-100 n1_579050_534880 n1_579050_532398 0.00816447
R14-669-100 n1_579050_538224 n1_579050_534880 0.011
R14-670-100 n1_579050_541568 n1_579050_538224 0.011
R14-671-100 n1_579050_544912 n1_579050_541568 0.011
R14-672-100 n1_579050_548256 n1_579050_544912 0.011
R14-673-100 n1_579050_551600 n1_579050_548256 0.011
R14-674-100 n1_579050_554894 n1_579050_551600 0.010835500000000001
R14-675-100 n1_579050_554944 n1_579050_554894 0.000164474
R14-676-100 n1_579050_558288 n1_579050_554944 0.011
R14-677-100 n1_579050_561632 n1_579050_558288 0.011
R14-678-100 n1_579050_564976 n1_579050_561632 0.011
R14-679-100 n1_579050_568320 n1_579050_564976 0.011
R14-680-100 n1_579050_571664 n1_579050_568320 0.011
R14-681-100 n1_579050_575008 n1_579050_571664 0.011
R14-682-100 n1_579050_576782 n1_579050_575008 0.00583553
R14-683-100 n1_579050_578352 n1_579050_576782 0.00516447
R14-684-100 n1_579050_581696 n1_579050_578352 0.011
R14-685-100 n1_579050_585040 n1_579050_581696 0.011
R14-686-100 n1_579050_588384 n1_579050_585040 0.011
R14-687-100 n1_579050_591728 n1_579050_588384 0.011
R14-688-100 n1_579050_595072 n1_579050_591728 0.011
R14-689-100 n1_579050_598416 n1_579050_595072 0.011
R14-690-100 n1_579050_599278 n1_579050_598416 0.00283553
R14-691-100 n1_579050_601760 n1_579050_599278 0.00816447
R14-692-100 n1_579050_605104 n1_579050_601760 0.011
R14-693-100 n1_579050_608448 n1_579050_605104 0.011
R14-694-100 n1_579050_611792 n1_579050_608448 0.011
R14-695-100 n1_579050_615136 n1_579050_611792 0.011
R14-696-100 n1_579050_618480 n1_579050_615136 0.011
R14-697-100 n1_579050_624152 n1_579050_618480 0.018657899999999998
R14-698-100 n1_579050_626152 n1_579050_624152 0.00657895
R14-699-100 n1_556858_46000 n1_556858_44000 0.00657895
R14-700-100 n1_556858_50000 n1_556858_46000 0.0131579
R14-701-100 n1_556858_53344 n1_556858_50000 0.011
R14-702-100 n1_556858_56688 n1_556858_53344 0.011
R14-703-100 n1_556858_60032 n1_556858_56688 0.011
R14-704-100 n1_556858_63376 n1_556858_60032 0.011
R14-705-100 n1_556858_66720 n1_556858_63376 0.011
R14-706-100 n1_556858_67278 n1_556858_66720 0.0018355300000000001
R14-707-100 n1_556858_70064 n1_556858_67278 0.00916447
R14-708-100 n1_556858_73408 n1_556858_70064 0.011
R14-709-100 n1_556858_76752 n1_556858_73408 0.011
R14-710-100 n1_556858_80096 n1_556858_76752 0.011
R14-711-100 n1_556858_83440 n1_556858_80096 0.011
R14-712-100 n1_556858_86784 n1_556858_83440 0.011
R14-713-100 n1_556858_89166 n1_556858_86784 0.00783553
R14-714-100 n1_556858_90128 n1_556858_89166 0.00316447
R14-715-100 n1_556858_93472 n1_556858_90128 0.011
R14-716-100 n1_556858_96816 n1_556858_93472 0.011
R14-717-100 n1_556858_100160 n1_556858_96816 0.011
R14-718-100 n1_556858_103504 n1_556858_100160 0.011
R14-719-100 n1_556858_106848 n1_556858_103504 0.011
R14-720-100 n1_556858_110192 n1_556858_106848 0.011
R14-721-100 n1_556858_111662 n1_556858_110192 0.004835529999999999
R14-722-100 n1_556858_113536 n1_556858_111662 0.00616447
R14-723-100 n1_556858_116880 n1_556858_113536 0.011
R14-724-100 n1_556858_120224 n1_556858_116880 0.011
R14-725-100 n1_556858_123568 n1_556858_120224 0.011
R14-726-100 n1_556858_126912 n1_556858_123568 0.011
R14-727-100 n1_556858_130256 n1_556858_126912 0.011
R14-728-100 n1_556858_133550 n1_556858_130256 0.010835500000000001
R14-729-100 n1_556858_133600 n1_556858_133550 0.000164474
R14-730-100 n1_556858_136944 n1_556858_133600 0.011
R14-731-100 n1_556858_140288 n1_556858_136944 0.011
R14-732-100 n1_556858_143632 n1_556858_140288 0.011
R14-733-100 n1_556858_146976 n1_556858_143632 0.011
R14-734-100 n1_556858_150320 n1_556858_146976 0.011
R14-735-100 n1_556858_153664 n1_556858_150320 0.011
R14-736-100 n1_556858_156046 n1_556858_153664 0.00783553
R14-737-100 n1_556858_157008 n1_556858_156046 0.00316447
R14-738-100 n1_556858_160352 n1_556858_157008 0.011
R14-739-100 n1_556858_163696 n1_556858_160352 0.011
R14-740-100 n1_556858_167040 n1_556858_163696 0.011
R14-741-100 n1_556858_170384 n1_556858_167040 0.011
R14-742-100 n1_556858_173728 n1_556858_170384 0.011
R14-743-100 n1_556858_177072 n1_556858_173728 0.011
R14-744-100 n1_556858_177934 n1_556858_177072 0.00283553
R14-745-100 n1_556858_180416 n1_556858_177934 0.00816447
R14-746-100 n1_556858_183760 n1_556858_180416 0.011
R14-747-100 n1_556858_187104 n1_556858_183760 0.011
R14-748-100 n1_556858_190448 n1_556858_187104 0.011
R14-749-100 n1_556858_193792 n1_556858_190448 0.011
R14-750-100 n1_556858_197136 n1_556858_193792 0.011
R14-751-100 n1_556858_200430 n1_556858_197136 0.010835500000000001
R14-752-100 n1_556858_200480 n1_556858_200430 0.000164474
R14-753-100 n1_556858_203824 n1_556858_200480 0.011
R14-754-100 n1_556858_207168 n1_556858_203824 0.011
R14-755-100 n1_556858_210512 n1_556858_207168 0.011
R14-756-100 n1_556858_213856 n1_556858_210512 0.011
R14-757-100 n1_556858_217200 n1_556858_213856 0.011
R14-758-100 n1_556858_220544 n1_556858_217200 0.011
R14-759-100 n1_556858_222318 n1_556858_220544 0.00583553
R14-760-100 n1_556858_223888 n1_556858_222318 0.00516447
R14-761-100 n1_556858_227232 n1_556858_223888 0.011
R14-762-100 n1_556858_230576 n1_556858_227232 0.011
R14-763-100 n1_556858_233920 n1_556858_230576 0.011
R14-764-100 n1_556858_237264 n1_556858_233920 0.011
R14-765-100 n1_556858_240608 n1_556858_237264 0.011
R14-766-100 n1_556858_243952 n1_556858_240608 0.011
R14-767-100 n1_556858_244814 n1_556858_243952 0.00283553
R14-768-100 n1_556858_247296 n1_556858_244814 0.00816447
R14-769-100 n1_556858_250640 n1_556858_247296 0.011
R14-770-100 n1_556858_253984 n1_556858_250640 0.011
R14-771-100 n1_556858_257328 n1_556858_253984 0.011
R14-772-100 n1_556858_260672 n1_556858_257328 0.011
R14-773-100 n1_556858_264016 n1_556858_260672 0.011
R14-774-100 n1_556858_266702 n1_556858_264016 0.00883553
R14-775-100 n1_556858_267360 n1_556858_266702 0.00216447
R14-776-100 n1_556858_270704 n1_556858_267360 0.011
R14-777-100 n1_556858_274048 n1_556858_270704 0.011
R14-778-100 n1_556858_277392 n1_556858_274048 0.011
R14-779-100 n1_556858_280736 n1_556858_277392 0.011
R14-780-100 n1_556858_284080 n1_556858_280736 0.011
R14-781-100 n1_556858_287424 n1_556858_284080 0.011
R14-782-100 n1_556858_288590 n1_556858_287424 0.00383553
R14-783-100 n1_556858_290768 n1_556858_288590 0.007164470000000001
R14-784-100 n1_556858_294112 n1_556858_290768 0.011
R14-785-100 n1_556858_297456 n1_556858_294112 0.011
R14-786-100 n1_556858_300800 n1_556858_297456 0.011
R14-787-100 n1_556858_304144 n1_556858_300800 0.011
R14-788-100 n1_556858_307488 n1_556858_304144 0.011
R14-789-100 n1_556858_310832 n1_556858_307488 0.011
R14-790-100 n1_556858_311086 n1_556858_310832 0.000835526
R14-791-100 n1_556858_314176 n1_556858_311086 0.0101645
R14-792-100 n1_556858_317520 n1_556858_314176 0.011
R14-793-100 n1_556858_320864 n1_556858_317520 0.011
R14-794-100 n1_556858_324208 n1_556858_320864 0.011
R14-795-100 n1_556858_327552 n1_556858_324208 0.011
R14-796-100 n1_556858_330896 n1_556858_327552 0.011
R14-797-100 n1_556858_332974 n1_556858_330896 0.006835529999999999
R14-798-100 n1_556858_334240 n1_556858_332974 0.00416447
R14-799-100 n1_556858_337584 n1_556858_334240 0.011
R14-800-100 n1_556858_340928 n1_556858_337584 0.011
R14-801-100 n1_556858_344272 n1_556858_340928 0.011
R14-802-100 n1_556858_347616 n1_556858_344272 0.011
R14-803-100 n1_556858_350960 n1_556858_347616 0.011
R14-804-100 n1_556858_354304 n1_556858_350960 0.011
R14-805-100 n1_556858_355470 n1_556858_354304 0.00383553
R14-806-100 n1_556858_357648 n1_556858_355470 0.007164470000000001
R14-807-100 n1_556858_360992 n1_556858_357648 0.011
R14-808-100 n1_556858_364336 n1_556858_360992 0.011
R14-809-100 n1_556858_367680 n1_556858_364336 0.011
R14-810-100 n1_556858_371024 n1_556858_367680 0.011
R14-811-100 n1_556858_374368 n1_556858_371024 0.011
R14-812-100 n1_556858_377358 n1_556858_374368 0.00983553
R14-813-100 n1_556858_377712 n1_556858_377358 0.00116447
R14-814-100 n1_556858_381056 n1_556858_377712 0.011
R14-815-100 n1_556858_384400 n1_556858_381056 0.011
R14-816-100 n1_556858_387744 n1_556858_384400 0.011
R14-817-100 n1_556858_391088 n1_556858_387744 0.011
R14-818-100 n1_556858_394432 n1_556858_391088 0.011
R14-819-100 n1_556858_397776 n1_556858_394432 0.011
R14-820-100 n1_556858_399854 n1_556858_397776 0.006835529999999999
R14-821-100 n1_556858_401120 n1_556858_399854 0.00416447
R14-822-100 n1_556858_404464 n1_556858_401120 0.011
R14-823-100 n1_556858_407808 n1_556858_404464 0.011
R14-824-100 n1_556858_411152 n1_556858_407808 0.011
R14-825-100 n1_556858_414496 n1_556858_411152 0.011
R14-826-100 n1_556858_417840 n1_556858_414496 0.011
R14-827-100 n1_556858_421184 n1_556858_417840 0.011
R14-828-100 n1_556858_421742 n1_556858_421184 0.0018355300000000001
R14-829-100 n1_556858_424528 n1_556858_421742 0.00916447
R14-830-100 n1_556858_427872 n1_556858_424528 0.011
R14-831-100 n1_556858_431216 n1_556858_427872 0.011
R14-832-100 n1_556858_434560 n1_556858_431216 0.011
R14-833-100 n1_556858_437904 n1_556858_434560 0.011
R14-834-100 n1_556858_441248 n1_556858_437904 0.011
R14-835-100 n1_556858_444238 n1_556858_441248 0.00983553
R14-836-100 n1_556858_444592 n1_556858_444238 0.00116447
R14-837-100 n1_556858_447936 n1_556858_444592 0.011
R14-838-100 n1_556858_451280 n1_556858_447936 0.011
R14-839-100 n1_556858_454624 n1_556858_451280 0.011
R14-840-100 n1_556858_457968 n1_556858_454624 0.011
R14-841-100 n1_556858_461312 n1_556858_457968 0.011
R14-842-100 n1_556858_464656 n1_556858_461312 0.011
R14-843-100 n1_556858_466126 n1_556858_464656 0.004835529999999999
R14-844-100 n1_556858_468000 n1_556858_466126 0.00616447
R14-845-100 n1_556858_471344 n1_556858_468000 0.011
R14-846-100 n1_556858_474688 n1_556858_471344 0.011
R14-847-100 n1_556858_478032 n1_556858_474688 0.011
R14-848-100 n1_556858_481376 n1_556858_478032 0.011
R14-849-100 n1_556858_484720 n1_556858_481376 0.011
R14-850-100 n1_556858_488064 n1_556858_484720 0.011
R14-851-100 n1_556858_488622 n1_556858_488064 0.0018355300000000001
R14-852-100 n1_556858_491408 n1_556858_488622 0.00916447
R14-853-100 n1_556858_494752 n1_556858_491408 0.011
R14-854-100 n1_556858_498096 n1_556858_494752 0.011
R14-855-100 n1_556858_501440 n1_556858_498096 0.011
R14-856-100 n1_556858_504784 n1_556858_501440 0.011
R14-857-100 n1_556858_508128 n1_556858_504784 0.011
R14-858-100 n1_556858_510510 n1_556858_508128 0.00783553
R14-859-100 n1_556858_511472 n1_556858_510510 0.00316447
R14-860-100 n1_556858_514816 n1_556858_511472 0.011
R14-861-100 n1_556858_518160 n1_556858_514816 0.011
R14-862-100 n1_556858_521504 n1_556858_518160 0.011
R14-863-100 n1_556858_524848 n1_556858_521504 0.011
R14-864-100 n1_556858_528192 n1_556858_524848 0.011
R14-865-100 n1_556858_531536 n1_556858_528192 0.011
R14-866-100 n1_556858_532398 n1_556858_531536 0.00283553
R14-867-100 n1_556858_534880 n1_556858_532398 0.00816447
R14-868-100 n1_556858_538224 n1_556858_534880 0.011
R14-869-100 n1_556858_541568 n1_556858_538224 0.011
R14-870-100 n1_556858_544912 n1_556858_541568 0.011
R14-871-100 n1_556858_548256 n1_556858_544912 0.011
R14-872-100 n1_556858_551600 n1_556858_548256 0.011
R14-873-100 n1_556858_554894 n1_556858_551600 0.010835500000000001
R14-874-100 n1_556858_554944 n1_556858_554894 0.000164474
R14-875-100 n1_556858_558288 n1_556858_554944 0.011
R14-876-100 n1_556858_561632 n1_556858_558288 0.011
R14-877-100 n1_556858_564976 n1_556858_561632 0.011
R14-878-100 n1_556858_568320 n1_556858_564976 0.011
R14-879-100 n1_556858_571664 n1_556858_568320 0.011
R14-880-100 n1_556858_575008 n1_556858_571664 0.011
R14-881-100 n1_556858_576782 n1_556858_575008 0.00583553
R14-882-100 n1_556858_578352 n1_556858_576782 0.00516447
R14-883-100 n1_556858_581696 n1_556858_578352 0.011
R14-884-100 n1_556858_585040 n1_556858_581696 0.011
R14-885-100 n1_556858_588384 n1_556858_585040 0.011
R14-886-100 n1_556858_591728 n1_556858_588384 0.011
R14-887-100 n1_556858_595072 n1_556858_591728 0.011
R14-888-100 n1_556858_598416 n1_556858_595072 0.011
R14-889-100 n1_556858_599278 n1_556858_598416 0.00283553
R14-890-100 n1_556858_601760 n1_556858_599278 0.00816447
R14-891-100 n1_556858_605104 n1_556858_601760 0.011
R14-892-100 n1_556858_608448 n1_556858_605104 0.011
R14-893-100 n1_556858_611792 n1_556858_608448 0.011
R14-894-100 n1_556858_615136 n1_556858_611792 0.011
R14-895-100 n1_556858_618480 n1_556858_615136 0.011
R14-896-100 n1_556858_624152 n1_556858_618480 0.018657899999999998
R14-897-100 n1_556858_626152 n1_556858_624152 0.00657895
R14-898-100 n1_534666_46000 n1_534666_44000 0.00657895
R14-899-100 n1_534666_50000 n1_534666_46000 0.0131579
R14-900-100 n1_534666_53344 n1_534666_50000 0.011
R14-901-100 n1_534666_56688 n1_534666_53344 0.011
R14-902-100 n1_534666_60032 n1_534666_56688 0.011
R14-903-100 n1_534666_63376 n1_534666_60032 0.011
R14-904-100 n1_534666_66720 n1_534666_63376 0.011
R14-905-100 n1_534666_67278 n1_534666_66720 0.0018355300000000001
R14-906-100 n1_534666_70064 n1_534666_67278 0.00916447
R14-907-100 n1_534666_73408 n1_534666_70064 0.011
R14-908-100 n1_534666_76752 n1_534666_73408 0.011
R14-909-100 n1_534666_80096 n1_534666_76752 0.011
R14-910-100 n1_534666_83440 n1_534666_80096 0.011
R14-911-100 n1_534666_86784 n1_534666_83440 0.011
R14-912-100 n1_534666_89166 n1_534666_86784 0.00783553
R14-913-100 n1_534666_90128 n1_534666_89166 0.00316447
R14-914-100 n1_534666_93472 n1_534666_90128 0.011
R14-915-100 n1_534666_96816 n1_534666_93472 0.011
R14-916-100 n1_534666_100160 n1_534666_96816 0.011
R14-917-100 n1_534666_103504 n1_534666_100160 0.011
R14-918-100 n1_534666_106848 n1_534666_103504 0.011
R14-919-100 n1_534666_110192 n1_534666_106848 0.011
R14-920-100 n1_534666_111662 n1_534666_110192 0.004835529999999999
R14-921-100 n1_534666_113536 n1_534666_111662 0.00616447
R14-922-100 n1_534666_116880 n1_534666_113536 0.011
R14-923-100 n1_534666_120224 n1_534666_116880 0.011
R14-924-100 n1_534666_123568 n1_534666_120224 0.011
R14-925-100 n1_534666_126912 n1_534666_123568 0.011
R14-926-100 n1_534666_130256 n1_534666_126912 0.011
R14-927-100 n1_534666_133550 n1_534666_130256 0.010835500000000001
R14-928-100 n1_534666_133600 n1_534666_133550 0.000164474
R14-929-100 n1_534666_136944 n1_534666_133600 0.011
R14-930-100 n1_534666_140288 n1_534666_136944 0.011
R14-931-100 n1_534666_143632 n1_534666_140288 0.011
R14-932-100 n1_534666_146976 n1_534666_143632 0.011
R14-933-100 n1_534666_150320 n1_534666_146976 0.011
R14-934-100 n1_534666_153664 n1_534666_150320 0.011
R14-935-100 n1_534666_156046 n1_534666_153664 0.00783553
R14-936-100 n1_534666_157008 n1_534666_156046 0.00316447
R14-937-100 n1_534666_160352 n1_534666_157008 0.011
R14-938-100 n1_534666_163696 n1_534666_160352 0.011
R14-939-100 n1_534666_167040 n1_534666_163696 0.011
R14-940-100 n1_534666_170384 n1_534666_167040 0.011
R14-941-100 n1_534666_173728 n1_534666_170384 0.011
R14-942-100 n1_534666_177072 n1_534666_173728 0.011
R14-943-100 n1_534666_177934 n1_534666_177072 0.00283553
R14-944-100 n1_534666_180416 n1_534666_177934 0.00816447
R14-945-100 n1_534666_183760 n1_534666_180416 0.011
R14-946-100 n1_534666_187104 n1_534666_183760 0.011
R14-947-100 n1_534666_190448 n1_534666_187104 0.011
R14-948-100 n1_534666_193792 n1_534666_190448 0.011
R14-949-100 n1_534666_197136 n1_534666_193792 0.011
R14-950-100 n1_534666_200430 n1_534666_197136 0.010835500000000001
R14-951-100 n1_534666_200480 n1_534666_200430 0.000164474
R14-952-100 n1_534666_203824 n1_534666_200480 0.011
R14-953-100 n1_534666_207168 n1_534666_203824 0.011
R14-954-100 n1_534666_210512 n1_534666_207168 0.011
R14-955-100 n1_534666_213856 n1_534666_210512 0.011
R14-956-100 n1_534666_217200 n1_534666_213856 0.011
R14-957-100 n1_534666_220544 n1_534666_217200 0.011
R14-958-100 n1_534666_222318 n1_534666_220544 0.00583553
R14-959-100 n1_534666_223888 n1_534666_222318 0.00516447
R14-960-100 n1_534666_227232 n1_534666_223888 0.011
R14-961-100 n1_534666_230576 n1_534666_227232 0.011
R14-962-100 n1_534666_233920 n1_534666_230576 0.011
R14-963-100 n1_534666_237264 n1_534666_233920 0.011
R14-964-100 n1_534666_240608 n1_534666_237264 0.011
R14-965-100 n1_534666_243952 n1_534666_240608 0.011
R14-966-100 n1_534666_244814 n1_534666_243952 0.00283553
R14-967-100 n1_534666_247296 n1_534666_244814 0.00816447
R14-968-100 n1_534666_250640 n1_534666_247296 0.011
R14-969-100 n1_534666_253984 n1_534666_250640 0.011
R14-970-100 n1_534666_257328 n1_534666_253984 0.011
R14-971-100 n1_534666_260672 n1_534666_257328 0.011
R14-972-100 n1_534666_264016 n1_534666_260672 0.011
R14-973-100 n1_534666_266702 n1_534666_264016 0.00883553
R14-974-100 n1_534666_267360 n1_534666_266702 0.00216447
R14-975-100 n1_534666_270704 n1_534666_267360 0.011
R14-976-100 n1_534666_274048 n1_534666_270704 0.011
R14-977-100 n1_534666_277392 n1_534666_274048 0.011
R14-978-100 n1_534666_280736 n1_534666_277392 0.011
R14-979-100 n1_534666_284080 n1_534666_280736 0.011
R14-980-100 n1_534666_287424 n1_534666_284080 0.011
R14-981-100 n1_534666_288590 n1_534666_287424 0.00383553
R14-982-100 n1_534666_290768 n1_534666_288590 0.007164470000000001
R14-983-100 n1_534666_294112 n1_534666_290768 0.011
R14-984-100 n1_534666_297456 n1_534666_294112 0.011
R14-985-100 n1_534666_300800 n1_534666_297456 0.011
R14-986-100 n1_534666_304144 n1_534666_300800 0.011
R14-987-100 n1_534666_307488 n1_534666_304144 0.011
R14-988-100 n1_534666_310832 n1_534666_307488 0.011
R14-989-100 n1_534666_311086 n1_534666_310832 0.000835526
R14-990-100 n1_534666_314176 n1_534666_311086 0.0101645
R14-991-100 n1_534666_317520 n1_534666_314176 0.011
R14-992-100 n1_534666_320864 n1_534666_317520 0.011
R14-993-100 n1_534666_324208 n1_534666_320864 0.011
R14-994-100 n1_534666_327552 n1_534666_324208 0.011
R14-995-100 n1_534666_330896 n1_534666_327552 0.011
R14-996-100 n1_534666_332974 n1_534666_330896 0.006835529999999999
R14-997-100 n1_534666_334240 n1_534666_332974 0.00416447
R14-998-100 n1_534666_337584 n1_534666_334240 0.011
R14-999-100 n1_534666_340928 n1_534666_337584 0.011
R14-1000-100 n1_534666_344272 n1_534666_340928 0.011
R14-1001-100 n1_534666_347616 n1_534666_344272 0.011
R14-1002-100 n1_534666_350960 n1_534666_347616 0.011
R14-1003-100 n1_534666_354304 n1_534666_350960 0.011
R14-1004-100 n1_534666_355470 n1_534666_354304 0.00383553
R14-1005-100 n1_534666_357648 n1_534666_355470 0.007164470000000001
R14-1006-100 n1_534666_360992 n1_534666_357648 0.011
R14-1007-100 n1_534666_364336 n1_534666_360992 0.011
R14-1008-100 n1_534666_367680 n1_534666_364336 0.011
R14-1009-100 n1_534666_371024 n1_534666_367680 0.011
R14-1010-100 n1_534666_374368 n1_534666_371024 0.011
R14-1011-100 n1_534666_377358 n1_534666_374368 0.00983553
R14-1012-100 n1_534666_377712 n1_534666_377358 0.00116447
R14-1013-100 n1_534666_381056 n1_534666_377712 0.011
R14-1014-100 n1_534666_384400 n1_534666_381056 0.011
R14-1015-100 n1_534666_387744 n1_534666_384400 0.011
R14-1016-100 n1_534666_391088 n1_534666_387744 0.011
R14-1017-100 n1_534666_394432 n1_534666_391088 0.011
R14-1018-100 n1_534666_397776 n1_534666_394432 0.011
R14-1019-100 n1_534666_399854 n1_534666_397776 0.006835529999999999
R14-1020-100 n1_534666_401120 n1_534666_399854 0.00416447
R14-1021-100 n1_534666_404464 n1_534666_401120 0.011
R14-1022-100 n1_534666_407808 n1_534666_404464 0.011
R14-1023-100 n1_534666_411152 n1_534666_407808 0.011
R14-1024-100 n1_534666_414496 n1_534666_411152 0.011
R14-1025-100 n1_534666_417840 n1_534666_414496 0.011
R14-1026-100 n1_534666_421184 n1_534666_417840 0.011
R14-1027-100 n1_534666_421742 n1_534666_421184 0.0018355300000000001
R14-1028-100 n1_534666_424528 n1_534666_421742 0.00916447
R14-1029-100 n1_534666_427872 n1_534666_424528 0.011
R14-1030-100 n1_534666_431216 n1_534666_427872 0.011
R14-1031-100 n1_534666_434560 n1_534666_431216 0.011
R14-1032-100 n1_534666_437904 n1_534666_434560 0.011
R14-1033-100 n1_534666_441248 n1_534666_437904 0.011
R14-1034-100 n1_534666_444238 n1_534666_441248 0.00983553
R14-1035-100 n1_534666_444592 n1_534666_444238 0.00116447
R14-1036-100 n1_534666_447936 n1_534666_444592 0.011
R14-1037-100 n1_534666_451280 n1_534666_447936 0.011
R14-1038-100 n1_534666_454624 n1_534666_451280 0.011
R14-1039-100 n1_534666_457968 n1_534666_454624 0.011
R14-1040-100 n1_534666_461312 n1_534666_457968 0.011
R14-1041-100 n1_534666_464656 n1_534666_461312 0.011
R14-1042-100 n1_534666_466126 n1_534666_464656 0.004835529999999999
R14-1043-100 n1_534666_468000 n1_534666_466126 0.00616447
R14-1044-100 n1_534666_471344 n1_534666_468000 0.011
R14-1045-100 n1_534666_474688 n1_534666_471344 0.011
R14-1046-100 n1_534666_478032 n1_534666_474688 0.011
R14-1047-100 n1_534666_481376 n1_534666_478032 0.011
R14-1048-100 n1_534666_484720 n1_534666_481376 0.011
R14-1049-100 n1_534666_488064 n1_534666_484720 0.011
R14-1050-100 n1_534666_488622 n1_534666_488064 0.0018355300000000001
R14-1051-100 n1_534666_491408 n1_534666_488622 0.00916447
R14-1052-100 n1_534666_494752 n1_534666_491408 0.011
R14-1053-100 n1_534666_498096 n1_534666_494752 0.011
R14-1054-100 n1_534666_501440 n1_534666_498096 0.011
R14-1055-100 n1_534666_504784 n1_534666_501440 0.011
R14-1056-100 n1_534666_508128 n1_534666_504784 0.011
R14-1057-100 n1_534666_510510 n1_534666_508128 0.00783553
R14-1058-100 n1_534666_511472 n1_534666_510510 0.00316447
R14-1059-100 n1_534666_514816 n1_534666_511472 0.011
R14-1060-100 n1_534666_518160 n1_534666_514816 0.011
R14-1061-100 n1_534666_521504 n1_534666_518160 0.011
R14-1062-100 n1_534666_524848 n1_534666_521504 0.011
R14-1063-100 n1_534666_528192 n1_534666_524848 0.011
R14-1064-100 n1_534666_531536 n1_534666_528192 0.011
R14-1065-100 n1_534666_532398 n1_534666_531536 0.00283553
R14-1066-100 n1_534666_534880 n1_534666_532398 0.00816447
R14-1067-100 n1_534666_538224 n1_534666_534880 0.011
R14-1068-100 n1_534666_541568 n1_534666_538224 0.011
R14-1069-100 n1_534666_544912 n1_534666_541568 0.011
R14-1070-100 n1_534666_548256 n1_534666_544912 0.011
R14-1071-100 n1_534666_551600 n1_534666_548256 0.011
R14-1072-100 n1_534666_554894 n1_534666_551600 0.010835500000000001
R14-1073-100 n1_534666_554944 n1_534666_554894 0.000164474
R14-1074-100 n1_534666_558288 n1_534666_554944 0.011
R14-1075-100 n1_534666_561632 n1_534666_558288 0.011
R14-1076-100 n1_534666_564976 n1_534666_561632 0.011
R14-1077-100 n1_534666_568320 n1_534666_564976 0.011
R14-1078-100 n1_534666_571664 n1_534666_568320 0.011
R14-1079-100 n1_534666_575008 n1_534666_571664 0.011
R14-1080-100 n1_534666_576782 n1_534666_575008 0.00583553
R14-1081-100 n1_534666_578352 n1_534666_576782 0.00516447
R14-1082-100 n1_534666_581696 n1_534666_578352 0.011
R14-1083-100 n1_534666_585040 n1_534666_581696 0.011
R14-1084-100 n1_534666_588384 n1_534666_585040 0.011
R14-1085-100 n1_534666_591728 n1_534666_588384 0.011
R14-1086-100 n1_534666_595072 n1_534666_591728 0.011
R14-1087-100 n1_534666_598416 n1_534666_595072 0.011
R14-1088-100 n1_534666_599278 n1_534666_598416 0.00283553
R14-1089-100 n1_534666_601760 n1_534666_599278 0.00816447
R14-1090-100 n1_534666_605104 n1_534666_601760 0.011
R14-1091-100 n1_534666_608448 n1_534666_605104 0.011
R14-1092-100 n1_534666_611792 n1_534666_608448 0.011
R14-1093-100 n1_534666_615136 n1_534666_611792 0.011
R14-1094-100 n1_534666_618480 n1_534666_615136 0.011
R14-1095-100 n1_534666_624152 n1_534666_618480 0.018657899999999998
R14-1096-100 n1_534666_626152 n1_534666_624152 0.00657895
R14-1097-100 n1_512170_46000 n1_512170_44000 0.00657895
R14-1098-100 n1_512170_50000 n1_512170_46000 0.0131579
R14-1099-100 n1_512170_53344 n1_512170_50000 0.011
R14-1100-100 n1_512170_56688 n1_512170_53344 0.011
R14-1101-100 n1_512170_60032 n1_512170_56688 0.011
R14-1102-100 n1_512170_63376 n1_512170_60032 0.011
R14-1103-100 n1_512170_66720 n1_512170_63376 0.011
R14-1104-100 n1_512170_67278 n1_512170_66720 0.0018355300000000001
R14-1105-100 n1_512170_70064 n1_512170_67278 0.00916447
R14-1106-100 n1_512170_73408 n1_512170_70064 0.011
R14-1107-100 n1_512170_76752 n1_512170_73408 0.011
R14-1108-100 n1_512170_80096 n1_512170_76752 0.011
R14-1109-100 n1_512170_83440 n1_512170_80096 0.011
R14-1110-100 n1_512170_86784 n1_512170_83440 0.011
R14-1111-100 n1_512170_89166 n1_512170_86784 0.00783553
R14-1112-100 n1_512170_90128 n1_512170_89166 0.00316447
R14-1113-100 n1_512170_93472 n1_512170_90128 0.011
R14-1114-100 n1_512170_96816 n1_512170_93472 0.011
R14-1115-100 n1_512170_100160 n1_512170_96816 0.011
R14-1116-100 n1_512170_103504 n1_512170_100160 0.011
R14-1117-100 n1_512170_106848 n1_512170_103504 0.011
R14-1118-100 n1_512170_110192 n1_512170_106848 0.011
R14-1119-100 n1_512170_111662 n1_512170_110192 0.004835529999999999
R14-1120-100 n1_512170_113536 n1_512170_111662 0.00616447
R14-1121-100 n1_512170_116880 n1_512170_113536 0.011
R14-1122-100 n1_512170_120224 n1_512170_116880 0.011
R14-1123-100 n1_512170_123568 n1_512170_120224 0.011
R14-1124-100 n1_512170_126912 n1_512170_123568 0.011
R14-1125-100 n1_512170_130256 n1_512170_126912 0.011
R14-1126-100 n1_512170_133550 n1_512170_130256 0.010835500000000001
R14-1127-100 n1_512170_133600 n1_512170_133550 0.000164474
R14-1128-100 n1_512170_136944 n1_512170_133600 0.011
R14-1129-100 n1_512170_140288 n1_512170_136944 0.011
R14-1130-100 n1_512170_143632 n1_512170_140288 0.011
R14-1131-100 n1_512170_146976 n1_512170_143632 0.011
R14-1132-100 n1_512170_150320 n1_512170_146976 0.011
R14-1133-100 n1_512170_153664 n1_512170_150320 0.011
R14-1134-100 n1_512170_156046 n1_512170_153664 0.00783553
R14-1135-100 n1_512170_157008 n1_512170_156046 0.00316447
R14-1136-100 n1_512170_160352 n1_512170_157008 0.011
R14-1137-100 n1_512170_163696 n1_512170_160352 0.011
R14-1138-100 n1_512170_167040 n1_512170_163696 0.011
R14-1139-100 n1_512170_170384 n1_512170_167040 0.011
R14-1140-100 n1_512170_173728 n1_512170_170384 0.011
R14-1141-100 n1_512170_177072 n1_512170_173728 0.011
R14-1142-100 n1_512170_177934 n1_512170_177072 0.00283553
R14-1143-100 n1_512170_180416 n1_512170_177934 0.00816447
R14-1144-100 n1_512170_183760 n1_512170_180416 0.011
R14-1145-100 n1_512170_187104 n1_512170_183760 0.011
R14-1146-100 n1_512170_190448 n1_512170_187104 0.011
R14-1147-100 n1_512170_193792 n1_512170_190448 0.011
R14-1148-100 n1_512170_197136 n1_512170_193792 0.011
R14-1149-100 n1_512170_200430 n1_512170_197136 0.010835500000000001
R14-1150-100 n1_512170_200480 n1_512170_200430 0.000164474
R14-1151-100 n1_512170_203824 n1_512170_200480 0.011
R14-1152-100 n1_512170_207168 n1_512170_203824 0.011
R14-1153-100 n1_512170_210512 n1_512170_207168 0.011
R14-1154-100 n1_512170_213856 n1_512170_210512 0.011
R14-1155-100 n1_512170_217200 n1_512170_213856 0.011
R14-1156-100 n1_512170_220544 n1_512170_217200 0.011
R14-1157-100 n1_512170_222318 n1_512170_220544 0.00583553
R14-1158-100 n1_512170_223888 n1_512170_222318 0.00516447
R14-1159-100 n1_512170_227232 n1_512170_223888 0.011
R14-1160-100 n1_512170_230576 n1_512170_227232 0.011
R14-1161-100 n1_512170_233920 n1_512170_230576 0.011
R14-1162-100 n1_512170_237264 n1_512170_233920 0.011
R14-1163-100 n1_512170_240608 n1_512170_237264 0.011
R14-1164-100 n1_512170_243952 n1_512170_240608 0.011
R14-1165-100 n1_512170_244814 n1_512170_243952 0.00283553
R14-1166-100 n1_512170_247296 n1_512170_244814 0.00816447
R14-1167-100 n1_512170_250640 n1_512170_247296 0.011
R14-1168-100 n1_512170_253984 n1_512170_250640 0.011
R14-1169-100 n1_512170_257328 n1_512170_253984 0.011
R14-1170-100 n1_512170_260672 n1_512170_257328 0.011
R14-1171-100 n1_512170_264016 n1_512170_260672 0.011
R14-1172-100 n1_512170_266702 n1_512170_264016 0.00883553
R14-1173-100 n1_512170_267360 n1_512170_266702 0.00216447
R14-1174-100 n1_512170_270704 n1_512170_267360 0.011
R14-1175-100 n1_512170_274048 n1_512170_270704 0.011
R14-1176-100 n1_512170_277392 n1_512170_274048 0.011
R14-1177-100 n1_512170_280736 n1_512170_277392 0.011
R14-1178-100 n1_512170_284080 n1_512170_280736 0.011
R14-1179-100 n1_512170_287424 n1_512170_284080 0.011
R14-1180-100 n1_512170_288590 n1_512170_287424 0.00383553
R14-1181-100 n1_512170_290768 n1_512170_288590 0.007164470000000001
R14-1182-100 n1_512170_294112 n1_512170_290768 0.011
R14-1183-100 n1_512170_297456 n1_512170_294112 0.011
R14-1184-100 n1_512170_300800 n1_512170_297456 0.011
R14-1185-100 n1_512170_304144 n1_512170_300800 0.011
R14-1186-100 n1_512170_307488 n1_512170_304144 0.011
R14-1187-100 n1_512170_310832 n1_512170_307488 0.011
R14-1188-100 n1_512170_311086 n1_512170_310832 0.000835526
R14-1189-100 n1_512170_314176 n1_512170_311086 0.0101645
R14-1190-100 n1_512170_317520 n1_512170_314176 0.011
R14-1191-100 n1_512170_320864 n1_512170_317520 0.011
R14-1192-100 n1_512170_324208 n1_512170_320864 0.011
R14-1193-100 n1_512170_327552 n1_512170_324208 0.011
R14-1194-100 n1_512170_330896 n1_512170_327552 0.011
R14-1195-100 n1_512170_332974 n1_512170_330896 0.006835529999999999
R14-1196-100 n1_512170_334240 n1_512170_332974 0.00416447
R14-1197-100 n1_512170_337584 n1_512170_334240 0.011
R14-1198-100 n1_512170_340928 n1_512170_337584 0.011
R14-1199-100 n1_512170_344272 n1_512170_340928 0.011
R14-1200-100 n1_512170_347616 n1_512170_344272 0.011
R14-1201-100 n1_512170_350960 n1_512170_347616 0.011
R14-1202-100 n1_512170_354304 n1_512170_350960 0.011
R14-1203-100 n1_512170_355470 n1_512170_354304 0.00383553
R14-1204-100 n1_512170_357648 n1_512170_355470 0.007164470000000001
R14-1205-100 n1_512170_360992 n1_512170_357648 0.011
R14-1206-100 n1_512170_364336 n1_512170_360992 0.011
R14-1207-100 n1_512170_367680 n1_512170_364336 0.011
R14-1208-100 n1_512170_371024 n1_512170_367680 0.011
R14-1209-100 n1_512170_374368 n1_512170_371024 0.011
R14-1210-100 n1_512170_377358 n1_512170_374368 0.00983553
R14-1211-100 n1_512170_377712 n1_512170_377358 0.00116447
R14-1212-100 n1_512170_381056 n1_512170_377712 0.011
R14-1213-100 n1_512170_384400 n1_512170_381056 0.011
R14-1214-100 n1_512170_387744 n1_512170_384400 0.011
R14-1215-100 n1_512170_391088 n1_512170_387744 0.011
R14-1216-100 n1_512170_394432 n1_512170_391088 0.011
R14-1217-100 n1_512170_397776 n1_512170_394432 0.011
R14-1218-100 n1_512170_399854 n1_512170_397776 0.006835529999999999
R14-1219-100 n1_512170_401120 n1_512170_399854 0.00416447
R14-1220-100 n1_512170_404464 n1_512170_401120 0.011
R14-1221-100 n1_512170_407808 n1_512170_404464 0.011
R14-1222-100 n1_512170_411152 n1_512170_407808 0.011
R14-1223-100 n1_512170_414496 n1_512170_411152 0.011
R14-1224-100 n1_512170_417840 n1_512170_414496 0.011
R14-1225-100 n1_512170_421184 n1_512170_417840 0.011
R14-1226-100 n1_512170_421742 n1_512170_421184 0.0018355300000000001
R14-1227-100 n1_512170_424528 n1_512170_421742 0.00916447
R14-1228-100 n1_512170_427872 n1_512170_424528 0.011
R14-1229-100 n1_512170_431216 n1_512170_427872 0.011
R14-1230-100 n1_512170_434560 n1_512170_431216 0.011
R14-1231-100 n1_512170_437904 n1_512170_434560 0.011
R14-1232-100 n1_512170_441248 n1_512170_437904 0.011
R14-1233-100 n1_512170_444238 n1_512170_441248 0.00983553
R14-1234-100 n1_512170_444592 n1_512170_444238 0.00116447
R14-1235-100 n1_512170_447936 n1_512170_444592 0.011
R14-1236-100 n1_512170_451280 n1_512170_447936 0.011
R14-1237-100 n1_512170_454624 n1_512170_451280 0.011
R14-1238-100 n1_512170_457968 n1_512170_454624 0.011
R14-1239-100 n1_512170_461312 n1_512170_457968 0.011
R14-1240-100 n1_512170_464656 n1_512170_461312 0.011
R14-1241-100 n1_512170_466126 n1_512170_464656 0.004835529999999999
R14-1242-100 n1_512170_468000 n1_512170_466126 0.00616447
R14-1243-100 n1_512170_471344 n1_512170_468000 0.011
R14-1244-100 n1_512170_474688 n1_512170_471344 0.011
R14-1245-100 n1_512170_478032 n1_512170_474688 0.011
R14-1246-100 n1_512170_481376 n1_512170_478032 0.011
R14-1247-100 n1_512170_484720 n1_512170_481376 0.011
R14-1248-100 n1_512170_488064 n1_512170_484720 0.011
R14-1249-100 n1_512170_488622 n1_512170_488064 0.0018355300000000001
R14-1250-100 n1_512170_491408 n1_512170_488622 0.00916447
R14-1251-100 n1_512170_494752 n1_512170_491408 0.011
R14-1252-100 n1_512170_498096 n1_512170_494752 0.011
R14-1253-100 n1_512170_501440 n1_512170_498096 0.011
R14-1254-100 n1_512170_504784 n1_512170_501440 0.011
R14-1255-100 n1_512170_508128 n1_512170_504784 0.011
R14-1256-100 n1_512170_510510 n1_512170_508128 0.00783553
R14-1257-100 n1_512170_511472 n1_512170_510510 0.00316447
R14-1258-100 n1_512170_514816 n1_512170_511472 0.011
R14-1259-100 n1_512170_518160 n1_512170_514816 0.011
R14-1260-100 n1_512170_521504 n1_512170_518160 0.011
R14-1261-100 n1_512170_524848 n1_512170_521504 0.011
R14-1262-100 n1_512170_528192 n1_512170_524848 0.011
R14-1263-100 n1_512170_531536 n1_512170_528192 0.011
R14-1264-100 n1_512170_532398 n1_512170_531536 0.00283553
R14-1265-100 n1_512170_534880 n1_512170_532398 0.00816447
R14-1266-100 n1_512170_538224 n1_512170_534880 0.011
R14-1267-100 n1_512170_541568 n1_512170_538224 0.011
R14-1268-100 n1_512170_544912 n1_512170_541568 0.011
R14-1269-100 n1_512170_548256 n1_512170_544912 0.011
R14-1270-100 n1_512170_551600 n1_512170_548256 0.011
R14-1271-100 n1_512170_554894 n1_512170_551600 0.010835500000000001
R14-1272-100 n1_512170_554944 n1_512170_554894 0.000164474
R14-1273-100 n1_512170_558288 n1_512170_554944 0.011
R14-1274-100 n1_512170_561632 n1_512170_558288 0.011
R14-1275-100 n1_512170_564976 n1_512170_561632 0.011
R14-1276-100 n1_512170_568320 n1_512170_564976 0.011
R14-1277-100 n1_512170_571664 n1_512170_568320 0.011
R14-1278-100 n1_512170_575008 n1_512170_571664 0.011
R14-1279-100 n1_512170_576782 n1_512170_575008 0.00583553
R14-1280-100 n1_512170_578352 n1_512170_576782 0.00516447
R14-1281-100 n1_512170_581696 n1_512170_578352 0.011
R14-1282-100 n1_512170_585040 n1_512170_581696 0.011
R14-1283-100 n1_512170_588384 n1_512170_585040 0.011
R14-1284-100 n1_512170_591728 n1_512170_588384 0.011
R14-1285-100 n1_512170_595072 n1_512170_591728 0.011
R14-1286-100 n1_512170_598416 n1_512170_595072 0.011
R14-1287-100 n1_512170_599278 n1_512170_598416 0.00283553
R14-1288-100 n1_512170_601760 n1_512170_599278 0.00816447
R14-1289-100 n1_512170_605104 n1_512170_601760 0.011
R14-1290-100 n1_512170_608448 n1_512170_605104 0.011
R14-1291-100 n1_512170_611792 n1_512170_608448 0.011
R14-1292-100 n1_512170_615136 n1_512170_611792 0.011
R14-1293-100 n1_512170_618480 n1_512170_615136 0.011
R14-1294-100 n1_512170_624152 n1_512170_618480 0.018657899999999998
R14-1295-100 n1_512170_626152 n1_512170_624152 0.00657895
R14-1296-100 n1_489978_46000 n1_489978_44000 0.00657895
R14-1297-100 n1_489978_50000 n1_489978_46000 0.0131579
R14-1298-100 n1_489978_53344 n1_489978_50000 0.011
R14-1299-100 n1_489978_56688 n1_489978_53344 0.011
R14-1300-100 n1_489978_60032 n1_489978_56688 0.011
R14-1301-100 n1_489978_63376 n1_489978_60032 0.011
R14-1302-100 n1_489978_66720 n1_489978_63376 0.011
R14-1303-100 n1_489978_67278 n1_489978_66720 0.0018355300000000001
R14-1304-100 n1_489978_70064 n1_489978_67278 0.00916447
R14-1305-100 n1_489978_73408 n1_489978_70064 0.011
R14-1306-100 n1_489978_76752 n1_489978_73408 0.011
R14-1307-100 n1_489978_80096 n1_489978_76752 0.011
R14-1308-100 n1_489978_83440 n1_489978_80096 0.011
R14-1309-100 n1_489978_86784 n1_489978_83440 0.011
R14-1310-100 n1_489978_89166 n1_489978_86784 0.00783553
R14-1311-100 n1_489978_90128 n1_489978_89166 0.00316447
R14-1312-100 n1_489978_93472 n1_489978_90128 0.011
R14-1313-100 n1_489978_96816 n1_489978_93472 0.011
R14-1314-100 n1_489978_100160 n1_489978_96816 0.011
R14-1315-100 n1_489978_103504 n1_489978_100160 0.011
R14-1316-100 n1_489978_106848 n1_489978_103504 0.011
R14-1317-100 n1_489978_110192 n1_489978_106848 0.011
R14-1318-100 n1_489978_111662 n1_489978_110192 0.004835529999999999
R14-1319-100 n1_489978_113536 n1_489978_111662 0.00616447
R14-1320-100 n1_489978_116880 n1_489978_113536 0.011
R14-1321-100 n1_489978_120224 n1_489978_116880 0.011
R14-1322-100 n1_489978_123568 n1_489978_120224 0.011
R14-1323-100 n1_489978_126912 n1_489978_123568 0.011
R14-1324-100 n1_489978_130256 n1_489978_126912 0.011
R14-1325-100 n1_489978_133550 n1_489978_130256 0.010835500000000001
R14-1326-100 n1_489978_133600 n1_489978_133550 0.000164474
R14-1327-100 n1_489978_136944 n1_489978_133600 0.011
R14-1328-100 n1_489978_140288 n1_489978_136944 0.011
R14-1329-100 n1_489978_143632 n1_489978_140288 0.011
R14-1330-100 n1_489978_146976 n1_489978_143632 0.011
R14-1331-100 n1_489978_150320 n1_489978_146976 0.011
R14-1332-100 n1_489978_153664 n1_489978_150320 0.011
R14-1333-100 n1_489978_156046 n1_489978_153664 0.00783553
R14-1334-100 n1_489978_157008 n1_489978_156046 0.00316447
R14-1335-100 n1_489978_160352 n1_489978_157008 0.011
R14-1336-100 n1_489978_163696 n1_489978_160352 0.011
R14-1337-100 n1_489978_167040 n1_489978_163696 0.011
R14-1338-100 n1_489978_170384 n1_489978_167040 0.011
R14-1339-100 n1_489978_173728 n1_489978_170384 0.011
R14-1340-100 n1_489978_177072 n1_489978_173728 0.011
R14-1341-100 n1_489978_177934 n1_489978_177072 0.00283553
R14-1342-100 n1_489978_180416 n1_489978_177934 0.00816447
R14-1343-100 n1_489978_183760 n1_489978_180416 0.011
R14-1344-100 n1_489978_187104 n1_489978_183760 0.011
R14-1345-100 n1_489978_190448 n1_489978_187104 0.011
R14-1346-100 n1_489978_193792 n1_489978_190448 0.011
R14-1347-100 n1_489978_197136 n1_489978_193792 0.011
R14-1348-100 n1_489978_200430 n1_489978_197136 0.010835500000000001
R14-1349-100 n1_489978_200480 n1_489978_200430 0.000164474
R14-1350-100 n1_489978_203824 n1_489978_200480 0.011
R14-1351-100 n1_489978_207168 n1_489978_203824 0.011
R14-1352-100 n1_489978_210512 n1_489978_207168 0.011
R14-1353-100 n1_489978_213856 n1_489978_210512 0.011
R14-1354-100 n1_489978_217200 n1_489978_213856 0.011
R14-1355-100 n1_489978_220544 n1_489978_217200 0.011
R14-1356-100 n1_489978_222318 n1_489978_220544 0.00583553
R14-1357-100 n1_489978_223888 n1_489978_222318 0.00516447
R14-1358-100 n1_489978_227232 n1_489978_223888 0.011
R14-1359-100 n1_489978_230576 n1_489978_227232 0.011
R14-1360-100 n1_489978_233920 n1_489978_230576 0.011
R14-1361-100 n1_489978_237264 n1_489978_233920 0.011
R14-1362-100 n1_489978_240608 n1_489978_237264 0.011
R14-1363-100 n1_489978_243952 n1_489978_240608 0.011
R14-1364-100 n1_489978_244814 n1_489978_243952 0.00283553
R14-1365-100 n1_489978_247296 n1_489978_244814 0.00816447
R14-1366-100 n1_489978_250640 n1_489978_247296 0.011
R14-1367-100 n1_489978_253984 n1_489978_250640 0.011
R14-1368-100 n1_489978_257328 n1_489978_253984 0.011
R14-1369-100 n1_489978_260672 n1_489978_257328 0.011
R14-1370-100 n1_489978_264016 n1_489978_260672 0.011
R14-1371-100 n1_489978_266702 n1_489978_264016 0.00883553
R14-1372-100 n1_489978_267360 n1_489978_266702 0.00216447
R14-1373-100 n1_489978_270704 n1_489978_267360 0.011
R14-1374-100 n1_489978_274048 n1_489978_270704 0.011
R14-1375-100 n1_489978_277392 n1_489978_274048 0.011
R14-1376-100 n1_489978_280736 n1_489978_277392 0.011
R14-1377-100 n1_489978_284080 n1_489978_280736 0.011
R14-1378-100 n1_489978_287424 n1_489978_284080 0.011
R14-1379-100 n1_489978_288590 n1_489978_287424 0.00383553
R14-1380-100 n1_489978_290768 n1_489978_288590 0.007164470000000001
R14-1381-100 n1_489978_294112 n1_489978_290768 0.011
R14-1382-100 n1_489978_297456 n1_489978_294112 0.011
R14-1383-100 n1_489978_300800 n1_489978_297456 0.011
R14-1384-100 n1_489978_304144 n1_489978_300800 0.011
R14-1385-100 n1_489978_307488 n1_489978_304144 0.011
R14-1386-100 n1_489978_310832 n1_489978_307488 0.011
R14-1387-100 n1_489978_311086 n1_489978_310832 0.000835526
R14-1388-100 n1_489978_314176 n1_489978_311086 0.0101645
R14-1389-100 n1_489978_317520 n1_489978_314176 0.011
R14-1390-100 n1_489978_320864 n1_489978_317520 0.011
R14-1391-100 n1_489978_324208 n1_489978_320864 0.011
R14-1392-100 n1_489978_327552 n1_489978_324208 0.011
R14-1393-100 n1_489978_330896 n1_489978_327552 0.011
R14-1394-100 n1_489978_332974 n1_489978_330896 0.006835529999999999
R14-1395-100 n1_489978_334240 n1_489978_332974 0.00416447
R14-1396-100 n1_489978_337584 n1_489978_334240 0.011
R14-1397-100 n1_489978_340928 n1_489978_337584 0.011
R14-1398-100 n1_489978_344272 n1_489978_340928 0.011
R14-1399-100 n1_489978_347616 n1_489978_344272 0.011
R14-1400-100 n1_489978_350960 n1_489978_347616 0.011
R14-1401-100 n1_489978_354304 n1_489978_350960 0.011
R14-1402-100 n1_489978_355470 n1_489978_354304 0.00383553
R14-1403-100 n1_489978_357648 n1_489978_355470 0.007164470000000001
R14-1404-100 n1_489978_360992 n1_489978_357648 0.011
R14-1405-100 n1_489978_364336 n1_489978_360992 0.011
R14-1406-100 n1_489978_367680 n1_489978_364336 0.011
R14-1407-100 n1_489978_371024 n1_489978_367680 0.011
R14-1408-100 n1_489978_374368 n1_489978_371024 0.011
R14-1409-100 n1_489978_377358 n1_489978_374368 0.00983553
R14-1410-100 n1_489978_377712 n1_489978_377358 0.00116447
R14-1411-100 n1_489978_381056 n1_489978_377712 0.011
R14-1412-100 n1_489978_384400 n1_489978_381056 0.011
R14-1413-100 n1_489978_387744 n1_489978_384400 0.011
R14-1414-100 n1_489978_391088 n1_489978_387744 0.011
R14-1415-100 n1_489978_394432 n1_489978_391088 0.011
R14-1416-100 n1_489978_397776 n1_489978_394432 0.011
R14-1417-100 n1_489978_399854 n1_489978_397776 0.006835529999999999
R14-1418-100 n1_489978_401120 n1_489978_399854 0.00416447
R14-1419-100 n1_489978_404464 n1_489978_401120 0.011
R14-1420-100 n1_489978_407808 n1_489978_404464 0.011
R14-1421-100 n1_489978_411152 n1_489978_407808 0.011
R14-1422-100 n1_489978_414496 n1_489978_411152 0.011
R14-1423-100 n1_489978_417840 n1_489978_414496 0.011
R14-1424-100 n1_489978_421184 n1_489978_417840 0.011
R14-1425-100 n1_489978_421742 n1_489978_421184 0.0018355300000000001
R14-1426-100 n1_489978_424528 n1_489978_421742 0.00916447
R14-1427-100 n1_489978_427872 n1_489978_424528 0.011
R14-1428-100 n1_489978_431216 n1_489978_427872 0.011
R14-1429-100 n1_489978_434560 n1_489978_431216 0.011
R14-1430-100 n1_489978_437904 n1_489978_434560 0.011
R14-1431-100 n1_489978_441248 n1_489978_437904 0.011
R14-1432-100 n1_489978_444238 n1_489978_441248 0.00983553
R14-1433-100 n1_489978_444592 n1_489978_444238 0.00116447
R14-1434-100 n1_489978_447936 n1_489978_444592 0.011
R14-1435-100 n1_489978_451280 n1_489978_447936 0.011
R14-1436-100 n1_489978_454624 n1_489978_451280 0.011
R14-1437-100 n1_489978_457968 n1_489978_454624 0.011
R14-1438-100 n1_489978_461312 n1_489978_457968 0.011
R14-1439-100 n1_489978_464656 n1_489978_461312 0.011
R14-1440-100 n1_489978_466126 n1_489978_464656 0.004835529999999999
R14-1441-100 n1_489978_468000 n1_489978_466126 0.00616447
R14-1442-100 n1_489978_471344 n1_489978_468000 0.011
R14-1443-100 n1_489978_474688 n1_489978_471344 0.011
R14-1444-100 n1_489978_478032 n1_489978_474688 0.011
R14-1445-100 n1_489978_481376 n1_489978_478032 0.011
R14-1446-100 n1_489978_484720 n1_489978_481376 0.011
R14-1447-100 n1_489978_488064 n1_489978_484720 0.011
R14-1448-100 n1_489978_488622 n1_489978_488064 0.0018355300000000001
R14-1449-100 n1_489978_491408 n1_489978_488622 0.00916447
R14-1450-100 n1_489978_494752 n1_489978_491408 0.011
R14-1451-100 n1_489978_498096 n1_489978_494752 0.011
R14-1452-100 n1_489978_501440 n1_489978_498096 0.011
R14-1453-100 n1_489978_504784 n1_489978_501440 0.011
R14-1454-100 n1_489978_508128 n1_489978_504784 0.011
R14-1455-100 n1_489978_510510 n1_489978_508128 0.00783553
R14-1456-100 n1_489978_511472 n1_489978_510510 0.00316447
R14-1457-100 n1_489978_514816 n1_489978_511472 0.011
R14-1458-100 n1_489978_518160 n1_489978_514816 0.011
R14-1459-100 n1_489978_521504 n1_489978_518160 0.011
R14-1460-100 n1_489978_524848 n1_489978_521504 0.011
R14-1461-100 n1_489978_528192 n1_489978_524848 0.011
R14-1462-100 n1_489978_531536 n1_489978_528192 0.011
R14-1463-100 n1_489978_532398 n1_489978_531536 0.00283553
R14-1464-100 n1_489978_534880 n1_489978_532398 0.00816447
R14-1465-100 n1_489978_538224 n1_489978_534880 0.011
R14-1466-100 n1_489978_541568 n1_489978_538224 0.011
R14-1467-100 n1_489978_544912 n1_489978_541568 0.011
R14-1468-100 n1_489978_548256 n1_489978_544912 0.011
R14-1469-100 n1_489978_551600 n1_489978_548256 0.011
R14-1470-100 n1_489978_554894 n1_489978_551600 0.010835500000000001
R14-1471-100 n1_489978_554944 n1_489978_554894 0.000164474
R14-1472-100 n1_489978_558288 n1_489978_554944 0.011
R14-1473-100 n1_489978_561632 n1_489978_558288 0.011
R14-1474-100 n1_489978_564976 n1_489978_561632 0.011
R14-1475-100 n1_489978_568320 n1_489978_564976 0.011
R14-1476-100 n1_489978_571664 n1_489978_568320 0.011
R14-1477-100 n1_489978_575008 n1_489978_571664 0.011
R14-1478-100 n1_489978_576782 n1_489978_575008 0.00583553
R14-1479-100 n1_489978_578352 n1_489978_576782 0.00516447
R14-1480-100 n1_489978_581696 n1_489978_578352 0.011
R14-1481-100 n1_489978_585040 n1_489978_581696 0.011
R14-1482-100 n1_489978_588384 n1_489978_585040 0.011
R14-1483-100 n1_489978_591728 n1_489978_588384 0.011
R14-1484-100 n1_489978_595072 n1_489978_591728 0.011
R14-1485-100 n1_489978_598416 n1_489978_595072 0.011
R14-1486-100 n1_489978_599278 n1_489978_598416 0.00283553
R14-1487-100 n1_489978_601760 n1_489978_599278 0.00816447
R14-1488-100 n1_489978_605104 n1_489978_601760 0.011
R14-1489-100 n1_489978_608448 n1_489978_605104 0.011
R14-1490-100 n1_489978_611792 n1_489978_608448 0.011
R14-1491-100 n1_489978_615136 n1_489978_611792 0.011
R14-1492-100 n1_489978_618480 n1_489978_615136 0.011
R14-1493-100 n1_489978_624152 n1_489978_618480 0.018657899999999998
R14-1494-100 n1_489978_626152 n1_489978_624152 0.00657895
R14-1495-100 n1_467482_46000 n1_467482_44000 0.00657895
R14-1496-100 n1_467482_50000 n1_467482_46000 0.0131579
R14-1497-100 n1_467482_53344 n1_467482_50000 0.011
R14-1498-100 n1_467482_56688 n1_467482_53344 0.011
R14-1499-100 n1_467482_60032 n1_467482_56688 0.011
R14-1500-100 n1_467482_63376 n1_467482_60032 0.011
R14-1501-100 n1_467482_66720 n1_467482_63376 0.011
R14-1502-100 n1_467482_67278 n1_467482_66720 0.0018355300000000001
R14-1503-100 n1_467482_70064 n1_467482_67278 0.00916447
R14-1504-100 n1_467482_73408 n1_467482_70064 0.011
R14-1505-100 n1_467482_76752 n1_467482_73408 0.011
R14-1506-100 n1_467482_80096 n1_467482_76752 0.011
R14-1507-100 n1_467482_83440 n1_467482_80096 0.011
R14-1508-100 n1_467482_86784 n1_467482_83440 0.011
R14-1509-100 n1_467482_89166 n1_467482_86784 0.00783553
R14-1510-100 n1_467482_90128 n1_467482_89166 0.00316447
R14-1511-100 n1_467482_93472 n1_467482_90128 0.011
R14-1512-100 n1_467482_96816 n1_467482_93472 0.011
R14-1513-100 n1_467482_100160 n1_467482_96816 0.011
R14-1514-100 n1_467482_103504 n1_467482_100160 0.011
R14-1515-100 n1_467482_106848 n1_467482_103504 0.011
R14-1516-100 n1_467482_110192 n1_467482_106848 0.011
R14-1517-100 n1_467482_111662 n1_467482_110192 0.004835529999999999
R14-1518-100 n1_467482_113536 n1_467482_111662 0.00616447
R14-1519-100 n1_467482_116880 n1_467482_113536 0.011
R14-1520-100 n1_467482_120224 n1_467482_116880 0.011
R14-1521-100 n1_467482_123568 n1_467482_120224 0.011
R14-1522-100 n1_467482_126912 n1_467482_123568 0.011
R14-1523-100 n1_467482_130256 n1_467482_126912 0.011
R14-1524-100 n1_467482_133550 n1_467482_130256 0.010835500000000001
R14-1525-100 n1_467482_133600 n1_467482_133550 0.000164474
R14-1526-100 n1_467482_136944 n1_467482_133600 0.011
R14-1527-100 n1_467482_140288 n1_467482_136944 0.011
R14-1528-100 n1_467482_143632 n1_467482_140288 0.011
R14-1529-100 n1_467482_146976 n1_467482_143632 0.011
R14-1530-100 n1_467482_150320 n1_467482_146976 0.011
R14-1531-100 n1_467482_153664 n1_467482_150320 0.011
R14-1532-100 n1_467482_156046 n1_467482_153664 0.00783553
R14-1533-100 n1_467482_157008 n1_467482_156046 0.00316447
R14-1534-100 n1_467482_160352 n1_467482_157008 0.011
R14-1535-100 n1_467482_163696 n1_467482_160352 0.011
R14-1536-100 n1_467482_167040 n1_467482_163696 0.011
R14-1537-100 n1_467482_170384 n1_467482_167040 0.011
R14-1538-100 n1_467482_173728 n1_467482_170384 0.011
R14-1539-100 n1_467482_177072 n1_467482_173728 0.011
R14-1540-100 n1_467482_177934 n1_467482_177072 0.00283553
R14-1541-100 n1_467482_180416 n1_467482_177934 0.00816447
R14-1542-100 n1_467482_183760 n1_467482_180416 0.011
R14-1543-100 n1_467482_187104 n1_467482_183760 0.011
R14-1544-100 n1_467482_190448 n1_467482_187104 0.011
R14-1545-100 n1_467482_193792 n1_467482_190448 0.011
R14-1546-100 n1_467482_197136 n1_467482_193792 0.011
R14-1547-100 n1_467482_200430 n1_467482_197136 0.010835500000000001
R14-1548-100 n1_467482_200480 n1_467482_200430 0.000164474
R14-1549-100 n1_467482_203824 n1_467482_200480 0.011
R14-1550-100 n1_467482_207168 n1_467482_203824 0.011
R14-1551-100 n1_467482_210512 n1_467482_207168 0.011
R14-1552-100 n1_467482_213856 n1_467482_210512 0.011
R14-1553-100 n1_467482_217200 n1_467482_213856 0.011
R14-1554-100 n1_467482_220544 n1_467482_217200 0.011
R14-1555-100 n1_467482_222318 n1_467482_220544 0.00583553
R14-1556-100 n1_467482_223888 n1_467482_222318 0.00516447
R14-1557-100 n1_467482_227232 n1_467482_223888 0.011
R14-1558-100 n1_467482_230576 n1_467482_227232 0.011
R14-1559-100 n1_467482_233920 n1_467482_230576 0.011
R14-1560-100 n1_467482_237264 n1_467482_233920 0.011
R14-1561-100 n1_467482_240608 n1_467482_237264 0.011
R14-1562-100 n1_467482_243952 n1_467482_240608 0.011
R14-1563-100 n1_467482_244814 n1_467482_243952 0.00283553
R14-1564-100 n1_467482_247296 n1_467482_244814 0.00816447
R14-1565-100 n1_467482_250640 n1_467482_247296 0.011
R14-1566-100 n1_467482_253984 n1_467482_250640 0.011
R14-1567-100 n1_467482_257328 n1_467482_253984 0.011
R14-1568-100 n1_467482_260672 n1_467482_257328 0.011
R14-1569-100 n1_467482_264016 n1_467482_260672 0.011
R14-1570-100 n1_467482_266702 n1_467482_264016 0.00883553
R14-1571-100 n1_467482_267360 n1_467482_266702 0.00216447
R14-1572-100 n1_467482_270704 n1_467482_267360 0.011
R14-1573-100 n1_467482_274048 n1_467482_270704 0.011
R14-1574-100 n1_467482_277392 n1_467482_274048 0.011
R14-1575-100 n1_467482_280736 n1_467482_277392 0.011
R14-1576-100 n1_467482_284080 n1_467482_280736 0.011
R14-1577-100 n1_467482_287424 n1_467482_284080 0.011
R14-1578-100 n1_467482_288590 n1_467482_287424 0.00383553
R14-1579-100 n1_467482_290768 n1_467482_288590 0.007164470000000001
R14-1580-100 n1_467482_294112 n1_467482_290768 0.011
R14-1581-100 n1_467482_297456 n1_467482_294112 0.011
R14-1582-100 n1_467482_300800 n1_467482_297456 0.011
R14-1583-100 n1_467482_304144 n1_467482_300800 0.011
R14-1584-100 n1_467482_307488 n1_467482_304144 0.011
R14-1585-100 n1_467482_310832 n1_467482_307488 0.011
R14-1586-100 n1_467482_311086 n1_467482_310832 0.000835526
R14-1587-100 n1_467482_314176 n1_467482_311086 0.0101645
R14-1588-100 n1_467482_317520 n1_467482_314176 0.011
R14-1589-100 n1_467482_320864 n1_467482_317520 0.011
R14-1590-100 n1_467482_324208 n1_467482_320864 0.011
R14-1591-100 n1_467482_327552 n1_467482_324208 0.011
R14-1592-100 n1_467482_330896 n1_467482_327552 0.011
R14-1593-100 n1_467482_332974 n1_467482_330896 0.006835529999999999
R14-1594-100 n1_467482_334240 n1_467482_332974 0.00416447
R14-1595-100 n1_467482_337584 n1_467482_334240 0.011
R14-1596-100 n1_467482_340928 n1_467482_337584 0.011
R14-1597-100 n1_467482_344272 n1_467482_340928 0.011
R14-1598-100 n1_467482_347616 n1_467482_344272 0.011
R14-1599-100 n1_467482_350960 n1_467482_347616 0.011
R14-1600-100 n1_467482_354304 n1_467482_350960 0.011
R14-1601-100 n1_467482_355470 n1_467482_354304 0.00383553
R14-1602-100 n1_467482_357648 n1_467482_355470 0.007164470000000001
R14-1603-100 n1_467482_360992 n1_467482_357648 0.011
R14-1604-100 n1_467482_364336 n1_467482_360992 0.011
R14-1605-100 n1_467482_367680 n1_467482_364336 0.011
R14-1606-100 n1_467482_371024 n1_467482_367680 0.011
R14-1607-100 n1_467482_374368 n1_467482_371024 0.011
R14-1608-100 n1_467482_377358 n1_467482_374368 0.00983553
R14-1609-100 n1_467482_377712 n1_467482_377358 0.00116447
R14-1610-100 n1_467482_381056 n1_467482_377712 0.011
R14-1611-100 n1_467482_384400 n1_467482_381056 0.011
R14-1612-100 n1_467482_387744 n1_467482_384400 0.011
R14-1613-100 n1_467482_391088 n1_467482_387744 0.011
R14-1614-100 n1_467482_394432 n1_467482_391088 0.011
R14-1615-100 n1_467482_397776 n1_467482_394432 0.011
R14-1616-100 n1_467482_399854 n1_467482_397776 0.006835529999999999
R14-1617-100 n1_467482_401120 n1_467482_399854 0.00416447
R14-1618-100 n1_467482_404464 n1_467482_401120 0.011
R14-1619-100 n1_467482_407808 n1_467482_404464 0.011
R14-1620-100 n1_467482_411152 n1_467482_407808 0.011
R14-1621-100 n1_467482_414496 n1_467482_411152 0.011
R14-1622-100 n1_467482_417840 n1_467482_414496 0.011
R14-1623-100 n1_467482_421184 n1_467482_417840 0.011
R14-1624-100 n1_467482_421742 n1_467482_421184 0.0018355300000000001
R14-1625-100 n1_467482_424528 n1_467482_421742 0.00916447
R14-1626-100 n1_467482_427872 n1_467482_424528 0.011
R14-1627-100 n1_467482_431216 n1_467482_427872 0.011
R14-1628-100 n1_467482_434560 n1_467482_431216 0.011
R14-1629-100 n1_467482_437904 n1_467482_434560 0.011
R14-1630-100 n1_467482_441248 n1_467482_437904 0.011
R14-1631-100 n1_467482_444238 n1_467482_441248 0.00983553
R14-1632-100 n1_467482_444592 n1_467482_444238 0.00116447
R14-1633-100 n1_467482_447936 n1_467482_444592 0.011
R14-1634-100 n1_467482_451280 n1_467482_447936 0.011
R14-1635-100 n1_467482_454624 n1_467482_451280 0.011
R14-1636-100 n1_467482_457968 n1_467482_454624 0.011
R14-1637-100 n1_467482_461312 n1_467482_457968 0.011
R14-1638-100 n1_467482_464656 n1_467482_461312 0.011
R14-1639-100 n1_467482_466126 n1_467482_464656 0.004835529999999999
R14-1640-100 n1_467482_468000 n1_467482_466126 0.00616447
R14-1641-100 n1_467482_471344 n1_467482_468000 0.011
R14-1642-100 n1_467482_474688 n1_467482_471344 0.011
R14-1643-100 n1_467482_478032 n1_467482_474688 0.011
R14-1644-100 n1_467482_481376 n1_467482_478032 0.011
R14-1645-100 n1_467482_484720 n1_467482_481376 0.011
R14-1646-100 n1_467482_488064 n1_467482_484720 0.011
R14-1647-100 n1_467482_488622 n1_467482_488064 0.0018355300000000001
R14-1648-100 n1_467482_491408 n1_467482_488622 0.00916447
R14-1649-100 n1_467482_494752 n1_467482_491408 0.011
R14-1650-100 n1_467482_498096 n1_467482_494752 0.011
R14-1651-100 n1_467482_501440 n1_467482_498096 0.011
R14-1652-100 n1_467482_504784 n1_467482_501440 0.011
R14-1653-100 n1_467482_508128 n1_467482_504784 0.011
R14-1654-100 n1_467482_510510 n1_467482_508128 0.00783553
R14-1655-100 n1_467482_511472 n1_467482_510510 0.00316447
R14-1656-100 n1_467482_514816 n1_467482_511472 0.011
R14-1657-100 n1_467482_518160 n1_467482_514816 0.011
R14-1658-100 n1_467482_521504 n1_467482_518160 0.011
R14-1659-100 n1_467482_524848 n1_467482_521504 0.011
R14-1660-100 n1_467482_528192 n1_467482_524848 0.011
R14-1661-100 n1_467482_531536 n1_467482_528192 0.011
R14-1662-100 n1_467482_532398 n1_467482_531536 0.00283553
R14-1663-100 n1_467482_534880 n1_467482_532398 0.00816447
R14-1664-100 n1_467482_538224 n1_467482_534880 0.011
R14-1665-100 n1_467482_541568 n1_467482_538224 0.011
R14-1666-100 n1_467482_544912 n1_467482_541568 0.011
R14-1667-100 n1_467482_548256 n1_467482_544912 0.011
R14-1668-100 n1_467482_551600 n1_467482_548256 0.011
R14-1669-100 n1_467482_554894 n1_467482_551600 0.010835500000000001
R14-1670-100 n1_467482_554944 n1_467482_554894 0.000164474
R14-1671-100 n1_467482_558288 n1_467482_554944 0.011
R14-1672-100 n1_467482_561632 n1_467482_558288 0.011
R14-1673-100 n1_467482_564976 n1_467482_561632 0.011
R14-1674-100 n1_467482_568320 n1_467482_564976 0.011
R14-1675-100 n1_467482_571664 n1_467482_568320 0.011
R14-1676-100 n1_467482_575008 n1_467482_571664 0.011
R14-1677-100 n1_467482_576782 n1_467482_575008 0.00583553
R14-1678-100 n1_467482_578352 n1_467482_576782 0.00516447
R14-1679-100 n1_467482_581696 n1_467482_578352 0.011
R14-1680-100 n1_467482_585040 n1_467482_581696 0.011
R14-1681-100 n1_467482_588384 n1_467482_585040 0.011
R14-1682-100 n1_467482_591728 n1_467482_588384 0.011
R14-1683-100 n1_467482_595072 n1_467482_591728 0.011
R14-1684-100 n1_467482_598416 n1_467482_595072 0.011
R14-1685-100 n1_467482_599278 n1_467482_598416 0.00283553
R14-1686-100 n1_467482_601760 n1_467482_599278 0.00816447
R14-1687-100 n1_467482_605104 n1_467482_601760 0.011
R14-1688-100 n1_467482_608448 n1_467482_605104 0.011
R14-1689-100 n1_467482_611792 n1_467482_608448 0.011
R14-1690-100 n1_467482_615136 n1_467482_611792 0.011
R14-1691-100 n1_467482_618480 n1_467482_615136 0.011
R14-1692-100 n1_467482_624152 n1_467482_618480 0.018657899999999998
R14-1693-100 n1_467482_626152 n1_467482_624152 0.00657895
R14-1694-100 n1_445290_46000 n1_445290_44000 0.00657895
R14-1695-100 n1_445290_50000 n1_445290_46000 0.0131579
R14-1696-100 n1_445290_53344 n1_445290_50000 0.011
R14-1697-100 n1_445290_56688 n1_445290_53344 0.011
R14-1698-100 n1_445290_60032 n1_445290_56688 0.011
R14-1699-100 n1_445290_63376 n1_445290_60032 0.011
R14-1700-100 n1_445290_66720 n1_445290_63376 0.011
R14-1701-100 n1_445290_67278 n1_445290_66720 0.0018355300000000001
R14-1702-100 n1_445290_70064 n1_445290_67278 0.00916447
R14-1703-100 n1_445290_73408 n1_445290_70064 0.011
R14-1704-100 n1_445290_76752 n1_445290_73408 0.011
R14-1705-100 n1_445290_80096 n1_445290_76752 0.011
R14-1706-100 n1_445290_83440 n1_445290_80096 0.011
R14-1707-100 n1_445290_86784 n1_445290_83440 0.011
R14-1708-100 n1_445290_89166 n1_445290_86784 0.00783553
R14-1709-100 n1_445290_90128 n1_445290_89166 0.00316447
R14-1710-100 n1_445290_93472 n1_445290_90128 0.011
R14-1711-100 n1_445290_96816 n1_445290_93472 0.011
R14-1712-100 n1_445290_100160 n1_445290_96816 0.011
R14-1713-100 n1_445290_103504 n1_445290_100160 0.011
R14-1714-100 n1_445290_106848 n1_445290_103504 0.011
R14-1715-100 n1_445290_110192 n1_445290_106848 0.011
R14-1716-100 n1_445290_111662 n1_445290_110192 0.004835529999999999
R14-1717-100 n1_445290_113536 n1_445290_111662 0.00616447
R14-1718-100 n1_445290_116880 n1_445290_113536 0.011
R14-1719-100 n1_445290_120224 n1_445290_116880 0.011
R14-1720-100 n1_445290_123568 n1_445290_120224 0.011
R14-1721-100 n1_445290_126912 n1_445290_123568 0.011
R14-1722-100 n1_445290_130256 n1_445290_126912 0.011
R14-1723-100 n1_445290_133550 n1_445290_130256 0.010835500000000001
R14-1724-100 n1_445290_133600 n1_445290_133550 0.000164474
R14-1725-100 n1_445290_136944 n1_445290_133600 0.011
R14-1726-100 n1_445290_140288 n1_445290_136944 0.011
R14-1727-100 n1_445290_143632 n1_445290_140288 0.011
R14-1728-100 n1_445290_146976 n1_445290_143632 0.011
R14-1729-100 n1_445290_150320 n1_445290_146976 0.011
R14-1730-100 n1_445290_153664 n1_445290_150320 0.011
R14-1731-100 n1_445290_156046 n1_445290_153664 0.00783553
R14-1732-100 n1_445290_157008 n1_445290_156046 0.00316447
R14-1733-100 n1_445290_160352 n1_445290_157008 0.011
R14-1734-100 n1_445290_163696 n1_445290_160352 0.011
R14-1735-100 n1_445290_167040 n1_445290_163696 0.011
R14-1736-100 n1_445290_170384 n1_445290_167040 0.011
R14-1737-100 n1_445290_173728 n1_445290_170384 0.011
R14-1738-100 n1_445290_177072 n1_445290_173728 0.011
R14-1739-100 n1_445290_177934 n1_445290_177072 0.00283553
R14-1740-100 n1_445290_180416 n1_445290_177934 0.00816447
R14-1741-100 n1_445290_183760 n1_445290_180416 0.011
R14-1742-100 n1_445290_187104 n1_445290_183760 0.011
R14-1743-100 n1_445290_190448 n1_445290_187104 0.011
R14-1744-100 n1_445290_193792 n1_445290_190448 0.011
R14-1745-100 n1_445290_197136 n1_445290_193792 0.011
R14-1746-100 n1_445290_200430 n1_445290_197136 0.010835500000000001
R14-1747-100 n1_445290_200480 n1_445290_200430 0.000164474
R14-1748-100 n1_445290_203824 n1_445290_200480 0.011
R14-1749-100 n1_445290_207168 n1_445290_203824 0.011
R14-1750-100 n1_445290_210512 n1_445290_207168 0.011
R14-1751-100 n1_445290_213856 n1_445290_210512 0.011
R14-1752-100 n1_445290_217200 n1_445290_213856 0.011
R14-1753-100 n1_445290_220544 n1_445290_217200 0.011
R14-1754-100 n1_445290_222318 n1_445290_220544 0.00583553
R14-1755-100 n1_445290_223888 n1_445290_222318 0.00516447
R14-1756-100 n1_445290_227232 n1_445290_223888 0.011
R14-1757-100 n1_445290_230576 n1_445290_227232 0.011
R14-1758-100 n1_445290_233920 n1_445290_230576 0.011
R14-1759-100 n1_445290_237264 n1_445290_233920 0.011
R14-1760-100 n1_445290_240608 n1_445290_237264 0.011
R14-1761-100 n1_445290_243952 n1_445290_240608 0.011
R14-1762-100 n1_445290_244814 n1_445290_243952 0.00283553
R14-1763-100 n1_445290_247296 n1_445290_244814 0.00816447
R14-1764-100 n1_445290_250640 n1_445290_247296 0.011
R14-1765-100 n1_445290_253984 n1_445290_250640 0.011
R14-1766-100 n1_445290_257328 n1_445290_253984 0.011
R14-1767-100 n1_445290_260672 n1_445290_257328 0.011
R14-1768-100 n1_445290_264016 n1_445290_260672 0.011
R14-1769-100 n1_445290_266702 n1_445290_264016 0.00883553
R14-1770-100 n1_445290_267360 n1_445290_266702 0.00216447
R14-1771-100 n1_445290_270704 n1_445290_267360 0.011
R14-1772-100 n1_445290_274048 n1_445290_270704 0.011
R14-1773-100 n1_445290_277392 n1_445290_274048 0.011
R14-1774-100 n1_445290_280736 n1_445290_277392 0.011
R14-1775-100 n1_445290_284080 n1_445290_280736 0.011
R14-1776-100 n1_445290_287424 n1_445290_284080 0.011
R14-1777-100 n1_445290_288590 n1_445290_287424 0.00383553
R14-1778-100 n1_445290_290768 n1_445290_288590 0.007164470000000001
R14-1779-100 n1_445290_294112 n1_445290_290768 0.011
R14-1780-100 n1_445290_297456 n1_445290_294112 0.011
R14-1781-100 n1_445290_300800 n1_445290_297456 0.011
R14-1782-100 n1_445290_304144 n1_445290_300800 0.011
R14-1783-100 n1_445290_307488 n1_445290_304144 0.011
R14-1784-100 n1_445290_310832 n1_445290_307488 0.011
R14-1785-100 n1_445290_311086 n1_445290_310832 0.000835526
R14-1786-100 n1_445290_314176 n1_445290_311086 0.0101645
R14-1787-100 n1_445290_317520 n1_445290_314176 0.011
R14-1788-100 n1_445290_320864 n1_445290_317520 0.011
R14-1789-100 n1_445290_324208 n1_445290_320864 0.011
R14-1790-100 n1_445290_327552 n1_445290_324208 0.011
R14-1791-100 n1_445290_330896 n1_445290_327552 0.011
R14-1792-100 n1_445290_332974 n1_445290_330896 0.006835529999999999
R14-1793-100 n1_445290_334240 n1_445290_332974 0.00416447
R14-1794-100 n1_445290_337584 n1_445290_334240 0.011
R14-1795-100 n1_445290_340928 n1_445290_337584 0.011
R14-1796-100 n1_445290_344272 n1_445290_340928 0.011
R14-1797-100 n1_445290_347616 n1_445290_344272 0.011
R14-1798-100 n1_445290_350960 n1_445290_347616 0.011
R14-1799-100 n1_445290_354304 n1_445290_350960 0.011
R14-1800-100 n1_445290_355470 n1_445290_354304 0.00383553
R14-1801-100 n1_445290_357648 n1_445290_355470 0.007164470000000001
R14-1802-100 n1_445290_360992 n1_445290_357648 0.011
R14-1803-100 n1_445290_364336 n1_445290_360992 0.011
R14-1804-100 n1_445290_367680 n1_445290_364336 0.011
R14-1805-100 n1_445290_371024 n1_445290_367680 0.011
R14-1806-100 n1_445290_374368 n1_445290_371024 0.011
R14-1807-100 n1_445290_377358 n1_445290_374368 0.00983553
R14-1808-100 n1_445290_377712 n1_445290_377358 0.00116447
R14-1809-100 n1_445290_381056 n1_445290_377712 0.011
R14-1810-100 n1_445290_384400 n1_445290_381056 0.011
R14-1811-100 n1_445290_387744 n1_445290_384400 0.011
R14-1812-100 n1_445290_391088 n1_445290_387744 0.011
R14-1813-100 n1_445290_394432 n1_445290_391088 0.011
R14-1814-100 n1_445290_397776 n1_445290_394432 0.011
R14-1815-100 n1_445290_399854 n1_445290_397776 0.006835529999999999
R14-1816-100 n1_445290_401120 n1_445290_399854 0.00416447
R14-1817-100 n1_445290_404464 n1_445290_401120 0.011
R14-1818-100 n1_445290_407808 n1_445290_404464 0.011
R14-1819-100 n1_445290_411152 n1_445290_407808 0.011
R14-1820-100 n1_445290_414496 n1_445290_411152 0.011
R14-1821-100 n1_445290_417840 n1_445290_414496 0.011
R14-1822-100 n1_445290_421184 n1_445290_417840 0.011
R14-1823-100 n1_445290_421742 n1_445290_421184 0.0018355300000000001
R14-1824-100 n1_445290_424528 n1_445290_421742 0.00916447
R14-1825-100 n1_445290_427872 n1_445290_424528 0.011
R14-1826-100 n1_445290_431216 n1_445290_427872 0.011
R14-1827-100 n1_445290_434560 n1_445290_431216 0.011
R14-1828-100 n1_445290_437904 n1_445290_434560 0.011
R14-1829-100 n1_445290_441248 n1_445290_437904 0.011
R14-1830-100 n1_445290_444238 n1_445290_441248 0.00983553
R14-1831-100 n1_445290_444592 n1_445290_444238 0.00116447
R14-1832-100 n1_445290_447936 n1_445290_444592 0.011
R14-1833-100 n1_445290_451280 n1_445290_447936 0.011
R14-1834-100 n1_445290_454624 n1_445290_451280 0.011
R14-1835-100 n1_445290_457968 n1_445290_454624 0.011
R14-1836-100 n1_445290_461312 n1_445290_457968 0.011
R14-1837-100 n1_445290_464656 n1_445290_461312 0.011
R14-1838-100 n1_445290_466126 n1_445290_464656 0.004835529999999999
R14-1839-100 n1_445290_468000 n1_445290_466126 0.00616447
R14-1840-100 n1_445290_471344 n1_445290_468000 0.011
R14-1841-100 n1_445290_474688 n1_445290_471344 0.011
R14-1842-100 n1_445290_478032 n1_445290_474688 0.011
R14-1843-100 n1_445290_481376 n1_445290_478032 0.011
R14-1844-100 n1_445290_484720 n1_445290_481376 0.011
R14-1845-100 n1_445290_488064 n1_445290_484720 0.011
R14-1846-100 n1_445290_488622 n1_445290_488064 0.0018355300000000001
R14-1847-100 n1_445290_491408 n1_445290_488622 0.00916447
R14-1848-100 n1_445290_494752 n1_445290_491408 0.011
R14-1849-100 n1_445290_498096 n1_445290_494752 0.011
R14-1850-100 n1_445290_501440 n1_445290_498096 0.011
R14-1851-100 n1_445290_504784 n1_445290_501440 0.011
R14-1852-100 n1_445290_508128 n1_445290_504784 0.011
R14-1853-100 n1_445290_510510 n1_445290_508128 0.00783553
R14-1854-100 n1_445290_511472 n1_445290_510510 0.00316447
R14-1855-100 n1_445290_514816 n1_445290_511472 0.011
R14-1856-100 n1_445290_518160 n1_445290_514816 0.011
R14-1857-100 n1_445290_521504 n1_445290_518160 0.011
R14-1858-100 n1_445290_524848 n1_445290_521504 0.011
R14-1859-100 n1_445290_528192 n1_445290_524848 0.011
R14-1860-100 n1_445290_531536 n1_445290_528192 0.011
R14-1861-100 n1_445290_532398 n1_445290_531536 0.00283553
R14-1862-100 n1_445290_534880 n1_445290_532398 0.00816447
R14-1863-100 n1_445290_538224 n1_445290_534880 0.011
R14-1864-100 n1_445290_541568 n1_445290_538224 0.011
R14-1865-100 n1_445290_544912 n1_445290_541568 0.011
R14-1866-100 n1_445290_548256 n1_445290_544912 0.011
R14-1867-100 n1_445290_551600 n1_445290_548256 0.011
R14-1868-100 n1_445290_554894 n1_445290_551600 0.010835500000000001
R14-1869-100 n1_445290_554944 n1_445290_554894 0.000164474
R14-1870-100 n1_445290_558288 n1_445290_554944 0.011
R14-1871-100 n1_445290_561632 n1_445290_558288 0.011
R14-1872-100 n1_445290_564976 n1_445290_561632 0.011
R14-1873-100 n1_445290_568320 n1_445290_564976 0.011
R14-1874-100 n1_445290_571664 n1_445290_568320 0.011
R14-1875-100 n1_445290_575008 n1_445290_571664 0.011
R14-1876-100 n1_445290_576782 n1_445290_575008 0.00583553
R14-1877-100 n1_445290_578352 n1_445290_576782 0.00516447
R14-1878-100 n1_445290_581696 n1_445290_578352 0.011
R14-1879-100 n1_445290_585040 n1_445290_581696 0.011
R14-1880-100 n1_445290_588384 n1_445290_585040 0.011
R14-1881-100 n1_445290_591728 n1_445290_588384 0.011
R14-1882-100 n1_445290_595072 n1_445290_591728 0.011
R14-1883-100 n1_445290_598416 n1_445290_595072 0.011
R14-1884-100 n1_445290_599278 n1_445290_598416 0.00283553
R14-1885-100 n1_445290_601760 n1_445290_599278 0.00816447
R14-1886-100 n1_445290_605104 n1_445290_601760 0.011
R14-1887-100 n1_445290_608448 n1_445290_605104 0.011
R14-1888-100 n1_445290_611792 n1_445290_608448 0.011
R14-1889-100 n1_445290_615136 n1_445290_611792 0.011
R14-1890-100 n1_445290_618480 n1_445290_615136 0.011
R14-1891-100 n1_445290_624152 n1_445290_618480 0.018657899999999998
R14-1892-100 n1_445290_626152 n1_445290_624152 0.00657895
R14-1893-100 n1_422794_46000 n1_422794_44000 0.00657895
R14-1894-100 n1_422794_50000 n1_422794_46000 0.0131579
R14-1895-100 n1_422794_53344 n1_422794_50000 0.011
R14-1896-100 n1_422794_56688 n1_422794_53344 0.011
R14-1897-100 n1_422794_60032 n1_422794_56688 0.011
R14-1898-100 n1_422794_63376 n1_422794_60032 0.011
R14-1899-100 n1_422794_66720 n1_422794_63376 0.011
R14-1900-100 n1_422794_67278 n1_422794_66720 0.0018355300000000001
R14-1901-100 n1_422794_70064 n1_422794_67278 0.00916447
R14-1902-100 n1_422794_73408 n1_422794_70064 0.011
R14-1903-100 n1_422794_76752 n1_422794_73408 0.011
R14-1904-100 n1_422794_80096 n1_422794_76752 0.011
R14-1905-100 n1_422794_83440 n1_422794_80096 0.011
R14-1906-100 n1_422794_86784 n1_422794_83440 0.011
R14-1907-100 n1_422794_89166 n1_422794_86784 0.00783553
R14-1908-100 n1_422794_90128 n1_422794_89166 0.00316447
R14-1909-100 n1_422794_93472 n1_422794_90128 0.011
R14-1910-100 n1_422794_96816 n1_422794_93472 0.011
R14-1911-100 n1_422794_100160 n1_422794_96816 0.011
R14-1912-100 n1_422794_103504 n1_422794_100160 0.011
R14-1913-100 n1_422794_106848 n1_422794_103504 0.011
R14-1914-100 n1_422794_110192 n1_422794_106848 0.011
R14-1915-100 n1_422794_111662 n1_422794_110192 0.004835529999999999
R14-1916-100 n1_422794_113536 n1_422794_111662 0.00616447
R14-1917-100 n1_422794_116880 n1_422794_113536 0.011
R14-1918-100 n1_422794_120224 n1_422794_116880 0.011
R14-1919-100 n1_422794_123568 n1_422794_120224 0.011
R14-1920-100 n1_422794_126912 n1_422794_123568 0.011
R14-1921-100 n1_422794_130256 n1_422794_126912 0.011
R14-1922-100 n1_422794_133550 n1_422794_130256 0.010835500000000001
R14-1923-100 n1_422794_133600 n1_422794_133550 0.000164474
R14-1924-100 n1_422794_136944 n1_422794_133600 0.011
R14-1925-100 n1_422794_140288 n1_422794_136944 0.011
R14-1926-100 n1_422794_143632 n1_422794_140288 0.011
R14-1927-100 n1_422794_146976 n1_422794_143632 0.011
R14-1928-100 n1_422794_150320 n1_422794_146976 0.011
R14-1929-100 n1_422794_153664 n1_422794_150320 0.011
R14-1930-100 n1_422794_156046 n1_422794_153664 0.00783553
R14-1931-100 n1_422794_157008 n1_422794_156046 0.00316447
R14-1932-100 n1_422794_160352 n1_422794_157008 0.011
R14-1933-100 n1_422794_163696 n1_422794_160352 0.011
R14-1934-100 n1_422794_167040 n1_422794_163696 0.011
R14-1935-100 n1_422794_170384 n1_422794_167040 0.011
R14-1936-100 n1_422794_173728 n1_422794_170384 0.011
R14-1937-100 n1_422794_177072 n1_422794_173728 0.011
R14-1938-100 n1_422794_177934 n1_422794_177072 0.00283553
R14-1939-100 n1_422794_180416 n1_422794_177934 0.00816447
R14-1940-100 n1_422794_183760 n1_422794_180416 0.011
R14-1941-100 n1_422794_187104 n1_422794_183760 0.011
R14-1942-100 n1_422794_190448 n1_422794_187104 0.011
R14-1943-100 n1_422794_193792 n1_422794_190448 0.011
R14-1944-100 n1_422794_197136 n1_422794_193792 0.011
R14-1945-100 n1_422794_200430 n1_422794_197136 0.010835500000000001
R14-1946-100 n1_422794_200480 n1_422794_200430 0.000164474
R14-1947-100 n1_422794_203824 n1_422794_200480 0.011
R14-1948-100 n1_422794_207168 n1_422794_203824 0.011
R14-1949-100 n1_422794_210512 n1_422794_207168 0.011
R14-1950-100 n1_422794_213856 n1_422794_210512 0.011
R14-1951-100 n1_422794_217200 n1_422794_213856 0.011
R14-1952-100 n1_422794_220544 n1_422794_217200 0.011
R14-1953-100 n1_422794_222318 n1_422794_220544 0.00583553
R14-1954-100 n1_422794_223888 n1_422794_222318 0.00516447
R14-1955-100 n1_422794_227232 n1_422794_223888 0.011
R14-1956-100 n1_422794_230576 n1_422794_227232 0.011
R14-1957-100 n1_422794_233920 n1_422794_230576 0.011
R14-1958-100 n1_422794_237264 n1_422794_233920 0.011
R14-1959-100 n1_422794_240608 n1_422794_237264 0.011
R14-1960-100 n1_422794_243952 n1_422794_240608 0.011
R14-1961-100 n1_422794_244814 n1_422794_243952 0.00283553
R14-1962-100 n1_422794_247296 n1_422794_244814 0.00816447
R14-1963-100 n1_422794_250640 n1_422794_247296 0.011
R14-1964-100 n1_422794_253984 n1_422794_250640 0.011
R14-1965-100 n1_422794_257328 n1_422794_253984 0.011
R14-1966-100 n1_422794_260672 n1_422794_257328 0.011
R14-1967-100 n1_422794_264016 n1_422794_260672 0.011
R14-1968-100 n1_422794_266702 n1_422794_264016 0.00883553
R14-1969-100 n1_422794_267360 n1_422794_266702 0.00216447
R14-1970-100 n1_422794_270704 n1_422794_267360 0.011
R14-1971-100 n1_422794_274048 n1_422794_270704 0.011
R14-1972-100 n1_422794_277392 n1_422794_274048 0.011
R14-1973-100 n1_422794_280736 n1_422794_277392 0.011
R14-1974-100 n1_422794_284080 n1_422794_280736 0.011
R14-1975-100 n1_422794_287424 n1_422794_284080 0.011
R14-1976-100 n1_422794_288590 n1_422794_287424 0.00383553
R14-1977-100 n1_422794_290768 n1_422794_288590 0.007164470000000001
R14-1978-100 n1_422794_294112 n1_422794_290768 0.011
R14-1979-100 n1_422794_297456 n1_422794_294112 0.011
R14-1980-100 n1_422794_300800 n1_422794_297456 0.011
R14-1981-100 n1_422794_304144 n1_422794_300800 0.011
R14-1982-100 n1_422794_307488 n1_422794_304144 0.011
R14-1983-100 n1_422794_310832 n1_422794_307488 0.011
R14-1984-100 n1_422794_311086 n1_422794_310832 0.000835526
R14-1985-100 n1_422794_314176 n1_422794_311086 0.0101645
R14-1986-100 n1_422794_317520 n1_422794_314176 0.011
R14-1987-100 n1_422794_320864 n1_422794_317520 0.011
R14-1988-100 n1_422794_324208 n1_422794_320864 0.011
R14-1989-100 n1_422794_327552 n1_422794_324208 0.011
R14-1990-100 n1_422794_330896 n1_422794_327552 0.011
R14-1991-100 n1_422794_332974 n1_422794_330896 0.006835529999999999
R14-1992-100 n1_422794_334240 n1_422794_332974 0.00416447
R14-1993-100 n1_422794_337584 n1_422794_334240 0.011
R14-1994-100 n1_422794_340928 n1_422794_337584 0.011
R14-1995-100 n1_422794_344272 n1_422794_340928 0.011
R14-1996-100 n1_422794_347616 n1_422794_344272 0.011
R14-1997-100 n1_422794_350960 n1_422794_347616 0.011
R14-1998-100 n1_422794_354304 n1_422794_350960 0.011
R14-1999-100 n1_422794_355470 n1_422794_354304 0.00383553
R14-2000-100 n1_422794_357648 n1_422794_355470 0.007164470000000001
R14-2001-100 n1_422794_360992 n1_422794_357648 0.011
R14-2002-100 n1_422794_364336 n1_422794_360992 0.011
R14-2003-100 n1_422794_367680 n1_422794_364336 0.011
R14-2004-100 n1_422794_371024 n1_422794_367680 0.011
R14-2005-100 n1_422794_374368 n1_422794_371024 0.011
R14-2006-100 n1_422794_377358 n1_422794_374368 0.00983553
R14-2007-100 n1_422794_377712 n1_422794_377358 0.00116447
R14-2008-100 n1_422794_381056 n1_422794_377712 0.011
R14-2009-100 n1_422794_384400 n1_422794_381056 0.011
R14-2010-100 n1_422794_387744 n1_422794_384400 0.011
R14-2011-100 n1_422794_391088 n1_422794_387744 0.011
R14-2012-100 n1_422794_394432 n1_422794_391088 0.011
R14-2013-100 n1_422794_397776 n1_422794_394432 0.011
R14-2014-100 n1_422794_399854 n1_422794_397776 0.006835529999999999
R14-2015-100 n1_422794_401120 n1_422794_399854 0.00416447
R14-2016-100 n1_422794_404464 n1_422794_401120 0.011
R14-2017-100 n1_422794_407808 n1_422794_404464 0.011
R14-2018-100 n1_422794_411152 n1_422794_407808 0.011
R14-2019-100 n1_422794_414496 n1_422794_411152 0.011
R14-2020-100 n1_422794_417840 n1_422794_414496 0.011
R14-2021-100 n1_422794_421184 n1_422794_417840 0.011
R14-2022-100 n1_422794_421742 n1_422794_421184 0.0018355300000000001
R14-2023-100 n1_422794_424528 n1_422794_421742 0.00916447
R14-2024-100 n1_422794_427872 n1_422794_424528 0.011
R14-2025-100 n1_422794_431216 n1_422794_427872 0.011
R14-2026-100 n1_422794_434560 n1_422794_431216 0.011
R14-2027-100 n1_422794_437904 n1_422794_434560 0.011
R14-2028-100 n1_422794_441248 n1_422794_437904 0.011
R14-2029-100 n1_422794_444238 n1_422794_441248 0.00983553
R14-2030-100 n1_422794_444592 n1_422794_444238 0.00116447
R14-2031-100 n1_422794_447936 n1_422794_444592 0.011
R14-2032-100 n1_422794_451280 n1_422794_447936 0.011
R14-2033-100 n1_422794_454624 n1_422794_451280 0.011
R14-2034-100 n1_422794_457968 n1_422794_454624 0.011
R14-2035-100 n1_422794_461312 n1_422794_457968 0.011
R14-2036-100 n1_422794_464656 n1_422794_461312 0.011
R14-2037-100 n1_422794_466126 n1_422794_464656 0.004835529999999999
R14-2038-100 n1_422794_468000 n1_422794_466126 0.00616447
R14-2039-100 n1_422794_471344 n1_422794_468000 0.011
R14-2040-100 n1_422794_474688 n1_422794_471344 0.011
R14-2041-100 n1_422794_478032 n1_422794_474688 0.011
R14-2042-100 n1_422794_481376 n1_422794_478032 0.011
R14-2043-100 n1_422794_484720 n1_422794_481376 0.011
R14-2044-100 n1_422794_488064 n1_422794_484720 0.011
R14-2045-100 n1_422794_488622 n1_422794_488064 0.0018355300000000001
R14-2046-100 n1_422794_491408 n1_422794_488622 0.00916447
R14-2047-100 n1_422794_494752 n1_422794_491408 0.011
R14-2048-100 n1_422794_498096 n1_422794_494752 0.011
R14-2049-100 n1_422794_501440 n1_422794_498096 0.011
R14-2050-100 n1_422794_504784 n1_422794_501440 0.011
R14-2051-100 n1_422794_508128 n1_422794_504784 0.011
R14-2052-100 n1_422794_510510 n1_422794_508128 0.00783553
R14-2053-100 n1_422794_511472 n1_422794_510510 0.00316447
R14-2054-100 n1_422794_514816 n1_422794_511472 0.011
R14-2055-100 n1_422794_518160 n1_422794_514816 0.011
R14-2056-100 n1_422794_521504 n1_422794_518160 0.011
R14-2057-100 n1_422794_524848 n1_422794_521504 0.011
R14-2058-100 n1_422794_528192 n1_422794_524848 0.011
R14-2059-100 n1_422794_531536 n1_422794_528192 0.011
R14-2060-100 n1_422794_532398 n1_422794_531536 0.00283553
R14-2061-100 n1_422794_534880 n1_422794_532398 0.00816447
R14-2062-100 n1_422794_538224 n1_422794_534880 0.011
R14-2063-100 n1_422794_541568 n1_422794_538224 0.011
R14-2064-100 n1_422794_544912 n1_422794_541568 0.011
R14-2065-100 n1_422794_548256 n1_422794_544912 0.011
R14-2066-100 n1_422794_551600 n1_422794_548256 0.011
R14-2067-100 n1_422794_554894 n1_422794_551600 0.010835500000000001
R14-2068-100 n1_422794_554944 n1_422794_554894 0.000164474
R14-2069-100 n1_422794_558288 n1_422794_554944 0.011
R14-2070-100 n1_422794_561632 n1_422794_558288 0.011
R14-2071-100 n1_422794_564976 n1_422794_561632 0.011
R14-2072-100 n1_422794_568320 n1_422794_564976 0.011
R14-2073-100 n1_422794_571664 n1_422794_568320 0.011
R14-2074-100 n1_422794_575008 n1_422794_571664 0.011
R14-2075-100 n1_422794_576782 n1_422794_575008 0.00583553
R14-2076-100 n1_422794_578352 n1_422794_576782 0.00516447
R14-2077-100 n1_422794_581696 n1_422794_578352 0.011
R14-2078-100 n1_422794_585040 n1_422794_581696 0.011
R14-2079-100 n1_422794_588384 n1_422794_585040 0.011
R14-2080-100 n1_422794_591728 n1_422794_588384 0.011
R14-2081-100 n1_422794_595072 n1_422794_591728 0.011
R14-2082-100 n1_422794_598416 n1_422794_595072 0.011
R14-2083-100 n1_422794_599278 n1_422794_598416 0.00283553
R14-2084-100 n1_422794_601760 n1_422794_599278 0.00816447
R14-2085-100 n1_422794_605104 n1_422794_601760 0.011
R14-2086-100 n1_422794_608448 n1_422794_605104 0.011
R14-2087-100 n1_422794_611792 n1_422794_608448 0.011
R14-2088-100 n1_422794_615136 n1_422794_611792 0.011
R14-2089-100 n1_422794_618480 n1_422794_615136 0.011
R14-2090-100 n1_422794_624152 n1_422794_618480 0.018657899999999998
R14-2091-100 n1_422794_626152 n1_422794_624152 0.00657895
R14-2092-100 n1_400602_46000 n1_400602_44000 0.00657895
R14-2093-100 n1_400602_50000 n1_400602_46000 0.0131579
R14-2094-100 n1_400602_53344 n1_400602_50000 0.011
R14-2095-100 n1_400602_56688 n1_400602_53344 0.011
R14-2096-100 n1_400602_60032 n1_400602_56688 0.011
R14-2097-100 n1_400602_63376 n1_400602_60032 0.011
R14-2098-100 n1_400602_66720 n1_400602_63376 0.011
R14-2099-100 n1_400602_67278 n1_400602_66720 0.0018355300000000001
R14-2100-100 n1_400602_70064 n1_400602_67278 0.00916447
R14-2101-100 n1_400602_73408 n1_400602_70064 0.011
R14-2102-100 n1_400602_76752 n1_400602_73408 0.011
R14-2103-100 n1_400602_80096 n1_400602_76752 0.011
R14-2104-100 n1_400602_83440 n1_400602_80096 0.011
R14-2105-100 n1_400602_86784 n1_400602_83440 0.011
R14-2106-100 n1_400602_89166 n1_400602_86784 0.00783553
R14-2107-100 n1_400602_90128 n1_400602_89166 0.00316447
R14-2108-100 n1_400602_93472 n1_400602_90128 0.011
R14-2109-100 n1_400602_96816 n1_400602_93472 0.011
R14-2110-100 n1_400602_100160 n1_400602_96816 0.011
R14-2111-100 n1_400602_103504 n1_400602_100160 0.011
R14-2112-100 n1_400602_106848 n1_400602_103504 0.011
R14-2113-100 n1_400602_110192 n1_400602_106848 0.011
R14-2114-100 n1_400602_111662 n1_400602_110192 0.004835529999999999
R14-2115-100 n1_400602_113536 n1_400602_111662 0.00616447
R14-2116-100 n1_400602_116880 n1_400602_113536 0.011
R14-2117-100 n1_400602_120224 n1_400602_116880 0.011
R14-2118-100 n1_400602_123568 n1_400602_120224 0.011
R14-2119-100 n1_400602_126912 n1_400602_123568 0.011
R14-2120-100 n1_400602_130256 n1_400602_126912 0.011
R14-2121-100 n1_400602_133550 n1_400602_130256 0.010835500000000001
R14-2122-100 n1_400602_133600 n1_400602_133550 0.000164474
R14-2123-100 n1_400602_136944 n1_400602_133600 0.011
R14-2124-100 n1_400602_140288 n1_400602_136944 0.011
R14-2125-100 n1_400602_143632 n1_400602_140288 0.011
R14-2126-100 n1_400602_146976 n1_400602_143632 0.011
R14-2127-100 n1_400602_150320 n1_400602_146976 0.011
R14-2128-100 n1_400602_153664 n1_400602_150320 0.011
R14-2129-100 n1_400602_156046 n1_400602_153664 0.00783553
R14-2130-100 n1_400602_157008 n1_400602_156046 0.00316447
R14-2131-100 n1_400602_160352 n1_400602_157008 0.011
R14-2132-100 n1_400602_163696 n1_400602_160352 0.011
R14-2133-100 n1_400602_167040 n1_400602_163696 0.011
R14-2134-100 n1_400602_170384 n1_400602_167040 0.011
R14-2135-100 n1_400602_173728 n1_400602_170384 0.011
R14-2136-100 n1_400602_177072 n1_400602_173728 0.011
R14-2137-100 n1_400602_177934 n1_400602_177072 0.00283553
R14-2138-100 n1_400602_180416 n1_400602_177934 0.00816447
R14-2139-100 n1_400602_183760 n1_400602_180416 0.011
R14-2140-100 n1_400602_187104 n1_400602_183760 0.011
R14-2141-100 n1_400602_190448 n1_400602_187104 0.011
R14-2142-100 n1_400602_193792 n1_400602_190448 0.011
R14-2143-100 n1_400602_197136 n1_400602_193792 0.011
R14-2144-100 n1_400602_200430 n1_400602_197136 0.010835500000000001
R14-2145-100 n1_400602_200480 n1_400602_200430 0.000164474
R14-2146-100 n1_400602_203824 n1_400602_200480 0.011
R14-2147-100 n1_400602_207168 n1_400602_203824 0.011
R14-2148-100 n1_400602_210512 n1_400602_207168 0.011
R14-2149-100 n1_400602_213856 n1_400602_210512 0.011
R14-2150-100 n1_400602_217200 n1_400602_213856 0.011
R14-2151-100 n1_400602_220544 n1_400602_217200 0.011
R14-2152-100 n1_400602_222318 n1_400602_220544 0.00583553
R14-2153-100 n1_400602_223888 n1_400602_222318 0.00516447
R14-2154-100 n1_400602_227232 n1_400602_223888 0.011
R14-2155-100 n1_400602_230576 n1_400602_227232 0.011
R14-2156-100 n1_400602_233920 n1_400602_230576 0.011
R14-2157-100 n1_400602_237264 n1_400602_233920 0.011
R14-2158-100 n1_400602_240608 n1_400602_237264 0.011
R14-2159-100 n1_400602_243952 n1_400602_240608 0.011
R14-2160-100 n1_400602_244814 n1_400602_243952 0.00283553
R14-2161-100 n1_400602_247296 n1_400602_244814 0.00816447
R14-2162-100 n1_400602_250640 n1_400602_247296 0.011
R14-2163-100 n1_400602_253984 n1_400602_250640 0.011
R14-2164-100 n1_400602_257328 n1_400602_253984 0.011
R14-2165-100 n1_400602_260672 n1_400602_257328 0.011
R14-2166-100 n1_400602_264016 n1_400602_260672 0.011
R14-2167-100 n1_400602_266702 n1_400602_264016 0.00883553
R14-2168-100 n1_400602_267360 n1_400602_266702 0.00216447
R14-2169-100 n1_400602_270704 n1_400602_267360 0.011
R14-2170-100 n1_400602_274048 n1_400602_270704 0.011
R14-2171-100 n1_400602_277392 n1_400602_274048 0.011
R14-2172-100 n1_400602_280736 n1_400602_277392 0.011
R14-2173-100 n1_400602_284080 n1_400602_280736 0.011
R14-2174-100 n1_400602_287424 n1_400602_284080 0.011
R14-2175-100 n1_400602_288590 n1_400602_287424 0.00383553
R14-2176-100 n1_400602_290768 n1_400602_288590 0.007164470000000001
R14-2177-100 n1_400602_294112 n1_400602_290768 0.011
R14-2178-100 n1_400602_297456 n1_400602_294112 0.011
R14-2179-100 n1_400602_300800 n1_400602_297456 0.011
R14-2180-100 n1_400602_304144 n1_400602_300800 0.011
R14-2181-100 n1_400602_307488 n1_400602_304144 0.011
R14-2182-100 n1_400602_310832 n1_400602_307488 0.011
R14-2183-100 n1_400602_311086 n1_400602_310832 0.000835526
R14-2184-100 n1_400602_314176 n1_400602_311086 0.0101645
R14-2185-100 n1_400602_317520 n1_400602_314176 0.011
R14-2186-100 n1_400602_320864 n1_400602_317520 0.011
R14-2187-100 n1_400602_324208 n1_400602_320864 0.011
R14-2188-100 n1_400602_327552 n1_400602_324208 0.011
R14-2189-100 n1_400602_330896 n1_400602_327552 0.011
R14-2190-100 n1_400602_332974 n1_400602_330896 0.006835529999999999
R14-2191-100 n1_400602_334240 n1_400602_332974 0.00416447
R14-2192-100 n1_400602_337584 n1_400602_334240 0.011
R14-2193-100 n1_400602_340928 n1_400602_337584 0.011
R14-2194-100 n1_400602_344272 n1_400602_340928 0.011
R14-2195-100 n1_400602_347616 n1_400602_344272 0.011
R14-2196-100 n1_400602_350960 n1_400602_347616 0.011
R14-2197-100 n1_400602_354304 n1_400602_350960 0.011
R14-2198-100 n1_400602_355470 n1_400602_354304 0.00383553
R14-2199-100 n1_400602_357648 n1_400602_355470 0.007164470000000001
R14-2200-100 n1_400602_360992 n1_400602_357648 0.011
R14-2201-100 n1_400602_364336 n1_400602_360992 0.011
R14-2202-100 n1_400602_367680 n1_400602_364336 0.011
R14-2203-100 n1_400602_371024 n1_400602_367680 0.011
R14-2204-100 n1_400602_374368 n1_400602_371024 0.011
R14-2205-100 n1_400602_377358 n1_400602_374368 0.00983553
R14-2206-100 n1_400602_377712 n1_400602_377358 0.00116447
R14-2207-100 n1_400602_381056 n1_400602_377712 0.011
R14-2208-100 n1_400602_384400 n1_400602_381056 0.011
R14-2209-100 n1_400602_387744 n1_400602_384400 0.011
R14-2210-100 n1_400602_391088 n1_400602_387744 0.011
R14-2211-100 n1_400602_394432 n1_400602_391088 0.011
R14-2212-100 n1_400602_397776 n1_400602_394432 0.011
R14-2213-100 n1_400602_399854 n1_400602_397776 0.006835529999999999
R14-2214-100 n1_400602_401120 n1_400602_399854 0.00416447
R14-2215-100 n1_400602_404464 n1_400602_401120 0.011
R14-2216-100 n1_400602_407808 n1_400602_404464 0.011
R14-2217-100 n1_400602_411152 n1_400602_407808 0.011
R14-2218-100 n1_400602_414496 n1_400602_411152 0.011
R14-2219-100 n1_400602_417840 n1_400602_414496 0.011
R14-2220-100 n1_400602_421184 n1_400602_417840 0.011
R14-2221-100 n1_400602_421742 n1_400602_421184 0.0018355300000000001
R14-2222-100 n1_400602_424528 n1_400602_421742 0.00916447
R14-2223-100 n1_400602_427872 n1_400602_424528 0.011
R14-2224-100 n1_400602_431216 n1_400602_427872 0.011
R14-2225-100 n1_400602_434560 n1_400602_431216 0.011
R14-2226-100 n1_400602_437904 n1_400602_434560 0.011
R14-2227-100 n1_400602_441248 n1_400602_437904 0.011
R14-2228-100 n1_400602_444238 n1_400602_441248 0.00983553
R14-2229-100 n1_400602_444592 n1_400602_444238 0.00116447
R14-2230-100 n1_400602_447936 n1_400602_444592 0.011
R14-2231-100 n1_400602_451280 n1_400602_447936 0.011
R14-2232-100 n1_400602_454624 n1_400602_451280 0.011
R14-2233-100 n1_400602_457968 n1_400602_454624 0.011
R14-2234-100 n1_400602_461312 n1_400602_457968 0.011
R14-2235-100 n1_400602_464656 n1_400602_461312 0.011
R14-2236-100 n1_400602_466126 n1_400602_464656 0.004835529999999999
R14-2237-100 n1_400602_468000 n1_400602_466126 0.00616447
R14-2238-100 n1_400602_471344 n1_400602_468000 0.011
R14-2239-100 n1_400602_474688 n1_400602_471344 0.011
R14-2240-100 n1_400602_478032 n1_400602_474688 0.011
R14-2241-100 n1_400602_481376 n1_400602_478032 0.011
R14-2242-100 n1_400602_484720 n1_400602_481376 0.011
R14-2243-100 n1_400602_488064 n1_400602_484720 0.011
R14-2244-100 n1_400602_488622 n1_400602_488064 0.0018355300000000001
R14-2245-100 n1_400602_491408 n1_400602_488622 0.00916447
R14-2246-100 n1_400602_494752 n1_400602_491408 0.011
R14-2247-100 n1_400602_498096 n1_400602_494752 0.011
R14-2248-100 n1_400602_501440 n1_400602_498096 0.011
R14-2249-100 n1_400602_504784 n1_400602_501440 0.011
R14-2250-100 n1_400602_508128 n1_400602_504784 0.011
R14-2251-100 n1_400602_510510 n1_400602_508128 0.00783553
R14-2252-100 n1_400602_511472 n1_400602_510510 0.00316447
R14-2253-100 n1_400602_514816 n1_400602_511472 0.011
R14-2254-100 n1_400602_518160 n1_400602_514816 0.011
R14-2255-100 n1_400602_521504 n1_400602_518160 0.011
R14-2256-100 n1_400602_524848 n1_400602_521504 0.011
R14-2257-100 n1_400602_528192 n1_400602_524848 0.011
R14-2258-100 n1_400602_531536 n1_400602_528192 0.011
R14-2259-100 n1_400602_532398 n1_400602_531536 0.00283553
R14-2260-100 n1_400602_534880 n1_400602_532398 0.00816447
R14-2261-100 n1_400602_538224 n1_400602_534880 0.011
R14-2262-100 n1_400602_541568 n1_400602_538224 0.011
R14-2263-100 n1_400602_544912 n1_400602_541568 0.011
R14-2264-100 n1_400602_548256 n1_400602_544912 0.011
R14-2265-100 n1_400602_551600 n1_400602_548256 0.011
R14-2266-100 n1_400602_554894 n1_400602_551600 0.010835500000000001
R14-2267-100 n1_400602_554944 n1_400602_554894 0.000164474
R14-2268-100 n1_400602_558288 n1_400602_554944 0.011
R14-2269-100 n1_400602_561632 n1_400602_558288 0.011
R14-2270-100 n1_400602_564976 n1_400602_561632 0.011
R14-2271-100 n1_400602_568320 n1_400602_564976 0.011
R14-2272-100 n1_400602_571664 n1_400602_568320 0.011
R14-2273-100 n1_400602_575008 n1_400602_571664 0.011
R14-2274-100 n1_400602_576782 n1_400602_575008 0.00583553
R14-2275-100 n1_400602_578352 n1_400602_576782 0.00516447
R14-2276-100 n1_400602_581696 n1_400602_578352 0.011
R14-2277-100 n1_400602_585040 n1_400602_581696 0.011
R14-2278-100 n1_400602_588384 n1_400602_585040 0.011
R14-2279-100 n1_400602_591728 n1_400602_588384 0.011
R14-2280-100 n1_400602_595072 n1_400602_591728 0.011
R14-2281-100 n1_400602_598416 n1_400602_595072 0.011
R14-2282-100 n1_400602_599278 n1_400602_598416 0.00283553
R14-2283-100 n1_400602_601760 n1_400602_599278 0.00816447
R14-2284-100 n1_400602_605104 n1_400602_601760 0.011
R14-2285-100 n1_400602_608448 n1_400602_605104 0.011
R14-2286-100 n1_400602_611792 n1_400602_608448 0.011
R14-2287-100 n1_400602_615136 n1_400602_611792 0.011
R14-2288-100 n1_400602_618480 n1_400602_615136 0.011
R14-2289-100 n1_400602_624152 n1_400602_618480 0.018657899999999998
R14-2290-100 n1_400602_626152 n1_400602_624152 0.00657895
R14-2291-100 n1_378410_46000 n1_378410_44000 0.00657895
R14-2292-100 n1_378410_50000 n1_378410_46000 0.0131579
R14-2293-100 n1_378410_53344 n1_378410_50000 0.011
R14-2294-100 n1_378410_56688 n1_378410_53344 0.011
R14-2295-100 n1_378410_60032 n1_378410_56688 0.011
R14-2296-100 n1_378410_63376 n1_378410_60032 0.011
R14-2297-100 n1_378410_66720 n1_378410_63376 0.011
R14-2298-100 n1_378410_67278 n1_378410_66720 0.0018355300000000001
R14-2299-100 n1_378410_70064 n1_378410_67278 0.00916447
R14-2300-100 n1_378410_73408 n1_378410_70064 0.011
R14-2301-100 n1_378410_76752 n1_378410_73408 0.011
R14-2302-100 n1_378410_80096 n1_378410_76752 0.011
R14-2303-100 n1_378410_83440 n1_378410_80096 0.011
R14-2304-100 n1_378410_86784 n1_378410_83440 0.011
R14-2305-100 n1_378410_89166 n1_378410_86784 0.00783553
R14-2306-100 n1_378410_90128 n1_378410_89166 0.00316447
R14-2307-100 n1_378410_93472 n1_378410_90128 0.011
R14-2308-100 n1_378410_96816 n1_378410_93472 0.011
R14-2309-100 n1_378410_100160 n1_378410_96816 0.011
R14-2310-100 n1_378410_103504 n1_378410_100160 0.011
R14-2311-100 n1_378410_106848 n1_378410_103504 0.011
R14-2312-100 n1_378410_110192 n1_378410_106848 0.011
R14-2313-100 n1_378410_111662 n1_378410_110192 0.004835529999999999
R14-2314-100 n1_378410_113536 n1_378410_111662 0.00616447
R14-2315-100 n1_378410_116880 n1_378410_113536 0.011
R14-2316-100 n1_378410_120224 n1_378410_116880 0.011
R14-2317-100 n1_378410_123568 n1_378410_120224 0.011
R14-2318-100 n1_378410_126912 n1_378410_123568 0.011
R14-2319-100 n1_378410_130256 n1_378410_126912 0.011
R14-2320-100 n1_378410_133550 n1_378410_130256 0.010835500000000001
R14-2321-100 n1_378410_133600 n1_378410_133550 0.000164474
R14-2322-100 n1_378410_136944 n1_378410_133600 0.011
R14-2323-100 n1_378410_140288 n1_378410_136944 0.011
R14-2324-100 n1_378410_143632 n1_378410_140288 0.011
R14-2325-100 n1_378410_146976 n1_378410_143632 0.011
R14-2326-100 n1_378410_150320 n1_378410_146976 0.011
R14-2327-100 n1_378410_153664 n1_378410_150320 0.011
R14-2328-100 n1_378410_156046 n1_378410_153664 0.00783553
R14-2329-100 n1_378410_157008 n1_378410_156046 0.00316447
R14-2330-100 n1_378410_160352 n1_378410_157008 0.011
R14-2331-100 n1_378410_163696 n1_378410_160352 0.011
R14-2332-100 n1_378410_167040 n1_378410_163696 0.011
R14-2333-100 n1_378410_170384 n1_378410_167040 0.011
R14-2334-100 n1_378410_173728 n1_378410_170384 0.011
R14-2335-100 n1_378410_177072 n1_378410_173728 0.011
R14-2336-100 n1_378410_177934 n1_378410_177072 0.00283553
R14-2337-100 n1_378410_180416 n1_378410_177934 0.00816447
R14-2338-100 n1_378410_183760 n1_378410_180416 0.011
R14-2339-100 n1_378410_187104 n1_378410_183760 0.011
R14-2340-100 n1_378410_190448 n1_378410_187104 0.011
R14-2341-100 n1_378410_193792 n1_378410_190448 0.011
R14-2342-100 n1_378410_197136 n1_378410_193792 0.011
R14-2343-100 n1_378410_200430 n1_378410_197136 0.010835500000000001
R14-2344-100 n1_378410_200480 n1_378410_200430 0.000164474
R14-2345-100 n1_378410_203824 n1_378410_200480 0.011
R14-2346-100 n1_378410_207168 n1_378410_203824 0.011
R14-2347-100 n1_378410_210512 n1_378410_207168 0.011
R14-2348-100 n1_378410_213856 n1_378410_210512 0.011
R14-2349-100 n1_378410_217200 n1_378410_213856 0.011
R14-2350-100 n1_378410_220544 n1_378410_217200 0.011
R14-2351-100 n1_378410_222318 n1_378410_220544 0.00583553
R14-2352-100 n1_378410_223888 n1_378410_222318 0.00516447
R14-2353-100 n1_378410_227232 n1_378410_223888 0.011
R14-2354-100 n1_378410_230576 n1_378410_227232 0.011
R14-2355-100 n1_378410_233920 n1_378410_230576 0.011
R14-2356-100 n1_378410_237264 n1_378410_233920 0.011
R14-2357-100 n1_378410_240608 n1_378410_237264 0.011
R14-2358-100 n1_378410_243952 n1_378410_240608 0.011
R14-2359-100 n1_378410_244814 n1_378410_243952 0.00283553
R14-2360-100 n1_378410_247296 n1_378410_244814 0.00816447
R14-2361-100 n1_378410_250640 n1_378410_247296 0.011
R14-2362-100 n1_378410_253984 n1_378410_250640 0.011
R14-2363-100 n1_378410_257328 n1_378410_253984 0.011
R14-2364-100 n1_378410_260672 n1_378410_257328 0.011
R14-2365-100 n1_378410_264016 n1_378410_260672 0.011
R14-2366-100 n1_378410_266702 n1_378410_264016 0.00883553
R14-2367-100 n1_378410_267360 n1_378410_266702 0.00216447
R14-2368-100 n1_378410_270704 n1_378410_267360 0.011
R14-2369-100 n1_378410_274048 n1_378410_270704 0.011
R14-2370-100 n1_378410_277392 n1_378410_274048 0.011
R14-2371-100 n1_378410_280736 n1_378410_277392 0.011
R14-2372-100 n1_378410_284080 n1_378410_280736 0.011
R14-2373-100 n1_378410_287424 n1_378410_284080 0.011
R14-2374-100 n1_378410_288590 n1_378410_287424 0.00383553
R14-2375-100 n1_378410_290768 n1_378410_288590 0.007164470000000001
R14-2376-100 n1_378410_294112 n1_378410_290768 0.011
R14-2377-100 n1_378410_297456 n1_378410_294112 0.011
R14-2378-100 n1_378410_300800 n1_378410_297456 0.011
R14-2379-100 n1_378410_304144 n1_378410_300800 0.011
R14-2380-100 n1_378410_307488 n1_378410_304144 0.011
R14-2381-100 n1_378410_310832 n1_378410_307488 0.011
R14-2382-100 n1_378410_311086 n1_378410_310832 0.000835526
R14-2383-100 n1_378410_314176 n1_378410_311086 0.0101645
R14-2384-100 n1_378410_317520 n1_378410_314176 0.011
R14-2385-100 n1_378410_320864 n1_378410_317520 0.011
R14-2386-100 n1_378410_324208 n1_378410_320864 0.011
R14-2387-100 n1_378410_327552 n1_378410_324208 0.011
R14-2388-100 n1_378410_330896 n1_378410_327552 0.011
R14-2389-100 n1_378410_332974 n1_378410_330896 0.006835529999999999
R14-2390-100 n1_378410_334240 n1_378410_332974 0.00416447
R14-2391-100 n1_378410_337584 n1_378410_334240 0.011
R14-2392-100 n1_378410_340928 n1_378410_337584 0.011
R14-2393-100 n1_378410_344272 n1_378410_340928 0.011
R14-2394-100 n1_378410_347616 n1_378410_344272 0.011
R14-2395-100 n1_378410_350960 n1_378410_347616 0.011
R14-2396-100 n1_378410_354304 n1_378410_350960 0.011
R14-2397-100 n1_378410_355470 n1_378410_354304 0.00383553
R14-2398-100 n1_378410_357648 n1_378410_355470 0.007164470000000001
R14-2399-100 n1_378410_360992 n1_378410_357648 0.011
R14-2400-100 n1_378410_364336 n1_378410_360992 0.011
R14-2401-100 n1_378410_367680 n1_378410_364336 0.011
R14-2402-100 n1_378410_371024 n1_378410_367680 0.011
R14-2403-100 n1_378410_374368 n1_378410_371024 0.011
R14-2404-100 n1_378410_377358 n1_378410_374368 0.00983553
R14-2405-100 n1_378410_377712 n1_378410_377358 0.00116447
R14-2406-100 n1_378410_381056 n1_378410_377712 0.011
R14-2407-100 n1_378410_384400 n1_378410_381056 0.011
R14-2408-100 n1_378410_387744 n1_378410_384400 0.011
R14-2409-100 n1_378410_391088 n1_378410_387744 0.011
R14-2410-100 n1_378410_394432 n1_378410_391088 0.011
R14-2411-100 n1_378410_397776 n1_378410_394432 0.011
R14-2412-100 n1_378410_399854 n1_378410_397776 0.006835529999999999
R14-2413-100 n1_378410_401120 n1_378410_399854 0.00416447
R14-2414-100 n1_378410_404464 n1_378410_401120 0.011
R14-2415-100 n1_378410_407808 n1_378410_404464 0.011
R14-2416-100 n1_378410_411152 n1_378410_407808 0.011
R14-2417-100 n1_378410_414496 n1_378410_411152 0.011
R14-2418-100 n1_378410_417840 n1_378410_414496 0.011
R14-2419-100 n1_378410_421184 n1_378410_417840 0.011
R14-2420-100 n1_378410_421742 n1_378410_421184 0.0018355300000000001
R14-2421-100 n1_378410_424528 n1_378410_421742 0.00916447
R14-2422-100 n1_378410_427872 n1_378410_424528 0.011
R14-2423-100 n1_378410_431216 n1_378410_427872 0.011
R14-2424-100 n1_378410_434560 n1_378410_431216 0.011
R14-2425-100 n1_378410_437904 n1_378410_434560 0.011
R14-2426-100 n1_378410_441248 n1_378410_437904 0.011
R14-2427-100 n1_378410_444238 n1_378410_441248 0.00983553
R14-2428-100 n1_378410_444592 n1_378410_444238 0.00116447
R14-2429-100 n1_378410_447936 n1_378410_444592 0.011
R14-2430-100 n1_378410_451280 n1_378410_447936 0.011
R14-2431-100 n1_378410_454624 n1_378410_451280 0.011
R14-2432-100 n1_378410_457968 n1_378410_454624 0.011
R14-2433-100 n1_378410_461312 n1_378410_457968 0.011
R14-2434-100 n1_378410_464656 n1_378410_461312 0.011
R14-2435-100 n1_378410_466126 n1_378410_464656 0.004835529999999999
R14-2436-100 n1_378410_468000 n1_378410_466126 0.00616447
R14-2437-100 n1_378410_471344 n1_378410_468000 0.011
R14-2438-100 n1_378410_474688 n1_378410_471344 0.011
R14-2439-100 n1_378410_478032 n1_378410_474688 0.011
R14-2440-100 n1_378410_481376 n1_378410_478032 0.011
R14-2441-100 n1_378410_484720 n1_378410_481376 0.011
R14-2442-100 n1_378410_488064 n1_378410_484720 0.011
R14-2443-100 n1_378410_488622 n1_378410_488064 0.0018355300000000001
R14-2444-100 n1_378410_491408 n1_378410_488622 0.00916447
R14-2445-100 n1_378410_494752 n1_378410_491408 0.011
R14-2446-100 n1_378410_498096 n1_378410_494752 0.011
R14-2447-100 n1_378410_501440 n1_378410_498096 0.011
R14-2448-100 n1_378410_504784 n1_378410_501440 0.011
R14-2449-100 n1_378410_508128 n1_378410_504784 0.011
R14-2450-100 n1_378410_510510 n1_378410_508128 0.00783553
R14-2451-100 n1_378410_511472 n1_378410_510510 0.00316447
R14-2452-100 n1_378410_514816 n1_378410_511472 0.011
R14-2453-100 n1_378410_518160 n1_378410_514816 0.011
R14-2454-100 n1_378410_521504 n1_378410_518160 0.011
R14-2455-100 n1_378410_524848 n1_378410_521504 0.011
R14-2456-100 n1_378410_528192 n1_378410_524848 0.011
R14-2457-100 n1_378410_531536 n1_378410_528192 0.011
R14-2458-100 n1_378410_532398 n1_378410_531536 0.00283553
R14-2459-100 n1_378410_534880 n1_378410_532398 0.00816447
R14-2460-100 n1_378410_538224 n1_378410_534880 0.011
R14-2461-100 n1_378410_541568 n1_378410_538224 0.011
R14-2462-100 n1_378410_544912 n1_378410_541568 0.011
R14-2463-100 n1_378410_548256 n1_378410_544912 0.011
R14-2464-100 n1_378410_551600 n1_378410_548256 0.011
R14-2465-100 n1_378410_554894 n1_378410_551600 0.010835500000000001
R14-2466-100 n1_378410_554944 n1_378410_554894 0.000164474
R14-2467-100 n1_378410_558288 n1_378410_554944 0.011
R14-2468-100 n1_378410_561632 n1_378410_558288 0.011
R14-2469-100 n1_378410_564976 n1_378410_561632 0.011
R14-2470-100 n1_378410_568320 n1_378410_564976 0.011
R14-2471-100 n1_378410_571664 n1_378410_568320 0.011
R14-2472-100 n1_378410_575008 n1_378410_571664 0.011
R14-2473-100 n1_378410_576782 n1_378410_575008 0.00583553
R14-2474-100 n1_378410_578352 n1_378410_576782 0.00516447
R14-2475-100 n1_378410_581696 n1_378410_578352 0.011
R14-2476-100 n1_378410_585040 n1_378410_581696 0.011
R14-2477-100 n1_378410_588384 n1_378410_585040 0.011
R14-2478-100 n1_378410_591728 n1_378410_588384 0.011
R14-2479-100 n1_378410_595072 n1_378410_591728 0.011
R14-2480-100 n1_378410_598416 n1_378410_595072 0.011
R14-2481-100 n1_378410_599278 n1_378410_598416 0.00283553
R14-2482-100 n1_378410_601760 n1_378410_599278 0.00816447
R14-2483-100 n1_378410_605104 n1_378410_601760 0.011
R14-2484-100 n1_378410_608448 n1_378410_605104 0.011
R14-2485-100 n1_378410_611792 n1_378410_608448 0.011
R14-2486-100 n1_378410_615136 n1_378410_611792 0.011
R14-2487-100 n1_378410_618480 n1_378410_615136 0.011
R14-2488-100 n1_378410_624152 n1_378410_618480 0.018657899999999998
R14-2489-100 n1_378410_626152 n1_378410_624152 0.00657895
R14-2490-100 n1_355914_46000 n1_355914_44000 0.00657895
R14-2491-100 n1_355914_50000 n1_355914_46000 0.0131579
R14-2492-100 n1_355914_53344 n1_355914_50000 0.011
R14-2493-100 n1_355914_56688 n1_355914_53344 0.011
R14-2494-100 n1_355914_60032 n1_355914_56688 0.011
R14-2495-100 n1_355914_63376 n1_355914_60032 0.011
R14-2496-100 n1_355914_66720 n1_355914_63376 0.011
R14-2497-100 n1_355914_67278 n1_355914_66720 0.0018355300000000001
R14-2498-100 n1_355914_70064 n1_355914_67278 0.00916447
R14-2499-100 n1_355914_73408 n1_355914_70064 0.011
R14-2500-100 n1_355914_76752 n1_355914_73408 0.011
R14-2501-100 n1_355914_80096 n1_355914_76752 0.011
R14-2502-100 n1_355914_83440 n1_355914_80096 0.011
R14-2503-100 n1_355914_86784 n1_355914_83440 0.011
R14-2504-100 n1_355914_89166 n1_355914_86784 0.00783553
R14-2505-100 n1_355914_90128 n1_355914_89166 0.00316447
R14-2506-100 n1_355914_93472 n1_355914_90128 0.011
R14-2507-100 n1_355914_96816 n1_355914_93472 0.011
R14-2508-100 n1_355914_100160 n1_355914_96816 0.011
R14-2509-100 n1_355914_103504 n1_355914_100160 0.011
R14-2510-100 n1_355914_106848 n1_355914_103504 0.011
R14-2511-100 n1_355914_110192 n1_355914_106848 0.011
R14-2512-100 n1_355914_111662 n1_355914_110192 0.004835529999999999
R14-2513-100 n1_355914_113536 n1_355914_111662 0.00616447
R14-2514-100 n1_355914_116880 n1_355914_113536 0.011
R14-2515-100 n1_355914_120224 n1_355914_116880 0.011
R14-2516-100 n1_355914_123568 n1_355914_120224 0.011
R14-2517-100 n1_355914_126912 n1_355914_123568 0.011
R14-2518-100 n1_355914_130256 n1_355914_126912 0.011
R14-2519-100 n1_355914_133550 n1_355914_130256 0.010835500000000001
R14-2520-100 n1_355914_133600 n1_355914_133550 0.000164474
R14-2521-100 n1_355914_136944 n1_355914_133600 0.011
R14-2522-100 n1_355914_140288 n1_355914_136944 0.011
R14-2523-100 n1_355914_143632 n1_355914_140288 0.011
R14-2524-100 n1_355914_146976 n1_355914_143632 0.011
R14-2525-100 n1_355914_150320 n1_355914_146976 0.011
R14-2526-100 n1_355914_153664 n1_355914_150320 0.011
R14-2527-100 n1_355914_156046 n1_355914_153664 0.00783553
R14-2528-100 n1_355914_157008 n1_355914_156046 0.00316447
R14-2529-100 n1_355914_160352 n1_355914_157008 0.011
R14-2530-100 n1_355914_163696 n1_355914_160352 0.011
R14-2531-100 n1_355914_167040 n1_355914_163696 0.011
R14-2532-100 n1_355914_170384 n1_355914_167040 0.011
R14-2533-100 n1_355914_173728 n1_355914_170384 0.011
R14-2534-100 n1_355914_177072 n1_355914_173728 0.011
R14-2535-100 n1_355914_177934 n1_355914_177072 0.00283553
R14-2536-100 n1_355914_180416 n1_355914_177934 0.00816447
R14-2537-100 n1_355914_183760 n1_355914_180416 0.011
R14-2538-100 n1_355914_187104 n1_355914_183760 0.011
R14-2539-100 n1_355914_190448 n1_355914_187104 0.011
R14-2540-100 n1_355914_193792 n1_355914_190448 0.011
R14-2541-100 n1_355914_197136 n1_355914_193792 0.011
R14-2542-100 n1_355914_200430 n1_355914_197136 0.010835500000000001
R14-2543-100 n1_355914_200480 n1_355914_200430 0.000164474
R14-2544-100 n1_355914_203824 n1_355914_200480 0.011
R14-2545-100 n1_355914_207168 n1_355914_203824 0.011
R14-2546-100 n1_355914_210512 n1_355914_207168 0.011
R14-2547-100 n1_355914_213856 n1_355914_210512 0.011
R14-2548-100 n1_355914_217200 n1_355914_213856 0.011
R14-2549-100 n1_355914_220544 n1_355914_217200 0.011
R14-2550-100 n1_355914_222318 n1_355914_220544 0.00583553
R14-2551-100 n1_355914_223888 n1_355914_222318 0.00516447
R14-2552-100 n1_355914_227232 n1_355914_223888 0.011
R14-2553-100 n1_355914_230576 n1_355914_227232 0.011
R14-2554-100 n1_355914_233920 n1_355914_230576 0.011
R14-2555-100 n1_355914_237264 n1_355914_233920 0.011
R14-2556-100 n1_355914_240608 n1_355914_237264 0.011
R14-2557-100 n1_355914_243952 n1_355914_240608 0.011
R14-2558-100 n1_355914_244814 n1_355914_243952 0.00283553
R14-2559-100 n1_355914_247296 n1_355914_244814 0.00816447
R14-2560-100 n1_355914_250640 n1_355914_247296 0.011
R14-2561-100 n1_355914_253984 n1_355914_250640 0.011
R14-2562-100 n1_355914_257328 n1_355914_253984 0.011
R14-2563-100 n1_355914_260672 n1_355914_257328 0.011
R14-2564-100 n1_355914_264016 n1_355914_260672 0.011
R14-2565-100 n1_355914_266702 n1_355914_264016 0.00883553
R14-2566-100 n1_355914_267360 n1_355914_266702 0.00216447
R14-2567-100 n1_355914_270704 n1_355914_267360 0.011
R14-2568-100 n1_355914_274048 n1_355914_270704 0.011
R14-2569-100 n1_355914_277392 n1_355914_274048 0.011
R14-2570-100 n1_355914_280736 n1_355914_277392 0.011
R14-2571-100 n1_355914_284080 n1_355914_280736 0.011
R14-2572-100 n1_355914_287424 n1_355914_284080 0.011
R14-2573-100 n1_355914_288590 n1_355914_287424 0.00383553
R14-2574-100 n1_355914_290768 n1_355914_288590 0.007164470000000001
R14-2575-100 n1_355914_294112 n1_355914_290768 0.011
R14-2576-100 n1_355914_297456 n1_355914_294112 0.011
R14-2577-100 n1_355914_300800 n1_355914_297456 0.011
R14-2578-100 n1_355914_304144 n1_355914_300800 0.011
R14-2579-100 n1_355914_307488 n1_355914_304144 0.011
R14-2580-100 n1_355914_310832 n1_355914_307488 0.011
R14-2581-100 n1_355914_311086 n1_355914_310832 0.000835526
R14-2582-100 n1_355914_314176 n1_355914_311086 0.0101645
R14-2583-100 n1_355914_317520 n1_355914_314176 0.011
R14-2584-100 n1_355914_320864 n1_355914_317520 0.011
R14-2585-100 n1_355914_324208 n1_355914_320864 0.011
R14-2586-100 n1_355914_327552 n1_355914_324208 0.011
R14-2587-100 n1_355914_330896 n1_355914_327552 0.011
R14-2588-100 n1_355914_332974 n1_355914_330896 0.006835529999999999
R14-2589-100 n1_355914_334240 n1_355914_332974 0.00416447
R14-2590-100 n1_355914_337584 n1_355914_334240 0.011
R14-2591-100 n1_355914_340928 n1_355914_337584 0.011
R14-2592-100 n1_355914_344272 n1_355914_340928 0.011
R14-2593-100 n1_355914_347616 n1_355914_344272 0.011
R14-2594-100 n1_355914_350960 n1_355914_347616 0.011
R14-2595-100 n1_355914_354304 n1_355914_350960 0.011
R14-2596-100 n1_355914_355470 n1_355914_354304 0.00383553
R14-2597-100 n1_355914_357648 n1_355914_355470 0.007164470000000001
R14-2598-100 n1_355914_360992 n1_355914_357648 0.011
R14-2599-100 n1_355914_364336 n1_355914_360992 0.011
R14-2600-100 n1_355914_367680 n1_355914_364336 0.011
R14-2601-100 n1_355914_371024 n1_355914_367680 0.011
R14-2602-100 n1_355914_374368 n1_355914_371024 0.011
R14-2603-100 n1_355914_377358 n1_355914_374368 0.00983553
R14-2604-100 n1_355914_377712 n1_355914_377358 0.00116447
R14-2605-100 n1_355914_381056 n1_355914_377712 0.011
R14-2606-100 n1_355914_384400 n1_355914_381056 0.011
R14-2607-100 n1_355914_387744 n1_355914_384400 0.011
R14-2608-100 n1_355914_391088 n1_355914_387744 0.011
R14-2609-100 n1_355914_394432 n1_355914_391088 0.011
R14-2610-100 n1_355914_397776 n1_355914_394432 0.011
R14-2611-100 n1_355914_399854 n1_355914_397776 0.006835529999999999
R14-2612-100 n1_355914_401120 n1_355914_399854 0.00416447
R14-2613-100 n1_355914_404464 n1_355914_401120 0.011
R14-2614-100 n1_355914_407808 n1_355914_404464 0.011
R14-2615-100 n1_355914_411152 n1_355914_407808 0.011
R14-2616-100 n1_355914_414496 n1_355914_411152 0.011
R14-2617-100 n1_355914_417840 n1_355914_414496 0.011
R14-2618-100 n1_355914_421184 n1_355914_417840 0.011
R14-2619-100 n1_355914_421742 n1_355914_421184 0.0018355300000000001
R14-2620-100 n1_355914_424528 n1_355914_421742 0.00916447
R14-2621-100 n1_355914_427872 n1_355914_424528 0.011
R14-2622-100 n1_355914_431216 n1_355914_427872 0.011
R14-2623-100 n1_355914_434560 n1_355914_431216 0.011
R14-2624-100 n1_355914_437904 n1_355914_434560 0.011
R14-2625-100 n1_355914_441248 n1_355914_437904 0.011
R14-2626-100 n1_355914_444238 n1_355914_441248 0.00983553
R14-2627-100 n1_355914_444592 n1_355914_444238 0.00116447
R14-2628-100 n1_355914_447936 n1_355914_444592 0.011
R14-2629-100 n1_355914_451280 n1_355914_447936 0.011
R14-2630-100 n1_355914_454624 n1_355914_451280 0.011
R14-2631-100 n1_355914_457968 n1_355914_454624 0.011
R14-2632-100 n1_355914_461312 n1_355914_457968 0.011
R14-2633-100 n1_355914_464656 n1_355914_461312 0.011
R14-2634-100 n1_355914_466126 n1_355914_464656 0.004835529999999999
R14-2635-100 n1_355914_468000 n1_355914_466126 0.00616447
R14-2636-100 n1_355914_471344 n1_355914_468000 0.011
R14-2637-100 n1_355914_474688 n1_355914_471344 0.011
R14-2638-100 n1_355914_478032 n1_355914_474688 0.011
R14-2639-100 n1_355914_481376 n1_355914_478032 0.011
R14-2640-100 n1_355914_484720 n1_355914_481376 0.011
R14-2641-100 n1_355914_488064 n1_355914_484720 0.011
R14-2642-100 n1_355914_488622 n1_355914_488064 0.0018355300000000001
R14-2643-100 n1_355914_491408 n1_355914_488622 0.00916447
R14-2644-100 n1_355914_494752 n1_355914_491408 0.011
R14-2645-100 n1_355914_498096 n1_355914_494752 0.011
R14-2646-100 n1_355914_501440 n1_355914_498096 0.011
R14-2647-100 n1_355914_504784 n1_355914_501440 0.011
R14-2648-100 n1_355914_508128 n1_355914_504784 0.011
R14-2649-100 n1_355914_510510 n1_355914_508128 0.00783553
R14-2650-100 n1_355914_511472 n1_355914_510510 0.00316447
R14-2651-100 n1_355914_514816 n1_355914_511472 0.011
R14-2652-100 n1_355914_518160 n1_355914_514816 0.011
R14-2653-100 n1_355914_521504 n1_355914_518160 0.011
R14-2654-100 n1_355914_524848 n1_355914_521504 0.011
R14-2655-100 n1_355914_528192 n1_355914_524848 0.011
R14-2656-100 n1_355914_531536 n1_355914_528192 0.011
R14-2657-100 n1_355914_532398 n1_355914_531536 0.00283553
R14-2658-100 n1_355914_534880 n1_355914_532398 0.00816447
R14-2659-100 n1_355914_538224 n1_355914_534880 0.011
R14-2660-100 n1_355914_541568 n1_355914_538224 0.011
R14-2661-100 n1_355914_544912 n1_355914_541568 0.011
R14-2662-100 n1_355914_548256 n1_355914_544912 0.011
R14-2663-100 n1_355914_551600 n1_355914_548256 0.011
R14-2664-100 n1_355914_554894 n1_355914_551600 0.010835500000000001
R14-2665-100 n1_355914_554944 n1_355914_554894 0.000164474
R14-2666-100 n1_355914_558288 n1_355914_554944 0.011
R14-2667-100 n1_355914_561632 n1_355914_558288 0.011
R14-2668-100 n1_355914_564976 n1_355914_561632 0.011
R14-2669-100 n1_355914_568320 n1_355914_564976 0.011
R14-2670-100 n1_355914_571664 n1_355914_568320 0.011
R14-2671-100 n1_355914_575008 n1_355914_571664 0.011
R14-2672-100 n1_355914_576782 n1_355914_575008 0.00583553
R14-2673-100 n1_355914_578352 n1_355914_576782 0.00516447
R14-2674-100 n1_355914_581696 n1_355914_578352 0.011
R14-2675-100 n1_355914_585040 n1_355914_581696 0.011
R14-2676-100 n1_355914_588384 n1_355914_585040 0.011
R14-2677-100 n1_355914_591728 n1_355914_588384 0.011
R14-2678-100 n1_355914_595072 n1_355914_591728 0.011
R14-2679-100 n1_355914_598416 n1_355914_595072 0.011
R14-2680-100 n1_355914_599278 n1_355914_598416 0.00283553
R14-2681-100 n1_355914_601760 n1_355914_599278 0.00816447
R14-2682-100 n1_355914_605104 n1_355914_601760 0.011
R14-2683-100 n1_355914_608448 n1_355914_605104 0.011
R14-2684-100 n1_355914_611792 n1_355914_608448 0.011
R14-2685-100 n1_355914_615136 n1_355914_611792 0.011
R14-2686-100 n1_355914_618480 n1_355914_615136 0.011
R14-2687-100 n1_355914_624152 n1_355914_618480 0.018657899999999998
R14-2688-100 n1_355914_626152 n1_355914_624152 0.00657895
R14-2689-100 n1_333722_46000 n1_333722_44000 0.00657895
R14-2690-100 n1_333722_50000 n1_333722_46000 0.0131579
R14-2691-100 n1_333722_53344 n1_333722_50000 0.011
R14-2692-100 n1_333722_56688 n1_333722_53344 0.011
R14-2693-100 n1_333722_60032 n1_333722_56688 0.011
R14-2694-100 n1_333722_63376 n1_333722_60032 0.011
R14-2695-100 n1_333722_66720 n1_333722_63376 0.011
R14-2696-100 n1_333722_67278 n1_333722_66720 0.0018355300000000001
R14-2697-100 n1_333722_70064 n1_333722_67278 0.00916447
R14-2698-100 n1_333722_73408 n1_333722_70064 0.011
R14-2699-100 n1_333722_76752 n1_333722_73408 0.011
R14-2700-100 n1_333722_80096 n1_333722_76752 0.011
R14-2701-100 n1_333722_83440 n1_333722_80096 0.011
R14-2702-100 n1_333722_86784 n1_333722_83440 0.011
R14-2703-100 n1_333722_89166 n1_333722_86784 0.00783553
R14-2704-100 n1_333722_90128 n1_333722_89166 0.00316447
R14-2705-100 n1_333722_93472 n1_333722_90128 0.011
R14-2706-100 n1_333722_96816 n1_333722_93472 0.011
R14-2707-100 n1_333722_100160 n1_333722_96816 0.011
R14-2708-100 n1_333722_103504 n1_333722_100160 0.011
R14-2709-100 n1_333722_106848 n1_333722_103504 0.011
R14-2710-100 n1_333722_110192 n1_333722_106848 0.011
R14-2711-100 n1_333722_111662 n1_333722_110192 0.004835529999999999
R14-2712-100 n1_333722_113536 n1_333722_111662 0.00616447
R14-2713-100 n1_333722_116880 n1_333722_113536 0.011
R14-2714-100 n1_333722_120224 n1_333722_116880 0.011
R14-2715-100 n1_333722_123568 n1_333722_120224 0.011
R14-2716-100 n1_333722_126912 n1_333722_123568 0.011
R14-2717-100 n1_333722_130256 n1_333722_126912 0.011
R14-2718-100 n1_333722_133550 n1_333722_130256 0.010835500000000001
R14-2719-100 n1_333722_133600 n1_333722_133550 0.000164474
R14-2720-100 n1_333722_136944 n1_333722_133600 0.011
R14-2721-100 n1_333722_140288 n1_333722_136944 0.011
R14-2722-100 n1_333722_143632 n1_333722_140288 0.011
R14-2723-100 n1_333722_146976 n1_333722_143632 0.011
R14-2724-100 n1_333722_150320 n1_333722_146976 0.011
R14-2725-100 n1_333722_153664 n1_333722_150320 0.011
R14-2726-100 n1_333722_156046 n1_333722_153664 0.00783553
R14-2727-100 n1_333722_157008 n1_333722_156046 0.00316447
R14-2728-100 n1_333722_160352 n1_333722_157008 0.011
R14-2729-100 n1_333722_163696 n1_333722_160352 0.011
R14-2730-100 n1_333722_167040 n1_333722_163696 0.011
R14-2731-100 n1_333722_170384 n1_333722_167040 0.011
R14-2732-100 n1_333722_173728 n1_333722_170384 0.011
R14-2733-100 n1_333722_177072 n1_333722_173728 0.011
R14-2734-100 n1_333722_177934 n1_333722_177072 0.00283553
R14-2735-100 n1_333722_180416 n1_333722_177934 0.00816447
R14-2736-100 n1_333722_183760 n1_333722_180416 0.011
R14-2737-100 n1_333722_187104 n1_333722_183760 0.011
R14-2738-100 n1_333722_190448 n1_333722_187104 0.011
R14-2739-100 n1_333722_193792 n1_333722_190448 0.011
R14-2740-100 n1_333722_197136 n1_333722_193792 0.011
R14-2741-100 n1_333722_200430 n1_333722_197136 0.010835500000000001
R14-2742-100 n1_333722_200480 n1_333722_200430 0.000164474
R14-2743-100 n1_333722_203824 n1_333722_200480 0.011
R14-2744-100 n1_333722_207168 n1_333722_203824 0.011
R14-2745-100 n1_333722_210512 n1_333722_207168 0.011
R14-2746-100 n1_333722_213856 n1_333722_210512 0.011
R14-2747-100 n1_333722_217200 n1_333722_213856 0.011
R14-2748-100 n1_333722_220544 n1_333722_217200 0.011
R14-2749-100 n1_333722_222318 n1_333722_220544 0.00583553
R14-2750-100 n1_333722_223888 n1_333722_222318 0.00516447
R14-2751-100 n1_333722_227232 n1_333722_223888 0.011
R14-2752-100 n1_333722_230576 n1_333722_227232 0.011
R14-2753-100 n1_333722_233920 n1_333722_230576 0.011
R14-2754-100 n1_333722_237264 n1_333722_233920 0.011
R14-2755-100 n1_333722_240608 n1_333722_237264 0.011
R14-2756-100 n1_333722_243952 n1_333722_240608 0.011
R14-2757-100 n1_333722_244814 n1_333722_243952 0.00283553
R14-2758-100 n1_333722_247296 n1_333722_244814 0.00816447
R14-2759-100 n1_333722_250640 n1_333722_247296 0.011
R14-2760-100 n1_333722_253984 n1_333722_250640 0.011
R14-2761-100 n1_333722_257328 n1_333722_253984 0.011
R14-2762-100 n1_333722_260672 n1_333722_257328 0.011
R14-2763-100 n1_333722_264016 n1_333722_260672 0.011
R14-2764-100 n1_333722_266702 n1_333722_264016 0.00883553
R14-2765-100 n1_333722_267360 n1_333722_266702 0.00216447
R14-2766-100 n1_333722_270704 n1_333722_267360 0.011
R14-2767-100 n1_333722_274048 n1_333722_270704 0.011
R14-2768-100 n1_333722_277392 n1_333722_274048 0.011
R14-2769-100 n1_333722_280736 n1_333722_277392 0.011
R14-2770-100 n1_333722_284080 n1_333722_280736 0.011
R14-2771-100 n1_333722_287424 n1_333722_284080 0.011
R14-2772-100 n1_333722_288590 n1_333722_287424 0.00383553
R14-2773-100 n1_333722_290768 n1_333722_288590 0.007164470000000001
R14-2774-100 n1_333722_294112 n1_333722_290768 0.011
R14-2775-100 n1_333722_297456 n1_333722_294112 0.011
R14-2776-100 n1_333722_300800 n1_333722_297456 0.011
R14-2777-100 n1_333722_304144 n1_333722_300800 0.011
R14-2778-100 n1_333722_307488 n1_333722_304144 0.011
R14-2779-100 n1_333722_310832 n1_333722_307488 0.011
R14-2780-100 n1_333722_311086 n1_333722_310832 0.000835526
R14-2781-100 n1_333722_314176 n1_333722_311086 0.0101645
R14-2782-100 n1_333722_317520 n1_333722_314176 0.011
R14-2783-100 n1_333722_320864 n1_333722_317520 0.011
R14-2784-100 n1_333722_324208 n1_333722_320864 0.011
R14-2785-100 n1_333722_327552 n1_333722_324208 0.011
R14-2786-100 n1_333722_330896 n1_333722_327552 0.011
R14-2787-100 n1_333722_332974 n1_333722_330896 0.006835529999999999
R14-2788-100 n1_333722_334240 n1_333722_332974 0.00416447
R14-2789-100 n1_333722_337584 n1_333722_334240 0.011
R14-2790-100 n1_333722_340928 n1_333722_337584 0.011
R14-2791-100 n1_333722_344272 n1_333722_340928 0.011
R14-2792-100 n1_333722_347616 n1_333722_344272 0.011
R14-2793-100 n1_333722_350960 n1_333722_347616 0.011
R14-2794-100 n1_333722_354304 n1_333722_350960 0.011
R14-2795-100 n1_333722_355470 n1_333722_354304 0.00383553
R14-2796-100 n1_333722_357648 n1_333722_355470 0.007164470000000001
R14-2797-100 n1_333722_360992 n1_333722_357648 0.011
R14-2798-100 n1_333722_364336 n1_333722_360992 0.011
R14-2799-100 n1_333722_367680 n1_333722_364336 0.011
R14-2800-100 n1_333722_371024 n1_333722_367680 0.011
R14-2801-100 n1_333722_374368 n1_333722_371024 0.011
R14-2802-100 n1_333722_377358 n1_333722_374368 0.00983553
R14-2803-100 n1_333722_377712 n1_333722_377358 0.00116447
R14-2804-100 n1_333722_381056 n1_333722_377712 0.011
R14-2805-100 n1_333722_384400 n1_333722_381056 0.011
R14-2806-100 n1_333722_387744 n1_333722_384400 0.011
R14-2807-100 n1_333722_391088 n1_333722_387744 0.011
R14-2808-100 n1_333722_394432 n1_333722_391088 0.011
R14-2809-100 n1_333722_397776 n1_333722_394432 0.011
R14-2810-100 n1_333722_399854 n1_333722_397776 0.006835529999999999
R14-2811-100 n1_333722_401120 n1_333722_399854 0.00416447
R14-2812-100 n1_333722_404464 n1_333722_401120 0.011
R14-2813-100 n1_333722_407808 n1_333722_404464 0.011
R14-2814-100 n1_333722_411152 n1_333722_407808 0.011
R14-2815-100 n1_333722_414496 n1_333722_411152 0.011
R14-2816-100 n1_333722_417840 n1_333722_414496 0.011
R14-2817-100 n1_333722_421184 n1_333722_417840 0.011
R14-2818-100 n1_333722_421742 n1_333722_421184 0.0018355300000000001
R14-2819-100 n1_333722_424528 n1_333722_421742 0.00916447
R14-2820-100 n1_333722_427872 n1_333722_424528 0.011
R14-2821-100 n1_333722_431216 n1_333722_427872 0.011
R14-2822-100 n1_333722_434560 n1_333722_431216 0.011
R14-2823-100 n1_333722_437904 n1_333722_434560 0.011
R14-2824-100 n1_333722_441248 n1_333722_437904 0.011
R14-2825-100 n1_333722_444238 n1_333722_441248 0.00983553
R14-2826-100 n1_333722_444592 n1_333722_444238 0.00116447
R14-2827-100 n1_333722_447936 n1_333722_444592 0.011
R14-2828-100 n1_333722_451280 n1_333722_447936 0.011
R14-2829-100 n1_333722_454624 n1_333722_451280 0.011
R14-2830-100 n1_333722_457968 n1_333722_454624 0.011
R14-2831-100 n1_333722_461312 n1_333722_457968 0.011
R14-2832-100 n1_333722_464656 n1_333722_461312 0.011
R14-2833-100 n1_333722_466126 n1_333722_464656 0.004835529999999999
R14-2834-100 n1_333722_468000 n1_333722_466126 0.00616447
R14-2835-100 n1_333722_471344 n1_333722_468000 0.011
R14-2836-100 n1_333722_474688 n1_333722_471344 0.011
R14-2837-100 n1_333722_478032 n1_333722_474688 0.011
R14-2838-100 n1_333722_481376 n1_333722_478032 0.011
R14-2839-100 n1_333722_484720 n1_333722_481376 0.011
R14-2840-100 n1_333722_488064 n1_333722_484720 0.011
R14-2841-100 n1_333722_488622 n1_333722_488064 0.0018355300000000001
R14-2842-100 n1_333722_491408 n1_333722_488622 0.00916447
R14-2843-100 n1_333722_494752 n1_333722_491408 0.011
R14-2844-100 n1_333722_498096 n1_333722_494752 0.011
R14-2845-100 n1_333722_501440 n1_333722_498096 0.011
R14-2846-100 n1_333722_504784 n1_333722_501440 0.011
R14-2847-100 n1_333722_508128 n1_333722_504784 0.011
R14-2848-100 n1_333722_510510 n1_333722_508128 0.00783553
R14-2849-100 n1_333722_511472 n1_333722_510510 0.00316447
R14-2850-100 n1_333722_514816 n1_333722_511472 0.011
R14-2851-100 n1_333722_518160 n1_333722_514816 0.011
R14-2852-100 n1_333722_521504 n1_333722_518160 0.011
R14-2853-100 n1_333722_524848 n1_333722_521504 0.011
R14-2854-100 n1_333722_528192 n1_333722_524848 0.011
R14-2855-100 n1_333722_531536 n1_333722_528192 0.011
R14-2856-100 n1_333722_532398 n1_333722_531536 0.00283553
R14-2857-100 n1_333722_534880 n1_333722_532398 0.00816447
R14-2858-100 n1_333722_538224 n1_333722_534880 0.011
R14-2859-100 n1_333722_541568 n1_333722_538224 0.011
R14-2860-100 n1_333722_544912 n1_333722_541568 0.011
R14-2861-100 n1_333722_548256 n1_333722_544912 0.011
R14-2862-100 n1_333722_551600 n1_333722_548256 0.011
R14-2863-100 n1_333722_554894 n1_333722_551600 0.010835500000000001
R14-2864-100 n1_333722_554944 n1_333722_554894 0.000164474
R14-2865-100 n1_333722_558288 n1_333722_554944 0.011
R14-2866-100 n1_333722_561632 n1_333722_558288 0.011
R14-2867-100 n1_333722_564976 n1_333722_561632 0.011
R14-2868-100 n1_333722_568320 n1_333722_564976 0.011
R14-2869-100 n1_333722_571664 n1_333722_568320 0.011
R14-2870-100 n1_333722_575008 n1_333722_571664 0.011
R14-2871-100 n1_333722_576782 n1_333722_575008 0.00583553
R14-2872-100 n1_333722_578352 n1_333722_576782 0.00516447
R14-2873-100 n1_333722_581696 n1_333722_578352 0.011
R14-2874-100 n1_333722_585040 n1_333722_581696 0.011
R14-2875-100 n1_333722_588384 n1_333722_585040 0.011
R14-2876-100 n1_333722_591728 n1_333722_588384 0.011
R14-2877-100 n1_333722_595072 n1_333722_591728 0.011
R14-2878-100 n1_333722_598416 n1_333722_595072 0.011
R14-2879-100 n1_333722_599278 n1_333722_598416 0.00283553
R14-2880-100 n1_333722_601760 n1_333722_599278 0.00816447
R14-2881-100 n1_333722_605104 n1_333722_601760 0.011
R14-2882-100 n1_333722_608448 n1_333722_605104 0.011
R14-2883-100 n1_333722_611792 n1_333722_608448 0.011
R14-2884-100 n1_333722_615136 n1_333722_611792 0.011
R14-2885-100 n1_333722_618480 n1_333722_615136 0.011
R14-2886-100 n1_333722_624152 n1_333722_618480 0.018657899999999998
R14-2887-100 n1_333722_626152 n1_333722_624152 0.00657895
R14-2888-100 n1_311226_46000 n1_311226_44000 0.00657895
R14-2889-100 n1_311226_50000 n1_311226_46000 0.0131579
R14-2890-100 n1_311226_53344 n1_311226_50000 0.011
R14-2891-100 n1_311226_56688 n1_311226_53344 0.011
R14-2892-100 n1_311226_60032 n1_311226_56688 0.011
R14-2893-100 n1_311226_63376 n1_311226_60032 0.011
R14-2894-100 n1_311226_66720 n1_311226_63376 0.011
R14-2895-100 n1_311226_67278 n1_311226_66720 0.0018355300000000001
R14-2896-100 n1_311226_70064 n1_311226_67278 0.00916447
R14-2897-100 n1_311226_73408 n1_311226_70064 0.011
R14-2898-100 n1_311226_76752 n1_311226_73408 0.011
R14-2899-100 n1_311226_80096 n1_311226_76752 0.011
R14-2900-100 n1_311226_83440 n1_311226_80096 0.011
R14-2901-100 n1_311226_86784 n1_311226_83440 0.011
R14-2902-100 n1_311226_89166 n1_311226_86784 0.00783553
R14-2903-100 n1_311226_90128 n1_311226_89166 0.00316447
R14-2904-100 n1_311226_93472 n1_311226_90128 0.011
R14-2905-100 n1_311226_96816 n1_311226_93472 0.011
R14-2906-100 n1_311226_100160 n1_311226_96816 0.011
R14-2907-100 n1_311226_103504 n1_311226_100160 0.011
R14-2908-100 n1_311226_106848 n1_311226_103504 0.011
R14-2909-100 n1_311226_110192 n1_311226_106848 0.011
R14-2910-100 n1_311226_111662 n1_311226_110192 0.004835529999999999
R14-2911-100 n1_311226_113536 n1_311226_111662 0.00616447
R14-2912-100 n1_311226_116880 n1_311226_113536 0.011
R14-2913-100 n1_311226_120224 n1_311226_116880 0.011
R14-2914-100 n1_311226_123568 n1_311226_120224 0.011
R14-2915-100 n1_311226_126912 n1_311226_123568 0.011
R14-2916-100 n1_311226_130256 n1_311226_126912 0.011
R14-2917-100 n1_311226_133550 n1_311226_130256 0.010835500000000001
R14-2918-100 n1_311226_133600 n1_311226_133550 0.000164474
R14-2919-100 n1_311226_136944 n1_311226_133600 0.011
R14-2920-100 n1_311226_140288 n1_311226_136944 0.011
R14-2921-100 n1_311226_143632 n1_311226_140288 0.011
R14-2922-100 n1_311226_146976 n1_311226_143632 0.011
R14-2923-100 n1_311226_150320 n1_311226_146976 0.011
R14-2924-100 n1_311226_153664 n1_311226_150320 0.011
R14-2925-100 n1_311226_156046 n1_311226_153664 0.00783553
R14-2926-100 n1_311226_157008 n1_311226_156046 0.00316447
R14-2927-100 n1_311226_160352 n1_311226_157008 0.011
R14-2928-100 n1_311226_163696 n1_311226_160352 0.011
R14-2929-100 n1_311226_167040 n1_311226_163696 0.011
R14-2930-100 n1_311226_170384 n1_311226_167040 0.011
R14-2931-100 n1_311226_173728 n1_311226_170384 0.011
R14-2932-100 n1_311226_177072 n1_311226_173728 0.011
R14-2933-100 n1_311226_177934 n1_311226_177072 0.00283553
R14-2934-100 n1_311226_180416 n1_311226_177934 0.00816447
R14-2935-100 n1_311226_183760 n1_311226_180416 0.011
R14-2936-100 n1_311226_187104 n1_311226_183760 0.011
R14-2937-100 n1_311226_190448 n1_311226_187104 0.011
R14-2938-100 n1_311226_193792 n1_311226_190448 0.011
R14-2939-100 n1_311226_197136 n1_311226_193792 0.011
R14-2940-100 n1_311226_200430 n1_311226_197136 0.010835500000000001
R14-2941-100 n1_311226_200480 n1_311226_200430 0.000164474
R14-2942-100 n1_311226_203824 n1_311226_200480 0.011
R14-2943-100 n1_311226_207168 n1_311226_203824 0.011
R14-2944-100 n1_311226_210512 n1_311226_207168 0.011
R14-2945-100 n1_311226_213856 n1_311226_210512 0.011
R14-2946-100 n1_311226_217200 n1_311226_213856 0.011
R14-2947-100 n1_311226_220544 n1_311226_217200 0.011
R14-2948-100 n1_311226_222318 n1_311226_220544 0.00583553
R14-2949-100 n1_311226_223888 n1_311226_222318 0.00516447
R14-2950-100 n1_311226_227232 n1_311226_223888 0.011
R14-2951-100 n1_311226_230576 n1_311226_227232 0.011
R14-2952-100 n1_311226_233920 n1_311226_230576 0.011
R14-2953-100 n1_311226_237264 n1_311226_233920 0.011
R14-2954-100 n1_311226_240608 n1_311226_237264 0.011
R14-2955-100 n1_311226_243952 n1_311226_240608 0.011
R14-2956-100 n1_311226_244814 n1_311226_243952 0.00283553
R14-2957-100 n1_311226_247296 n1_311226_244814 0.00816447
R14-2958-100 n1_311226_250640 n1_311226_247296 0.011
R14-2959-100 n1_311226_253984 n1_311226_250640 0.011
R14-2960-100 n1_311226_257328 n1_311226_253984 0.011
R14-2961-100 n1_311226_260672 n1_311226_257328 0.011
R14-2962-100 n1_311226_264016 n1_311226_260672 0.011
R14-2963-100 n1_311226_266702 n1_311226_264016 0.00883553
R14-2964-100 n1_311226_267360 n1_311226_266702 0.00216447
R14-2965-100 n1_311226_270704 n1_311226_267360 0.011
R14-2966-100 n1_311226_274048 n1_311226_270704 0.011
R14-2967-100 n1_311226_277392 n1_311226_274048 0.011
R14-2968-100 n1_311226_280736 n1_311226_277392 0.011
R14-2969-100 n1_311226_284080 n1_311226_280736 0.011
R14-2970-100 n1_311226_287424 n1_311226_284080 0.011
R14-2971-100 n1_311226_288590 n1_311226_287424 0.00383553
R14-2972-100 n1_311226_290768 n1_311226_288590 0.007164470000000001
R14-2973-100 n1_311226_294112 n1_311226_290768 0.011
R14-2974-100 n1_311226_297456 n1_311226_294112 0.011
R14-2975-100 n1_311226_300800 n1_311226_297456 0.011
R14-2976-100 n1_311226_304144 n1_311226_300800 0.011
R14-2977-100 n1_311226_307488 n1_311226_304144 0.011
R14-2978-100 n1_311226_310832 n1_311226_307488 0.011
R14-2979-100 n1_311226_311086 n1_311226_310832 0.000835526
R14-2980-100 n1_311226_314176 n1_311226_311086 0.0101645
R14-2981-100 n1_311226_317520 n1_311226_314176 0.011
R14-2982-100 n1_311226_320864 n1_311226_317520 0.011
R14-2983-100 n1_311226_324208 n1_311226_320864 0.011
R14-2984-100 n1_311226_327552 n1_311226_324208 0.011
R14-2985-100 n1_311226_330896 n1_311226_327552 0.011
R14-2986-100 n1_311226_332974 n1_311226_330896 0.006835529999999999
R14-2987-100 n1_311226_334240 n1_311226_332974 0.00416447
R14-2988-100 n1_311226_337584 n1_311226_334240 0.011
R14-2989-100 n1_311226_340928 n1_311226_337584 0.011
R14-2990-100 n1_311226_344272 n1_311226_340928 0.011
R14-2991-100 n1_311226_347616 n1_311226_344272 0.011
R14-2992-100 n1_311226_350960 n1_311226_347616 0.011
R14-2993-100 n1_311226_354304 n1_311226_350960 0.011
R14-2994-100 n1_311226_355470 n1_311226_354304 0.00383553
R14-2995-100 n1_311226_357648 n1_311226_355470 0.007164470000000001
R14-2996-100 n1_311226_360992 n1_311226_357648 0.011
R14-2997-100 n1_311226_364336 n1_311226_360992 0.011
R14-2998-100 n1_311226_367680 n1_311226_364336 0.011
R14-2999-100 n1_311226_371024 n1_311226_367680 0.011
R14-3000-100 n1_311226_374368 n1_311226_371024 0.011
R14-3001-100 n1_311226_377358 n1_311226_374368 0.00983553
R14-3002-100 n1_311226_377712 n1_311226_377358 0.00116447
R14-3003-100 n1_311226_381056 n1_311226_377712 0.011
R14-3004-100 n1_311226_384400 n1_311226_381056 0.011
R14-3005-100 n1_311226_387744 n1_311226_384400 0.011
R14-3006-100 n1_311226_391088 n1_311226_387744 0.011
R14-3007-100 n1_311226_394432 n1_311226_391088 0.011
R14-3008-100 n1_311226_397776 n1_311226_394432 0.011
R14-3009-100 n1_311226_399854 n1_311226_397776 0.006835529999999999
R14-3010-100 n1_311226_401120 n1_311226_399854 0.00416447
R14-3011-100 n1_311226_404464 n1_311226_401120 0.011
R14-3012-100 n1_311226_407808 n1_311226_404464 0.011
R14-3013-100 n1_311226_411152 n1_311226_407808 0.011
R14-3014-100 n1_311226_414496 n1_311226_411152 0.011
R14-3015-100 n1_311226_417840 n1_311226_414496 0.011
R14-3016-100 n1_311226_421184 n1_311226_417840 0.011
R14-3017-100 n1_311226_421742 n1_311226_421184 0.0018355300000000001
R14-3018-100 n1_311226_424528 n1_311226_421742 0.00916447
R14-3019-100 n1_311226_427872 n1_311226_424528 0.011
R14-3020-100 n1_311226_431216 n1_311226_427872 0.011
R14-3021-100 n1_311226_434560 n1_311226_431216 0.011
R14-3022-100 n1_311226_437904 n1_311226_434560 0.011
R14-3023-100 n1_311226_441248 n1_311226_437904 0.011
R14-3024-100 n1_311226_444238 n1_311226_441248 0.00983553
R14-3025-100 n1_311226_444592 n1_311226_444238 0.00116447
R14-3026-100 n1_311226_447936 n1_311226_444592 0.011
R14-3027-100 n1_311226_451280 n1_311226_447936 0.011
R14-3028-100 n1_311226_454624 n1_311226_451280 0.011
R14-3029-100 n1_311226_457968 n1_311226_454624 0.011
R14-3030-100 n1_311226_461312 n1_311226_457968 0.011
R14-3031-100 n1_311226_464656 n1_311226_461312 0.011
R14-3032-100 n1_311226_466126 n1_311226_464656 0.004835529999999999
R14-3033-100 n1_311226_468000 n1_311226_466126 0.00616447
R14-3034-100 n1_311226_471344 n1_311226_468000 0.011
R14-3035-100 n1_311226_474688 n1_311226_471344 0.011
R14-3036-100 n1_311226_478032 n1_311226_474688 0.011
R14-3037-100 n1_311226_481376 n1_311226_478032 0.011
R14-3038-100 n1_311226_484720 n1_311226_481376 0.011
R14-3039-100 n1_311226_488064 n1_311226_484720 0.011
R14-3040-100 n1_311226_488622 n1_311226_488064 0.0018355300000000001
R14-3041-100 n1_311226_491408 n1_311226_488622 0.00916447
R14-3042-100 n1_311226_494752 n1_311226_491408 0.011
R14-3043-100 n1_311226_498096 n1_311226_494752 0.011
R14-3044-100 n1_311226_501440 n1_311226_498096 0.011
R14-3045-100 n1_311226_504784 n1_311226_501440 0.011
R14-3046-100 n1_311226_508128 n1_311226_504784 0.011
R14-3047-100 n1_311226_510510 n1_311226_508128 0.00783553
R14-3048-100 n1_311226_511472 n1_311226_510510 0.00316447
R14-3049-100 n1_311226_514816 n1_311226_511472 0.011
R14-3050-100 n1_311226_518160 n1_311226_514816 0.011
R14-3051-100 n1_311226_521504 n1_311226_518160 0.011
R14-3052-100 n1_311226_524848 n1_311226_521504 0.011
R14-3053-100 n1_311226_528192 n1_311226_524848 0.011
R14-3054-100 n1_311226_531536 n1_311226_528192 0.011
R14-3055-100 n1_311226_532398 n1_311226_531536 0.00283553
R14-3056-100 n1_311226_534880 n1_311226_532398 0.00816447
R14-3057-100 n1_311226_538224 n1_311226_534880 0.011
R14-3058-100 n1_311226_541568 n1_311226_538224 0.011
R14-3059-100 n1_311226_544912 n1_311226_541568 0.011
R14-3060-100 n1_311226_548256 n1_311226_544912 0.011
R14-3061-100 n1_311226_551600 n1_311226_548256 0.011
R14-3062-100 n1_311226_554894 n1_311226_551600 0.010835500000000001
R14-3063-100 n1_311226_554944 n1_311226_554894 0.000164474
R14-3064-100 n1_311226_558288 n1_311226_554944 0.011
R14-3065-100 n1_311226_561632 n1_311226_558288 0.011
R14-3066-100 n1_311226_564976 n1_311226_561632 0.011
R14-3067-100 n1_311226_568320 n1_311226_564976 0.011
R14-3068-100 n1_311226_571664 n1_311226_568320 0.011
R14-3069-100 n1_311226_575008 n1_311226_571664 0.011
R14-3070-100 n1_311226_576782 n1_311226_575008 0.00583553
R14-3071-100 n1_311226_578352 n1_311226_576782 0.00516447
R14-3072-100 n1_311226_581696 n1_311226_578352 0.011
R14-3073-100 n1_311226_585040 n1_311226_581696 0.011
R14-3074-100 n1_311226_588384 n1_311226_585040 0.011
R14-3075-100 n1_311226_591728 n1_311226_588384 0.011
R14-3076-100 n1_311226_595072 n1_311226_591728 0.011
R14-3077-100 n1_311226_598416 n1_311226_595072 0.011
R14-3078-100 n1_311226_599278 n1_311226_598416 0.00283553
R14-3079-100 n1_311226_601760 n1_311226_599278 0.00816447
R14-3080-100 n1_311226_605104 n1_311226_601760 0.011
R14-3081-100 n1_311226_608448 n1_311226_605104 0.011
R14-3082-100 n1_311226_611792 n1_311226_608448 0.011
R14-3083-100 n1_311226_615136 n1_311226_611792 0.011
R14-3084-100 n1_311226_618480 n1_311226_615136 0.011
R14-3085-100 n1_311226_624152 n1_311226_618480 0.018657899999999998
R14-3086-100 n1_311226_626152 n1_311226_624152 0.00657895
R14-3087-100 n1_289034_46000 n1_289034_44000 0.00657895
R14-3088-100 n1_289034_50000 n1_289034_46000 0.0131579
R14-3089-100 n1_289034_53344 n1_289034_50000 0.011
R14-3090-100 n1_289034_56688 n1_289034_53344 0.011
R14-3091-100 n1_289034_60032 n1_289034_56688 0.011
R14-3092-100 n1_289034_63376 n1_289034_60032 0.011
R14-3093-100 n1_289034_66720 n1_289034_63376 0.011
R14-3094-100 n1_289034_67278 n1_289034_66720 0.0018355300000000001
R14-3095-100 n1_289034_70064 n1_289034_67278 0.00916447
R14-3096-100 n1_289034_73408 n1_289034_70064 0.011
R14-3097-100 n1_289034_76752 n1_289034_73408 0.011
R14-3098-100 n1_289034_80096 n1_289034_76752 0.011
R14-3099-100 n1_289034_83440 n1_289034_80096 0.011
R14-3100-100 n1_289034_86784 n1_289034_83440 0.011
R14-3101-100 n1_289034_89166 n1_289034_86784 0.00783553
R14-3102-100 n1_289034_90128 n1_289034_89166 0.00316447
R14-3103-100 n1_289034_93472 n1_289034_90128 0.011
R14-3104-100 n1_289034_96816 n1_289034_93472 0.011
R14-3105-100 n1_289034_100160 n1_289034_96816 0.011
R14-3106-100 n1_289034_103504 n1_289034_100160 0.011
R14-3107-100 n1_289034_106848 n1_289034_103504 0.011
R14-3108-100 n1_289034_110192 n1_289034_106848 0.011
R14-3109-100 n1_289034_111662 n1_289034_110192 0.004835529999999999
R14-3110-100 n1_289034_113536 n1_289034_111662 0.00616447
R14-3111-100 n1_289034_116880 n1_289034_113536 0.011
R14-3112-100 n1_289034_120224 n1_289034_116880 0.011
R14-3113-100 n1_289034_123568 n1_289034_120224 0.011
R14-3114-100 n1_289034_126912 n1_289034_123568 0.011
R14-3115-100 n1_289034_130256 n1_289034_126912 0.011
R14-3116-100 n1_289034_133550 n1_289034_130256 0.010835500000000001
R14-3117-100 n1_289034_133600 n1_289034_133550 0.000164474
R14-3118-100 n1_289034_136944 n1_289034_133600 0.011
R14-3119-100 n1_289034_140288 n1_289034_136944 0.011
R14-3120-100 n1_289034_143632 n1_289034_140288 0.011
R14-3121-100 n1_289034_146976 n1_289034_143632 0.011
R14-3122-100 n1_289034_150320 n1_289034_146976 0.011
R14-3123-100 n1_289034_153664 n1_289034_150320 0.011
R14-3124-100 n1_289034_156046 n1_289034_153664 0.00783553
R14-3125-100 n1_289034_157008 n1_289034_156046 0.00316447
R14-3126-100 n1_289034_160352 n1_289034_157008 0.011
R14-3127-100 n1_289034_163696 n1_289034_160352 0.011
R14-3128-100 n1_289034_167040 n1_289034_163696 0.011
R14-3129-100 n1_289034_170384 n1_289034_167040 0.011
R14-3130-100 n1_289034_173728 n1_289034_170384 0.011
R14-3131-100 n1_289034_177072 n1_289034_173728 0.011
R14-3132-100 n1_289034_177934 n1_289034_177072 0.00283553
R14-3133-100 n1_289034_180416 n1_289034_177934 0.00816447
R14-3134-100 n1_289034_183760 n1_289034_180416 0.011
R14-3135-100 n1_289034_187104 n1_289034_183760 0.011
R14-3136-100 n1_289034_190448 n1_289034_187104 0.011
R14-3137-100 n1_289034_193792 n1_289034_190448 0.011
R14-3138-100 n1_289034_197136 n1_289034_193792 0.011
R14-3139-100 n1_289034_200430 n1_289034_197136 0.010835500000000001
R14-3140-100 n1_289034_200480 n1_289034_200430 0.000164474
R14-3141-100 n1_289034_203824 n1_289034_200480 0.011
R14-3142-100 n1_289034_207168 n1_289034_203824 0.011
R14-3143-100 n1_289034_210512 n1_289034_207168 0.011
R14-3144-100 n1_289034_213856 n1_289034_210512 0.011
R14-3145-100 n1_289034_217200 n1_289034_213856 0.011
R14-3146-100 n1_289034_220544 n1_289034_217200 0.011
R14-3147-100 n1_289034_222318 n1_289034_220544 0.00583553
R14-3148-100 n1_289034_223888 n1_289034_222318 0.00516447
R14-3149-100 n1_289034_227232 n1_289034_223888 0.011
R14-3150-100 n1_289034_230576 n1_289034_227232 0.011
R14-3151-100 n1_289034_233920 n1_289034_230576 0.011
R14-3152-100 n1_289034_237264 n1_289034_233920 0.011
R14-3153-100 n1_289034_240608 n1_289034_237264 0.011
R14-3154-100 n1_289034_243952 n1_289034_240608 0.011
R14-3155-100 n1_289034_244814 n1_289034_243952 0.00283553
R14-3156-100 n1_289034_247296 n1_289034_244814 0.00816447
R14-3157-100 n1_289034_250640 n1_289034_247296 0.011
R14-3158-100 n1_289034_253984 n1_289034_250640 0.011
R14-3159-100 n1_289034_257328 n1_289034_253984 0.011
R14-3160-100 n1_289034_260672 n1_289034_257328 0.011
R14-3161-100 n1_289034_264016 n1_289034_260672 0.011
R14-3162-100 n1_289034_266702 n1_289034_264016 0.00883553
R14-3163-100 n1_289034_267360 n1_289034_266702 0.00216447
R14-3164-100 n1_289034_270704 n1_289034_267360 0.011
R14-3165-100 n1_289034_274048 n1_289034_270704 0.011
R14-3166-100 n1_289034_277392 n1_289034_274048 0.011
R14-3167-100 n1_289034_280736 n1_289034_277392 0.011
R14-3168-100 n1_289034_284080 n1_289034_280736 0.011
R14-3169-100 n1_289034_287424 n1_289034_284080 0.011
R14-3170-100 n1_289034_288590 n1_289034_287424 0.00383553
R14-3171-100 n1_289034_290768 n1_289034_288590 0.007164470000000001
R14-3172-100 n1_289034_294112 n1_289034_290768 0.011
R14-3173-100 n1_289034_297456 n1_289034_294112 0.011
R14-3174-100 n1_289034_300800 n1_289034_297456 0.011
R14-3175-100 n1_289034_304144 n1_289034_300800 0.011
R14-3176-100 n1_289034_307488 n1_289034_304144 0.011
R14-3177-100 n1_289034_310832 n1_289034_307488 0.011
R14-3178-100 n1_289034_311086 n1_289034_310832 0.000835526
R14-3179-100 n1_289034_314176 n1_289034_311086 0.0101645
R14-3180-100 n1_289034_317520 n1_289034_314176 0.011
R14-3181-100 n1_289034_320864 n1_289034_317520 0.011
R14-3182-100 n1_289034_324208 n1_289034_320864 0.011
R14-3183-100 n1_289034_327552 n1_289034_324208 0.011
R14-3184-100 n1_289034_330896 n1_289034_327552 0.011
R14-3185-100 n1_289034_332974 n1_289034_330896 0.006835529999999999
R14-3186-100 n1_289034_334240 n1_289034_332974 0.00416447
R14-3187-100 n1_289034_337584 n1_289034_334240 0.011
R14-3188-100 n1_289034_340928 n1_289034_337584 0.011
R14-3189-100 n1_289034_344272 n1_289034_340928 0.011
R14-3190-100 n1_289034_347616 n1_289034_344272 0.011
R14-3191-100 n1_289034_350960 n1_289034_347616 0.011
R14-3192-100 n1_289034_354304 n1_289034_350960 0.011
R14-3193-100 n1_289034_355470 n1_289034_354304 0.00383553
R14-3194-100 n1_289034_357648 n1_289034_355470 0.007164470000000001
R14-3195-100 n1_289034_360992 n1_289034_357648 0.011
R14-3196-100 n1_289034_364336 n1_289034_360992 0.011
R14-3197-100 n1_289034_367680 n1_289034_364336 0.011
R14-3198-100 n1_289034_371024 n1_289034_367680 0.011
R14-3199-100 n1_289034_374368 n1_289034_371024 0.011
R14-3200-100 n1_289034_377358 n1_289034_374368 0.00983553
R14-3201-100 n1_289034_377712 n1_289034_377358 0.00116447
R14-3202-100 n1_289034_381056 n1_289034_377712 0.011
R14-3203-100 n1_289034_384400 n1_289034_381056 0.011
R14-3204-100 n1_289034_387744 n1_289034_384400 0.011
R14-3205-100 n1_289034_391088 n1_289034_387744 0.011
R14-3206-100 n1_289034_394432 n1_289034_391088 0.011
R14-3207-100 n1_289034_397776 n1_289034_394432 0.011
R14-3208-100 n1_289034_399854 n1_289034_397776 0.006835529999999999
R14-3209-100 n1_289034_401120 n1_289034_399854 0.00416447
R14-3210-100 n1_289034_404464 n1_289034_401120 0.011
R14-3211-100 n1_289034_407808 n1_289034_404464 0.011
R14-3212-100 n1_289034_411152 n1_289034_407808 0.011
R14-3213-100 n1_289034_414496 n1_289034_411152 0.011
R14-3214-100 n1_289034_417840 n1_289034_414496 0.011
R14-3215-100 n1_289034_421184 n1_289034_417840 0.011
R14-3216-100 n1_289034_421742 n1_289034_421184 0.0018355300000000001
R14-3217-100 n1_289034_424528 n1_289034_421742 0.00916447
R14-3218-100 n1_289034_427872 n1_289034_424528 0.011
R14-3219-100 n1_289034_431216 n1_289034_427872 0.011
R14-3220-100 n1_289034_434560 n1_289034_431216 0.011
R14-3221-100 n1_289034_437904 n1_289034_434560 0.011
R14-3222-100 n1_289034_441248 n1_289034_437904 0.011
R14-3223-100 n1_289034_444238 n1_289034_441248 0.00983553
R14-3224-100 n1_289034_444592 n1_289034_444238 0.00116447
R14-3225-100 n1_289034_447936 n1_289034_444592 0.011
R14-3226-100 n1_289034_451280 n1_289034_447936 0.011
R14-3227-100 n1_289034_454624 n1_289034_451280 0.011
R14-3228-100 n1_289034_457968 n1_289034_454624 0.011
R14-3229-100 n1_289034_461312 n1_289034_457968 0.011
R14-3230-100 n1_289034_464656 n1_289034_461312 0.011
R14-3231-100 n1_289034_466126 n1_289034_464656 0.004835529999999999
R14-3232-100 n1_289034_468000 n1_289034_466126 0.00616447
R14-3233-100 n1_289034_471344 n1_289034_468000 0.011
R14-3234-100 n1_289034_474688 n1_289034_471344 0.011
R14-3235-100 n1_289034_478032 n1_289034_474688 0.011
R14-3236-100 n1_289034_481376 n1_289034_478032 0.011
R14-3237-100 n1_289034_484720 n1_289034_481376 0.011
R14-3238-100 n1_289034_488064 n1_289034_484720 0.011
R14-3239-100 n1_289034_488622 n1_289034_488064 0.0018355300000000001
R14-3240-100 n1_289034_491408 n1_289034_488622 0.00916447
R14-3241-100 n1_289034_494752 n1_289034_491408 0.011
R14-3242-100 n1_289034_498096 n1_289034_494752 0.011
R14-3243-100 n1_289034_501440 n1_289034_498096 0.011
R14-3244-100 n1_289034_504784 n1_289034_501440 0.011
R14-3245-100 n1_289034_508128 n1_289034_504784 0.011
R14-3246-100 n1_289034_510510 n1_289034_508128 0.00783553
R14-3247-100 n1_289034_511472 n1_289034_510510 0.00316447
R14-3248-100 n1_289034_514816 n1_289034_511472 0.011
R14-3249-100 n1_289034_518160 n1_289034_514816 0.011
R14-3250-100 n1_289034_521504 n1_289034_518160 0.011
R14-3251-100 n1_289034_524848 n1_289034_521504 0.011
R14-3252-100 n1_289034_528192 n1_289034_524848 0.011
R14-3253-100 n1_289034_531536 n1_289034_528192 0.011
R14-3254-100 n1_289034_532398 n1_289034_531536 0.00283553
R14-3255-100 n1_289034_534880 n1_289034_532398 0.00816447
R14-3256-100 n1_289034_538224 n1_289034_534880 0.011
R14-3257-100 n1_289034_541568 n1_289034_538224 0.011
R14-3258-100 n1_289034_544912 n1_289034_541568 0.011
R14-3259-100 n1_289034_548256 n1_289034_544912 0.011
R14-3260-100 n1_289034_551600 n1_289034_548256 0.011
R14-3261-100 n1_289034_554894 n1_289034_551600 0.010835500000000001
R14-3262-100 n1_289034_554944 n1_289034_554894 0.000164474
R14-3263-100 n1_289034_558288 n1_289034_554944 0.011
R14-3264-100 n1_289034_561632 n1_289034_558288 0.011
R14-3265-100 n1_289034_564976 n1_289034_561632 0.011
R14-3266-100 n1_289034_568320 n1_289034_564976 0.011
R14-3267-100 n1_289034_571664 n1_289034_568320 0.011
R14-3268-100 n1_289034_575008 n1_289034_571664 0.011
R14-3269-100 n1_289034_576782 n1_289034_575008 0.00583553
R14-3270-100 n1_289034_578352 n1_289034_576782 0.00516447
R14-3271-100 n1_289034_581696 n1_289034_578352 0.011
R14-3272-100 n1_289034_585040 n1_289034_581696 0.011
R14-3273-100 n1_289034_588384 n1_289034_585040 0.011
R14-3274-100 n1_289034_591728 n1_289034_588384 0.011
R14-3275-100 n1_289034_595072 n1_289034_591728 0.011
R14-3276-100 n1_289034_598416 n1_289034_595072 0.011
R14-3277-100 n1_289034_599278 n1_289034_598416 0.00283553
R14-3278-100 n1_289034_601760 n1_289034_599278 0.00816447
R14-3279-100 n1_289034_605104 n1_289034_601760 0.011
R14-3280-100 n1_289034_608448 n1_289034_605104 0.011
R14-3281-100 n1_289034_611792 n1_289034_608448 0.011
R14-3282-100 n1_289034_615136 n1_289034_611792 0.011
R14-3283-100 n1_289034_618480 n1_289034_615136 0.011
R14-3284-100 n1_289034_624152 n1_289034_618480 0.018657899999999998
R14-3285-100 n1_289034_626152 n1_289034_624152 0.00657895
R14-3286-100 n1_266538_46000 n1_266538_44000 0.00657895
R14-3287-100 n1_266538_50000 n1_266538_46000 0.0131579
R14-3288-100 n1_266538_53344 n1_266538_50000 0.011
R14-3289-100 n1_266538_56688 n1_266538_53344 0.011
R14-3290-100 n1_266538_60032 n1_266538_56688 0.011
R14-3291-100 n1_266538_63376 n1_266538_60032 0.011
R14-3292-100 n1_266538_66720 n1_266538_63376 0.011
R14-3293-100 n1_266538_67278 n1_266538_66720 0.0018355300000000001
R14-3294-100 n1_266538_70064 n1_266538_67278 0.00916447
R14-3295-100 n1_266538_73408 n1_266538_70064 0.011
R14-3296-100 n1_266538_76752 n1_266538_73408 0.011
R14-3297-100 n1_266538_80096 n1_266538_76752 0.011
R14-3298-100 n1_266538_83440 n1_266538_80096 0.011
R14-3299-100 n1_266538_86784 n1_266538_83440 0.011
R14-3300-100 n1_266538_89166 n1_266538_86784 0.00783553
R14-3301-100 n1_266538_90128 n1_266538_89166 0.00316447
R14-3302-100 n1_266538_93472 n1_266538_90128 0.011
R14-3303-100 n1_266538_96816 n1_266538_93472 0.011
R14-3304-100 n1_266538_100160 n1_266538_96816 0.011
R14-3305-100 n1_266538_103504 n1_266538_100160 0.011
R14-3306-100 n1_266538_106848 n1_266538_103504 0.011
R14-3307-100 n1_266538_110192 n1_266538_106848 0.011
R14-3308-100 n1_266538_111662 n1_266538_110192 0.004835529999999999
R14-3309-100 n1_266538_113536 n1_266538_111662 0.00616447
R14-3310-100 n1_266538_116880 n1_266538_113536 0.011
R14-3311-100 n1_266538_120224 n1_266538_116880 0.011
R14-3312-100 n1_266538_123568 n1_266538_120224 0.011
R14-3313-100 n1_266538_126912 n1_266538_123568 0.011
R14-3314-100 n1_266538_130256 n1_266538_126912 0.011
R14-3315-100 n1_266538_133550 n1_266538_130256 0.010835500000000001
R14-3316-100 n1_266538_133600 n1_266538_133550 0.000164474
R14-3317-100 n1_266538_136944 n1_266538_133600 0.011
R14-3318-100 n1_266538_140288 n1_266538_136944 0.011
R14-3319-100 n1_266538_143632 n1_266538_140288 0.011
R14-3320-100 n1_266538_146976 n1_266538_143632 0.011
R14-3321-100 n1_266538_150320 n1_266538_146976 0.011
R14-3322-100 n1_266538_153664 n1_266538_150320 0.011
R14-3323-100 n1_266538_156046 n1_266538_153664 0.00783553
R14-3324-100 n1_266538_157008 n1_266538_156046 0.00316447
R14-3325-100 n1_266538_160352 n1_266538_157008 0.011
R14-3326-100 n1_266538_163696 n1_266538_160352 0.011
R14-3327-100 n1_266538_167040 n1_266538_163696 0.011
R14-3328-100 n1_266538_170384 n1_266538_167040 0.011
R14-3329-100 n1_266538_173728 n1_266538_170384 0.011
R14-3330-100 n1_266538_177072 n1_266538_173728 0.011
R14-3331-100 n1_266538_177934 n1_266538_177072 0.00283553
R14-3332-100 n1_266538_180416 n1_266538_177934 0.00816447
R14-3333-100 n1_266538_183760 n1_266538_180416 0.011
R14-3334-100 n1_266538_187104 n1_266538_183760 0.011
R14-3335-100 n1_266538_190448 n1_266538_187104 0.011
R14-3336-100 n1_266538_193792 n1_266538_190448 0.011
R14-3337-100 n1_266538_197136 n1_266538_193792 0.011
R14-3338-100 n1_266538_200430 n1_266538_197136 0.010835500000000001
R14-3339-100 n1_266538_200480 n1_266538_200430 0.000164474
R14-3340-100 n1_266538_203824 n1_266538_200480 0.011
R14-3341-100 n1_266538_207168 n1_266538_203824 0.011
R14-3342-100 n1_266538_210512 n1_266538_207168 0.011
R14-3343-100 n1_266538_213856 n1_266538_210512 0.011
R14-3344-100 n1_266538_217200 n1_266538_213856 0.011
R14-3345-100 n1_266538_220544 n1_266538_217200 0.011
R14-3346-100 n1_266538_222318 n1_266538_220544 0.00583553
R14-3347-100 n1_266538_223888 n1_266538_222318 0.00516447
R14-3348-100 n1_266538_227232 n1_266538_223888 0.011
R14-3349-100 n1_266538_230576 n1_266538_227232 0.011
R14-3350-100 n1_266538_233920 n1_266538_230576 0.011
R14-3351-100 n1_266538_237264 n1_266538_233920 0.011
R14-3352-100 n1_266538_240608 n1_266538_237264 0.011
R14-3353-100 n1_266538_243952 n1_266538_240608 0.011
R14-3354-100 n1_266538_244814 n1_266538_243952 0.00283553
R14-3355-100 n1_266538_247296 n1_266538_244814 0.00816447
R14-3356-100 n1_266538_250640 n1_266538_247296 0.011
R14-3357-100 n1_266538_253984 n1_266538_250640 0.011
R14-3358-100 n1_266538_257328 n1_266538_253984 0.011
R14-3359-100 n1_266538_260672 n1_266538_257328 0.011
R14-3360-100 n1_266538_264016 n1_266538_260672 0.011
R14-3361-100 n1_266538_266702 n1_266538_264016 0.00883553
R14-3362-100 n1_266538_267360 n1_266538_266702 0.00216447
R14-3363-100 n1_266538_270704 n1_266538_267360 0.011
R14-3364-100 n1_266538_274048 n1_266538_270704 0.011
R14-3365-100 n1_266538_277392 n1_266538_274048 0.011
R14-3366-100 n1_266538_280736 n1_266538_277392 0.011
R14-3367-100 n1_266538_284080 n1_266538_280736 0.011
R14-3368-100 n1_266538_287424 n1_266538_284080 0.011
R14-3369-100 n1_266538_288590 n1_266538_287424 0.00383553
R14-3370-100 n1_266538_290768 n1_266538_288590 0.007164470000000001
R14-3371-100 n1_266538_294112 n1_266538_290768 0.011
R14-3372-100 n1_266538_297456 n1_266538_294112 0.011
R14-3373-100 n1_266538_300800 n1_266538_297456 0.011
R14-3374-100 n1_266538_304144 n1_266538_300800 0.011
R14-3375-100 n1_266538_307488 n1_266538_304144 0.011
R14-3376-100 n1_266538_310832 n1_266538_307488 0.011
R14-3377-100 n1_266538_311086 n1_266538_310832 0.000835526
R14-3378-100 n1_266538_314176 n1_266538_311086 0.0101645
R14-3379-100 n1_266538_317520 n1_266538_314176 0.011
R14-3380-100 n1_266538_320864 n1_266538_317520 0.011
R14-3381-100 n1_266538_324208 n1_266538_320864 0.011
R14-3382-100 n1_266538_327552 n1_266538_324208 0.011
R14-3383-100 n1_266538_330896 n1_266538_327552 0.011
R14-3384-100 n1_266538_332974 n1_266538_330896 0.006835529999999999
R14-3385-100 n1_266538_334240 n1_266538_332974 0.00416447
R14-3386-100 n1_266538_337584 n1_266538_334240 0.011
R14-3387-100 n1_266538_340928 n1_266538_337584 0.011
R14-3388-100 n1_266538_344272 n1_266538_340928 0.011
R14-3389-100 n1_266538_347616 n1_266538_344272 0.011
R14-3390-100 n1_266538_350960 n1_266538_347616 0.011
R14-3391-100 n1_266538_354304 n1_266538_350960 0.011
R14-3392-100 n1_266538_355470 n1_266538_354304 0.00383553
R14-3393-100 n1_266538_357648 n1_266538_355470 0.007164470000000001
R14-3394-100 n1_266538_360992 n1_266538_357648 0.011
R14-3395-100 n1_266538_364336 n1_266538_360992 0.011
R14-3396-100 n1_266538_367680 n1_266538_364336 0.011
R14-3397-100 n1_266538_371024 n1_266538_367680 0.011
R14-3398-100 n1_266538_374368 n1_266538_371024 0.011
R14-3399-100 n1_266538_377358 n1_266538_374368 0.00983553
R14-3400-100 n1_266538_377712 n1_266538_377358 0.00116447
R14-3401-100 n1_266538_381056 n1_266538_377712 0.011
R14-3402-100 n1_266538_384400 n1_266538_381056 0.011
R14-3403-100 n1_266538_387744 n1_266538_384400 0.011
R14-3404-100 n1_266538_391088 n1_266538_387744 0.011
R14-3405-100 n1_266538_394432 n1_266538_391088 0.011
R14-3406-100 n1_266538_397776 n1_266538_394432 0.011
R14-3407-100 n1_266538_399854 n1_266538_397776 0.006835529999999999
R14-3408-100 n1_266538_401120 n1_266538_399854 0.00416447
R14-3409-100 n1_266538_404464 n1_266538_401120 0.011
R14-3410-100 n1_266538_407808 n1_266538_404464 0.011
R14-3411-100 n1_266538_411152 n1_266538_407808 0.011
R14-3412-100 n1_266538_414496 n1_266538_411152 0.011
R14-3413-100 n1_266538_417840 n1_266538_414496 0.011
R14-3414-100 n1_266538_421184 n1_266538_417840 0.011
R14-3415-100 n1_266538_421742 n1_266538_421184 0.0018355300000000001
R14-3416-100 n1_266538_424528 n1_266538_421742 0.00916447
R14-3417-100 n1_266538_427872 n1_266538_424528 0.011
R14-3418-100 n1_266538_431216 n1_266538_427872 0.011
R14-3419-100 n1_266538_434560 n1_266538_431216 0.011
R14-3420-100 n1_266538_437904 n1_266538_434560 0.011
R14-3421-100 n1_266538_441248 n1_266538_437904 0.011
R14-3422-100 n1_266538_444238 n1_266538_441248 0.00983553
R14-3423-100 n1_266538_444592 n1_266538_444238 0.00116447
R14-3424-100 n1_266538_447936 n1_266538_444592 0.011
R14-3425-100 n1_266538_451280 n1_266538_447936 0.011
R14-3426-100 n1_266538_454624 n1_266538_451280 0.011
R14-3427-100 n1_266538_457968 n1_266538_454624 0.011
R14-3428-100 n1_266538_461312 n1_266538_457968 0.011
R14-3429-100 n1_266538_464656 n1_266538_461312 0.011
R14-3430-100 n1_266538_466126 n1_266538_464656 0.004835529999999999
R14-3431-100 n1_266538_468000 n1_266538_466126 0.00616447
R14-3432-100 n1_266538_471344 n1_266538_468000 0.011
R14-3433-100 n1_266538_474688 n1_266538_471344 0.011
R14-3434-100 n1_266538_478032 n1_266538_474688 0.011
R14-3435-100 n1_266538_481376 n1_266538_478032 0.011
R14-3436-100 n1_266538_484720 n1_266538_481376 0.011
R14-3437-100 n1_266538_488064 n1_266538_484720 0.011
R14-3438-100 n1_266538_488622 n1_266538_488064 0.0018355300000000001
R14-3439-100 n1_266538_491408 n1_266538_488622 0.00916447
R14-3440-100 n1_266538_494752 n1_266538_491408 0.011
R14-3441-100 n1_266538_498096 n1_266538_494752 0.011
R14-3442-100 n1_266538_501440 n1_266538_498096 0.011
R14-3443-100 n1_266538_504784 n1_266538_501440 0.011
R14-3444-100 n1_266538_508128 n1_266538_504784 0.011
R14-3445-100 n1_266538_510510 n1_266538_508128 0.00783553
R14-3446-100 n1_266538_511472 n1_266538_510510 0.00316447
R14-3447-100 n1_266538_514816 n1_266538_511472 0.011
R14-3448-100 n1_266538_518160 n1_266538_514816 0.011
R14-3449-100 n1_266538_521504 n1_266538_518160 0.011
R14-3450-100 n1_266538_524848 n1_266538_521504 0.011
R14-3451-100 n1_266538_528192 n1_266538_524848 0.011
R14-3452-100 n1_266538_531536 n1_266538_528192 0.011
R14-3453-100 n1_266538_532398 n1_266538_531536 0.00283553
R14-3454-100 n1_266538_534880 n1_266538_532398 0.00816447
R14-3455-100 n1_266538_538224 n1_266538_534880 0.011
R14-3456-100 n1_266538_541568 n1_266538_538224 0.011
R14-3457-100 n1_266538_544912 n1_266538_541568 0.011
R14-3458-100 n1_266538_548256 n1_266538_544912 0.011
R14-3459-100 n1_266538_551600 n1_266538_548256 0.011
R14-3460-100 n1_266538_554894 n1_266538_551600 0.010835500000000001
R14-3461-100 n1_266538_554944 n1_266538_554894 0.000164474
R14-3462-100 n1_266538_558288 n1_266538_554944 0.011
R14-3463-100 n1_266538_561632 n1_266538_558288 0.011
R14-3464-100 n1_266538_564976 n1_266538_561632 0.011
R14-3465-100 n1_266538_568320 n1_266538_564976 0.011
R14-3466-100 n1_266538_571664 n1_266538_568320 0.011
R14-3467-100 n1_266538_575008 n1_266538_571664 0.011
R14-3468-100 n1_266538_576782 n1_266538_575008 0.00583553
R14-3469-100 n1_266538_578352 n1_266538_576782 0.00516447
R14-3470-100 n1_266538_581696 n1_266538_578352 0.011
R14-3471-100 n1_266538_585040 n1_266538_581696 0.011
R14-3472-100 n1_266538_588384 n1_266538_585040 0.011
R14-3473-100 n1_266538_591728 n1_266538_588384 0.011
R14-3474-100 n1_266538_595072 n1_266538_591728 0.011
R14-3475-100 n1_266538_598416 n1_266538_595072 0.011
R14-3476-100 n1_266538_599278 n1_266538_598416 0.00283553
R14-3477-100 n1_266538_601760 n1_266538_599278 0.00816447
R14-3478-100 n1_266538_605104 n1_266538_601760 0.011
R14-3479-100 n1_266538_608448 n1_266538_605104 0.011
R14-3480-100 n1_266538_611792 n1_266538_608448 0.011
R14-3481-100 n1_266538_615136 n1_266538_611792 0.011
R14-3482-100 n1_266538_618480 n1_266538_615136 0.011
R14-3483-100 n1_266538_624152 n1_266538_618480 0.018657899999999998
R14-3484-100 n1_266538_626152 n1_266538_624152 0.00657895
R14-3485-100 n1_244346_46000 n1_244346_44000 0.00657895
R14-3486-100 n1_244346_50000 n1_244346_46000 0.0131579
R14-3487-100 n1_244346_53344 n1_244346_50000 0.011
R14-3488-100 n1_244346_56688 n1_244346_53344 0.011
R14-3489-100 n1_244346_60032 n1_244346_56688 0.011
R14-3490-100 n1_244346_63376 n1_244346_60032 0.011
R14-3491-100 n1_244346_66720 n1_244346_63376 0.011
R14-3492-100 n1_244346_67278 n1_244346_66720 0.0018355300000000001
R14-3493-100 n1_244346_70064 n1_244346_67278 0.00916447
R14-3494-100 n1_244346_73408 n1_244346_70064 0.011
R14-3495-100 n1_244346_76752 n1_244346_73408 0.011
R14-3496-100 n1_244346_80096 n1_244346_76752 0.011
R14-3497-100 n1_244346_83440 n1_244346_80096 0.011
R14-3498-100 n1_244346_86784 n1_244346_83440 0.011
R14-3499-100 n1_244346_89166 n1_244346_86784 0.00783553
R14-3500-100 n1_244346_90128 n1_244346_89166 0.00316447
R14-3501-100 n1_244346_93472 n1_244346_90128 0.011
R14-3502-100 n1_244346_96816 n1_244346_93472 0.011
R14-3503-100 n1_244346_100160 n1_244346_96816 0.011
R14-3504-100 n1_244346_103504 n1_244346_100160 0.011
R14-3505-100 n1_244346_106848 n1_244346_103504 0.011
R14-3506-100 n1_244346_110192 n1_244346_106848 0.011
R14-3507-100 n1_244346_111662 n1_244346_110192 0.004835529999999999
R14-3508-100 n1_244346_113536 n1_244346_111662 0.00616447
R14-3509-100 n1_244346_116880 n1_244346_113536 0.011
R14-3510-100 n1_244346_120224 n1_244346_116880 0.011
R14-3511-100 n1_244346_123568 n1_244346_120224 0.011
R14-3512-100 n1_244346_126912 n1_244346_123568 0.011
R14-3513-100 n1_244346_130256 n1_244346_126912 0.011
R14-3514-100 n1_244346_133550 n1_244346_130256 0.010835500000000001
R14-3515-100 n1_244346_133600 n1_244346_133550 0.000164474
R14-3516-100 n1_244346_136944 n1_244346_133600 0.011
R14-3517-100 n1_244346_140288 n1_244346_136944 0.011
R14-3518-100 n1_244346_143632 n1_244346_140288 0.011
R14-3519-100 n1_244346_146976 n1_244346_143632 0.011
R14-3520-100 n1_244346_150320 n1_244346_146976 0.011
R14-3521-100 n1_244346_153664 n1_244346_150320 0.011
R14-3522-100 n1_244346_156046 n1_244346_153664 0.00783553
R14-3523-100 n1_244346_157008 n1_244346_156046 0.00316447
R14-3524-100 n1_244346_160352 n1_244346_157008 0.011
R14-3525-100 n1_244346_163696 n1_244346_160352 0.011
R14-3526-100 n1_244346_167040 n1_244346_163696 0.011
R14-3527-100 n1_244346_170384 n1_244346_167040 0.011
R14-3528-100 n1_244346_173728 n1_244346_170384 0.011
R14-3529-100 n1_244346_177072 n1_244346_173728 0.011
R14-3530-100 n1_244346_177934 n1_244346_177072 0.00283553
R14-3531-100 n1_244346_180416 n1_244346_177934 0.00816447
R14-3532-100 n1_244346_183760 n1_244346_180416 0.011
R14-3533-100 n1_244346_187104 n1_244346_183760 0.011
R14-3534-100 n1_244346_190448 n1_244346_187104 0.011
R14-3535-100 n1_244346_193792 n1_244346_190448 0.011
R14-3536-100 n1_244346_197136 n1_244346_193792 0.011
R14-3537-100 n1_244346_200430 n1_244346_197136 0.010835500000000001
R14-3538-100 n1_244346_200480 n1_244346_200430 0.000164474
R14-3539-100 n1_244346_203824 n1_244346_200480 0.011
R14-3540-100 n1_244346_207168 n1_244346_203824 0.011
R14-3541-100 n1_244346_210512 n1_244346_207168 0.011
R14-3542-100 n1_244346_213856 n1_244346_210512 0.011
R14-3543-100 n1_244346_217200 n1_244346_213856 0.011
R14-3544-100 n1_244346_220544 n1_244346_217200 0.011
R14-3545-100 n1_244346_222318 n1_244346_220544 0.00583553
R14-3546-100 n1_244346_223888 n1_244346_222318 0.00516447
R14-3547-100 n1_244346_227232 n1_244346_223888 0.011
R14-3548-100 n1_244346_230576 n1_244346_227232 0.011
R14-3549-100 n1_244346_233920 n1_244346_230576 0.011
R14-3550-100 n1_244346_237264 n1_244346_233920 0.011
R14-3551-100 n1_244346_240608 n1_244346_237264 0.011
R14-3552-100 n1_244346_243952 n1_244346_240608 0.011
R14-3553-100 n1_244346_244814 n1_244346_243952 0.00283553
R14-3554-100 n1_244346_247296 n1_244346_244814 0.00816447
R14-3555-100 n1_244346_250640 n1_244346_247296 0.011
R14-3556-100 n1_244346_253984 n1_244346_250640 0.011
R14-3557-100 n1_244346_257328 n1_244346_253984 0.011
R14-3558-100 n1_244346_260672 n1_244346_257328 0.011
R14-3559-100 n1_244346_264016 n1_244346_260672 0.011
R14-3560-100 n1_244346_266702 n1_244346_264016 0.00883553
R14-3561-100 n1_244346_267360 n1_244346_266702 0.00216447
R14-3562-100 n1_244346_270704 n1_244346_267360 0.011
R14-3563-100 n1_244346_274048 n1_244346_270704 0.011
R14-3564-100 n1_244346_277392 n1_244346_274048 0.011
R14-3565-100 n1_244346_280736 n1_244346_277392 0.011
R14-3566-100 n1_244346_284080 n1_244346_280736 0.011
R14-3567-100 n1_244346_287424 n1_244346_284080 0.011
R14-3568-100 n1_244346_288590 n1_244346_287424 0.00383553
R14-3569-100 n1_244346_290768 n1_244346_288590 0.007164470000000001
R14-3570-100 n1_244346_294112 n1_244346_290768 0.011
R14-3571-100 n1_244346_297456 n1_244346_294112 0.011
R14-3572-100 n1_244346_300800 n1_244346_297456 0.011
R14-3573-100 n1_244346_304144 n1_244346_300800 0.011
R14-3574-100 n1_244346_307488 n1_244346_304144 0.011
R14-3575-100 n1_244346_310832 n1_244346_307488 0.011
R14-3576-100 n1_244346_311086 n1_244346_310832 0.000835526
R14-3577-100 n1_244346_314176 n1_244346_311086 0.0101645
R14-3578-100 n1_244346_317520 n1_244346_314176 0.011
R14-3579-100 n1_244346_320864 n1_244346_317520 0.011
R14-3580-100 n1_244346_324208 n1_244346_320864 0.011
R14-3581-100 n1_244346_327552 n1_244346_324208 0.011
R14-3582-100 n1_244346_330896 n1_244346_327552 0.011
R14-3583-100 n1_244346_332974 n1_244346_330896 0.006835529999999999
R14-3584-100 n1_244346_334240 n1_244346_332974 0.00416447
R14-3585-100 n1_244346_337584 n1_244346_334240 0.011
R14-3586-100 n1_244346_340928 n1_244346_337584 0.011
R14-3587-100 n1_244346_344272 n1_244346_340928 0.011
R14-3588-100 n1_244346_347616 n1_244346_344272 0.011
R14-3589-100 n1_244346_350960 n1_244346_347616 0.011
R14-3590-100 n1_244346_354304 n1_244346_350960 0.011
R14-3591-100 n1_244346_355470 n1_244346_354304 0.00383553
R14-3592-100 n1_244346_357648 n1_244346_355470 0.007164470000000001
R14-3593-100 n1_244346_360992 n1_244346_357648 0.011
R14-3594-100 n1_244346_364336 n1_244346_360992 0.011
R14-3595-100 n1_244346_367680 n1_244346_364336 0.011
R14-3596-100 n1_244346_371024 n1_244346_367680 0.011
R14-3597-100 n1_244346_374368 n1_244346_371024 0.011
R14-3598-100 n1_244346_377358 n1_244346_374368 0.00983553
R14-3599-100 n1_244346_377712 n1_244346_377358 0.00116447
R14-3600-100 n1_244346_381056 n1_244346_377712 0.011
R14-3601-100 n1_244346_384400 n1_244346_381056 0.011
R14-3602-100 n1_244346_387744 n1_244346_384400 0.011
R14-3603-100 n1_244346_391088 n1_244346_387744 0.011
R14-3604-100 n1_244346_394432 n1_244346_391088 0.011
R14-3605-100 n1_244346_397776 n1_244346_394432 0.011
R14-3606-100 n1_244346_399854 n1_244346_397776 0.006835529999999999
R14-3607-100 n1_244346_401120 n1_244346_399854 0.00416447
R14-3608-100 n1_244346_404464 n1_244346_401120 0.011
R14-3609-100 n1_244346_407808 n1_244346_404464 0.011
R14-3610-100 n1_244346_411152 n1_244346_407808 0.011
R14-3611-100 n1_244346_414496 n1_244346_411152 0.011
R14-3612-100 n1_244346_417840 n1_244346_414496 0.011
R14-3613-100 n1_244346_421184 n1_244346_417840 0.011
R14-3614-100 n1_244346_421742 n1_244346_421184 0.0018355300000000001
R14-3615-100 n1_244346_424528 n1_244346_421742 0.00916447
R14-3616-100 n1_244346_427872 n1_244346_424528 0.011
R14-3617-100 n1_244346_431216 n1_244346_427872 0.011
R14-3618-100 n1_244346_434560 n1_244346_431216 0.011
R14-3619-100 n1_244346_437904 n1_244346_434560 0.011
R14-3620-100 n1_244346_441248 n1_244346_437904 0.011
R14-3621-100 n1_244346_444238 n1_244346_441248 0.00983553
R14-3622-100 n1_244346_444592 n1_244346_444238 0.00116447
R14-3623-100 n1_244346_447936 n1_244346_444592 0.011
R14-3624-100 n1_244346_451280 n1_244346_447936 0.011
R14-3625-100 n1_244346_454624 n1_244346_451280 0.011
R14-3626-100 n1_244346_457968 n1_244346_454624 0.011
R14-3627-100 n1_244346_461312 n1_244346_457968 0.011
R14-3628-100 n1_244346_464656 n1_244346_461312 0.011
R14-3629-100 n1_244346_466126 n1_244346_464656 0.004835529999999999
R14-3630-100 n1_244346_468000 n1_244346_466126 0.00616447
R14-3631-100 n1_244346_471344 n1_244346_468000 0.011
R14-3632-100 n1_244346_474688 n1_244346_471344 0.011
R14-3633-100 n1_244346_478032 n1_244346_474688 0.011
R14-3634-100 n1_244346_481376 n1_244346_478032 0.011
R14-3635-100 n1_244346_484720 n1_244346_481376 0.011
R14-3636-100 n1_244346_488064 n1_244346_484720 0.011
R14-3637-100 n1_244346_488622 n1_244346_488064 0.0018355300000000001
R14-3638-100 n1_244346_491408 n1_244346_488622 0.00916447
R14-3639-100 n1_244346_494752 n1_244346_491408 0.011
R14-3640-100 n1_244346_498096 n1_244346_494752 0.011
R14-3641-100 n1_244346_501440 n1_244346_498096 0.011
R14-3642-100 n1_244346_504784 n1_244346_501440 0.011
R14-3643-100 n1_244346_508128 n1_244346_504784 0.011
R14-3644-100 n1_244346_510510 n1_244346_508128 0.00783553
R14-3645-100 n1_244346_511472 n1_244346_510510 0.00316447
R14-3646-100 n1_244346_514816 n1_244346_511472 0.011
R14-3647-100 n1_244346_518160 n1_244346_514816 0.011
R14-3648-100 n1_244346_521504 n1_244346_518160 0.011
R14-3649-100 n1_244346_524848 n1_244346_521504 0.011
R14-3650-100 n1_244346_528192 n1_244346_524848 0.011
R14-3651-100 n1_244346_531536 n1_244346_528192 0.011
R14-3652-100 n1_244346_532398 n1_244346_531536 0.00283553
R14-3653-100 n1_244346_534880 n1_244346_532398 0.00816447
R14-3654-100 n1_244346_538224 n1_244346_534880 0.011
R14-3655-100 n1_244346_541568 n1_244346_538224 0.011
R14-3656-100 n1_244346_544912 n1_244346_541568 0.011
R14-3657-100 n1_244346_548256 n1_244346_544912 0.011
R14-3658-100 n1_244346_551600 n1_244346_548256 0.011
R14-3659-100 n1_244346_554894 n1_244346_551600 0.010835500000000001
R14-3660-100 n1_244346_554944 n1_244346_554894 0.000164474
R14-3661-100 n1_244346_558288 n1_244346_554944 0.011
R14-3662-100 n1_244346_561632 n1_244346_558288 0.011
R14-3663-100 n1_244346_564976 n1_244346_561632 0.011
R14-3664-100 n1_244346_568320 n1_244346_564976 0.011
R14-3665-100 n1_244346_571664 n1_244346_568320 0.011
R14-3666-100 n1_244346_575008 n1_244346_571664 0.011
R14-3667-100 n1_244346_576782 n1_244346_575008 0.00583553
R14-3668-100 n1_244346_578352 n1_244346_576782 0.00516447
R14-3669-100 n1_244346_581696 n1_244346_578352 0.011
R14-3670-100 n1_244346_585040 n1_244346_581696 0.011
R14-3671-100 n1_244346_588384 n1_244346_585040 0.011
R14-3672-100 n1_244346_591728 n1_244346_588384 0.011
R14-3673-100 n1_244346_595072 n1_244346_591728 0.011
R14-3674-100 n1_244346_598416 n1_244346_595072 0.011
R14-3675-100 n1_244346_599278 n1_244346_598416 0.00283553
R14-3676-100 n1_244346_601760 n1_244346_599278 0.00816447
R14-3677-100 n1_244346_605104 n1_244346_601760 0.011
R14-3678-100 n1_244346_608448 n1_244346_605104 0.011
R14-3679-100 n1_244346_611792 n1_244346_608448 0.011
R14-3680-100 n1_244346_615136 n1_244346_611792 0.011
R14-3681-100 n1_244346_618480 n1_244346_615136 0.011
R14-3682-100 n1_244346_624152 n1_244346_618480 0.018657899999999998
R14-3683-100 n1_244346_626152 n1_244346_624152 0.00657895
R14-3684-100 n1_221850_46000 n1_221850_44000 0.00657895
R14-3685-100 n1_221850_50000 n1_221850_46000 0.0131579
R14-3686-100 n1_221850_53344 n1_221850_50000 0.011
R14-3687-100 n1_221850_56688 n1_221850_53344 0.011
R14-3688-100 n1_221850_60032 n1_221850_56688 0.011
R14-3689-100 n1_221850_63376 n1_221850_60032 0.011
R14-3690-100 n1_221850_66720 n1_221850_63376 0.011
R14-3691-100 n1_221850_67278 n1_221850_66720 0.0018355300000000001
R14-3692-100 n1_221850_70064 n1_221850_67278 0.00916447
R14-3693-100 n1_221850_73408 n1_221850_70064 0.011
R14-3694-100 n1_221850_76752 n1_221850_73408 0.011
R14-3695-100 n1_221850_80096 n1_221850_76752 0.011
R14-3696-100 n1_221850_83440 n1_221850_80096 0.011
R14-3697-100 n1_221850_86784 n1_221850_83440 0.011
R14-3698-100 n1_221850_89166 n1_221850_86784 0.00783553
R14-3699-100 n1_221850_90128 n1_221850_89166 0.00316447
R14-3700-100 n1_221850_93472 n1_221850_90128 0.011
R14-3701-100 n1_221850_96816 n1_221850_93472 0.011
R14-3702-100 n1_221850_100160 n1_221850_96816 0.011
R14-3703-100 n1_221850_103504 n1_221850_100160 0.011
R14-3704-100 n1_221850_106848 n1_221850_103504 0.011
R14-3705-100 n1_221850_110192 n1_221850_106848 0.011
R14-3706-100 n1_221850_111662 n1_221850_110192 0.004835529999999999
R14-3707-100 n1_221850_113536 n1_221850_111662 0.00616447
R14-3708-100 n1_221850_116880 n1_221850_113536 0.011
R14-3709-100 n1_221850_120224 n1_221850_116880 0.011
R14-3710-100 n1_221850_123568 n1_221850_120224 0.011
R14-3711-100 n1_221850_126912 n1_221850_123568 0.011
R14-3712-100 n1_221850_130256 n1_221850_126912 0.011
R14-3713-100 n1_221850_133550 n1_221850_130256 0.010835500000000001
R14-3714-100 n1_221850_133600 n1_221850_133550 0.000164474
R14-3715-100 n1_221850_136944 n1_221850_133600 0.011
R14-3716-100 n1_221850_140288 n1_221850_136944 0.011
R14-3717-100 n1_221850_143632 n1_221850_140288 0.011
R14-3718-100 n1_221850_146976 n1_221850_143632 0.011
R14-3719-100 n1_221850_150320 n1_221850_146976 0.011
R14-3720-100 n1_221850_153664 n1_221850_150320 0.011
R14-3721-100 n1_221850_156046 n1_221850_153664 0.00783553
R14-3722-100 n1_221850_157008 n1_221850_156046 0.00316447
R14-3723-100 n1_221850_160352 n1_221850_157008 0.011
R14-3724-100 n1_221850_163696 n1_221850_160352 0.011
R14-3725-100 n1_221850_167040 n1_221850_163696 0.011
R14-3726-100 n1_221850_170384 n1_221850_167040 0.011
R14-3727-100 n1_221850_173728 n1_221850_170384 0.011
R14-3728-100 n1_221850_177072 n1_221850_173728 0.011
R14-3729-100 n1_221850_177934 n1_221850_177072 0.00283553
R14-3730-100 n1_221850_180416 n1_221850_177934 0.00816447
R14-3731-100 n1_221850_183760 n1_221850_180416 0.011
R14-3732-100 n1_221850_187104 n1_221850_183760 0.011
R14-3733-100 n1_221850_190448 n1_221850_187104 0.011
R14-3734-100 n1_221850_193792 n1_221850_190448 0.011
R14-3735-100 n1_221850_197136 n1_221850_193792 0.011
R14-3736-100 n1_221850_200430 n1_221850_197136 0.010835500000000001
R14-3737-100 n1_221850_200480 n1_221850_200430 0.000164474
R14-3738-100 n1_221850_203824 n1_221850_200480 0.011
R14-3739-100 n1_221850_207168 n1_221850_203824 0.011
R14-3740-100 n1_221850_210512 n1_221850_207168 0.011
R14-3741-100 n1_221850_213856 n1_221850_210512 0.011
R14-3742-100 n1_221850_217200 n1_221850_213856 0.011
R14-3743-100 n1_221850_220544 n1_221850_217200 0.011
R14-3744-100 n1_221850_222318 n1_221850_220544 0.00583553
R14-3745-100 n1_221850_223888 n1_221850_222318 0.00516447
R14-3746-100 n1_221850_227232 n1_221850_223888 0.011
R14-3747-100 n1_221850_230576 n1_221850_227232 0.011
R14-3748-100 n1_221850_233920 n1_221850_230576 0.011
R14-3749-100 n1_221850_237264 n1_221850_233920 0.011
R14-3750-100 n1_221850_240608 n1_221850_237264 0.011
R14-3751-100 n1_221850_243952 n1_221850_240608 0.011
R14-3752-100 n1_221850_244814 n1_221850_243952 0.00283553
R14-3753-100 n1_221850_247296 n1_221850_244814 0.00816447
R14-3754-100 n1_221850_250640 n1_221850_247296 0.011
R14-3755-100 n1_221850_253984 n1_221850_250640 0.011
R14-3756-100 n1_221850_257328 n1_221850_253984 0.011
R14-3757-100 n1_221850_260672 n1_221850_257328 0.011
R14-3758-100 n1_221850_264016 n1_221850_260672 0.011
R14-3759-100 n1_221850_266702 n1_221850_264016 0.00883553
R14-3760-100 n1_221850_267360 n1_221850_266702 0.00216447
R14-3761-100 n1_221850_270704 n1_221850_267360 0.011
R14-3762-100 n1_221850_274048 n1_221850_270704 0.011
R14-3763-100 n1_221850_277392 n1_221850_274048 0.011
R14-3764-100 n1_221850_280736 n1_221850_277392 0.011
R14-3765-100 n1_221850_284080 n1_221850_280736 0.011
R14-3766-100 n1_221850_287424 n1_221850_284080 0.011
R14-3767-100 n1_221850_288590 n1_221850_287424 0.00383553
R14-3768-100 n1_221850_290768 n1_221850_288590 0.007164470000000001
R14-3769-100 n1_221850_294112 n1_221850_290768 0.011
R14-3770-100 n1_221850_297456 n1_221850_294112 0.011
R14-3771-100 n1_221850_300800 n1_221850_297456 0.011
R14-3772-100 n1_221850_304144 n1_221850_300800 0.011
R14-3773-100 n1_221850_307488 n1_221850_304144 0.011
R14-3774-100 n1_221850_310832 n1_221850_307488 0.011
R14-3775-100 n1_221850_311086 n1_221850_310832 0.000835526
R14-3776-100 n1_221850_314176 n1_221850_311086 0.0101645
R14-3777-100 n1_221850_317520 n1_221850_314176 0.011
R14-3778-100 n1_221850_320864 n1_221850_317520 0.011
R14-3779-100 n1_221850_324208 n1_221850_320864 0.011
R14-3780-100 n1_221850_327552 n1_221850_324208 0.011
R14-3781-100 n1_221850_330896 n1_221850_327552 0.011
R14-3782-100 n1_221850_332974 n1_221850_330896 0.006835529999999999
R14-3783-100 n1_221850_334240 n1_221850_332974 0.00416447
R14-3784-100 n1_221850_337584 n1_221850_334240 0.011
R14-3785-100 n1_221850_340928 n1_221850_337584 0.011
R14-3786-100 n1_221850_344272 n1_221850_340928 0.011
R14-3787-100 n1_221850_347616 n1_221850_344272 0.011
R14-3788-100 n1_221850_350960 n1_221850_347616 0.011
R14-3789-100 n1_221850_354304 n1_221850_350960 0.011
R14-3790-100 n1_221850_355470 n1_221850_354304 0.00383553
R14-3791-100 n1_221850_357648 n1_221850_355470 0.007164470000000001
R14-3792-100 n1_221850_360992 n1_221850_357648 0.011
R14-3793-100 n1_221850_364336 n1_221850_360992 0.011
R14-3794-100 n1_221850_367680 n1_221850_364336 0.011
R14-3795-100 n1_221850_371024 n1_221850_367680 0.011
R14-3796-100 n1_221850_374368 n1_221850_371024 0.011
R14-3797-100 n1_221850_377358 n1_221850_374368 0.00983553
R14-3798-100 n1_221850_377712 n1_221850_377358 0.00116447
R14-3799-100 n1_221850_381056 n1_221850_377712 0.011
R14-3800-100 n1_221850_384400 n1_221850_381056 0.011
R14-3801-100 n1_221850_387744 n1_221850_384400 0.011
R14-3802-100 n1_221850_391088 n1_221850_387744 0.011
R14-3803-100 n1_221850_394432 n1_221850_391088 0.011
R14-3804-100 n1_221850_397776 n1_221850_394432 0.011
R14-3805-100 n1_221850_399854 n1_221850_397776 0.006835529999999999
R14-3806-100 n1_221850_401120 n1_221850_399854 0.00416447
R14-3807-100 n1_221850_404464 n1_221850_401120 0.011
R14-3808-100 n1_221850_407808 n1_221850_404464 0.011
R14-3809-100 n1_221850_411152 n1_221850_407808 0.011
R14-3810-100 n1_221850_414496 n1_221850_411152 0.011
R14-3811-100 n1_221850_417840 n1_221850_414496 0.011
R14-3812-100 n1_221850_421184 n1_221850_417840 0.011
R14-3813-100 n1_221850_421742 n1_221850_421184 0.0018355300000000001
R14-3814-100 n1_221850_424528 n1_221850_421742 0.00916447
R14-3815-100 n1_221850_427872 n1_221850_424528 0.011
R14-3816-100 n1_221850_431216 n1_221850_427872 0.011
R14-3817-100 n1_221850_434560 n1_221850_431216 0.011
R14-3818-100 n1_221850_437904 n1_221850_434560 0.011
R14-3819-100 n1_221850_441248 n1_221850_437904 0.011
R14-3820-100 n1_221850_444238 n1_221850_441248 0.00983553
R14-3821-100 n1_221850_444592 n1_221850_444238 0.00116447
R14-3822-100 n1_221850_447936 n1_221850_444592 0.011
R14-3823-100 n1_221850_451280 n1_221850_447936 0.011
R14-3824-100 n1_221850_454624 n1_221850_451280 0.011
R14-3825-100 n1_221850_457968 n1_221850_454624 0.011
R14-3826-100 n1_221850_461312 n1_221850_457968 0.011
R14-3827-100 n1_221850_464656 n1_221850_461312 0.011
R14-3828-100 n1_221850_466126 n1_221850_464656 0.004835529999999999
R14-3829-100 n1_221850_468000 n1_221850_466126 0.00616447
R14-3830-100 n1_221850_471344 n1_221850_468000 0.011
R14-3831-100 n1_221850_474688 n1_221850_471344 0.011
R14-3832-100 n1_221850_478032 n1_221850_474688 0.011
R14-3833-100 n1_221850_481376 n1_221850_478032 0.011
R14-3834-100 n1_221850_484720 n1_221850_481376 0.011
R14-3835-100 n1_221850_488064 n1_221850_484720 0.011
R14-3836-100 n1_221850_488622 n1_221850_488064 0.0018355300000000001
R14-3837-100 n1_221850_491408 n1_221850_488622 0.00916447
R14-3838-100 n1_221850_494752 n1_221850_491408 0.011
R14-3839-100 n1_221850_498096 n1_221850_494752 0.011
R14-3840-100 n1_221850_501440 n1_221850_498096 0.011
R14-3841-100 n1_221850_504784 n1_221850_501440 0.011
R14-3842-100 n1_221850_508128 n1_221850_504784 0.011
R14-3843-100 n1_221850_510510 n1_221850_508128 0.00783553
R14-3844-100 n1_221850_511472 n1_221850_510510 0.00316447
R14-3845-100 n1_221850_514816 n1_221850_511472 0.011
R14-3846-100 n1_221850_518160 n1_221850_514816 0.011
R14-3847-100 n1_221850_521504 n1_221850_518160 0.011
R14-3848-100 n1_221850_524848 n1_221850_521504 0.011
R14-3849-100 n1_221850_528192 n1_221850_524848 0.011
R14-3850-100 n1_221850_531536 n1_221850_528192 0.011
R14-3851-100 n1_221850_532398 n1_221850_531536 0.00283553
R14-3852-100 n1_221850_534880 n1_221850_532398 0.00816447
R14-3853-100 n1_221850_538224 n1_221850_534880 0.011
R14-3854-100 n1_221850_541568 n1_221850_538224 0.011
R14-3855-100 n1_221850_544912 n1_221850_541568 0.011
R14-3856-100 n1_221850_548256 n1_221850_544912 0.011
R14-3857-100 n1_221850_551600 n1_221850_548256 0.011
R14-3858-100 n1_221850_554894 n1_221850_551600 0.010835500000000001
R14-3859-100 n1_221850_554944 n1_221850_554894 0.000164474
R14-3860-100 n1_221850_558288 n1_221850_554944 0.011
R14-3861-100 n1_221850_561632 n1_221850_558288 0.011
R14-3862-100 n1_221850_564976 n1_221850_561632 0.011
R14-3863-100 n1_221850_568320 n1_221850_564976 0.011
R14-3864-100 n1_221850_571664 n1_221850_568320 0.011
R14-3865-100 n1_221850_575008 n1_221850_571664 0.011
R14-3866-100 n1_221850_576782 n1_221850_575008 0.00583553
R14-3867-100 n1_221850_578352 n1_221850_576782 0.00516447
R14-3868-100 n1_221850_581696 n1_221850_578352 0.011
R14-3869-100 n1_221850_585040 n1_221850_581696 0.011
R14-3870-100 n1_221850_588384 n1_221850_585040 0.011
R14-3871-100 n1_221850_591728 n1_221850_588384 0.011
R14-3872-100 n1_221850_595072 n1_221850_591728 0.011
R14-3873-100 n1_221850_598416 n1_221850_595072 0.011
R14-3874-100 n1_221850_599278 n1_221850_598416 0.00283553
R14-3875-100 n1_221850_601760 n1_221850_599278 0.00816447
R14-3876-100 n1_221850_605104 n1_221850_601760 0.011
R14-3877-100 n1_221850_608448 n1_221850_605104 0.011
R14-3878-100 n1_221850_611792 n1_221850_608448 0.011
R14-3879-100 n1_221850_615136 n1_221850_611792 0.011
R14-3880-100 n1_221850_618480 n1_221850_615136 0.011
R14-3881-100 n1_221850_624152 n1_221850_618480 0.018657899999999998
R14-3882-100 n1_221850_626152 n1_221850_624152 0.00657895
R14-3883-100 n1_199658_46000 n1_199658_44000 0.00657895
R14-3884-100 n1_199658_50000 n1_199658_46000 0.0131579
R14-3885-100 n1_199658_53344 n1_199658_50000 0.011
R14-3886-100 n1_199658_56688 n1_199658_53344 0.011
R14-3887-100 n1_199658_60032 n1_199658_56688 0.011
R14-3888-100 n1_199658_63376 n1_199658_60032 0.011
R14-3889-100 n1_199658_66720 n1_199658_63376 0.011
R14-3890-100 n1_199658_67278 n1_199658_66720 0.0018355300000000001
R14-3891-100 n1_199658_70064 n1_199658_67278 0.00916447
R14-3892-100 n1_199658_73408 n1_199658_70064 0.011
R14-3893-100 n1_199658_76752 n1_199658_73408 0.011
R14-3894-100 n1_199658_80096 n1_199658_76752 0.011
R14-3895-100 n1_199658_83440 n1_199658_80096 0.011
R14-3896-100 n1_199658_86784 n1_199658_83440 0.011
R14-3897-100 n1_199658_89166 n1_199658_86784 0.00783553
R14-3898-100 n1_199658_90128 n1_199658_89166 0.00316447
R14-3899-100 n1_199658_93472 n1_199658_90128 0.011
R14-3900-100 n1_199658_96816 n1_199658_93472 0.011
R14-3901-100 n1_199658_100160 n1_199658_96816 0.011
R14-3902-100 n1_199658_103504 n1_199658_100160 0.011
R14-3903-100 n1_199658_106848 n1_199658_103504 0.011
R14-3904-100 n1_199658_110192 n1_199658_106848 0.011
R14-3905-100 n1_199658_111662 n1_199658_110192 0.004835529999999999
R14-3906-100 n1_199658_113536 n1_199658_111662 0.00616447
R14-3907-100 n1_199658_116880 n1_199658_113536 0.011
R14-3908-100 n1_199658_120224 n1_199658_116880 0.011
R14-3909-100 n1_199658_123568 n1_199658_120224 0.011
R14-3910-100 n1_199658_126912 n1_199658_123568 0.011
R14-3911-100 n1_199658_130256 n1_199658_126912 0.011
R14-3912-100 n1_199658_133550 n1_199658_130256 0.010835500000000001
R14-3913-100 n1_199658_133600 n1_199658_133550 0.000164474
R14-3914-100 n1_199658_136944 n1_199658_133600 0.011
R14-3915-100 n1_199658_140288 n1_199658_136944 0.011
R14-3916-100 n1_199658_143632 n1_199658_140288 0.011
R14-3917-100 n1_199658_146976 n1_199658_143632 0.011
R14-3918-100 n1_199658_150320 n1_199658_146976 0.011
R14-3919-100 n1_199658_153664 n1_199658_150320 0.011
R14-3920-100 n1_199658_156046 n1_199658_153664 0.00783553
R14-3921-100 n1_199658_157008 n1_199658_156046 0.00316447
R14-3922-100 n1_199658_160352 n1_199658_157008 0.011
R14-3923-100 n1_199658_163696 n1_199658_160352 0.011
R14-3924-100 n1_199658_167040 n1_199658_163696 0.011
R14-3925-100 n1_199658_170384 n1_199658_167040 0.011
R14-3926-100 n1_199658_173728 n1_199658_170384 0.011
R14-3927-100 n1_199658_177072 n1_199658_173728 0.011
R14-3928-100 n1_199658_177934 n1_199658_177072 0.00283553
R14-3929-100 n1_199658_180416 n1_199658_177934 0.00816447
R14-3930-100 n1_199658_183760 n1_199658_180416 0.011
R14-3931-100 n1_199658_187104 n1_199658_183760 0.011
R14-3932-100 n1_199658_190448 n1_199658_187104 0.011
R14-3933-100 n1_199658_193792 n1_199658_190448 0.011
R14-3934-100 n1_199658_197136 n1_199658_193792 0.011
R14-3935-100 n1_199658_200430 n1_199658_197136 0.010835500000000001
R14-3936-100 n1_199658_200480 n1_199658_200430 0.000164474
R14-3937-100 n1_199658_203824 n1_199658_200480 0.011
R14-3938-100 n1_199658_207168 n1_199658_203824 0.011
R14-3939-100 n1_199658_210512 n1_199658_207168 0.011
R14-3940-100 n1_199658_213856 n1_199658_210512 0.011
R14-3941-100 n1_199658_217200 n1_199658_213856 0.011
R14-3942-100 n1_199658_220544 n1_199658_217200 0.011
R14-3943-100 n1_199658_222318 n1_199658_220544 0.00583553
R14-3944-100 n1_199658_223888 n1_199658_222318 0.00516447
R14-3945-100 n1_199658_227232 n1_199658_223888 0.011
R14-3946-100 n1_199658_230576 n1_199658_227232 0.011
R14-3947-100 n1_199658_233920 n1_199658_230576 0.011
R14-3948-100 n1_199658_237264 n1_199658_233920 0.011
R14-3949-100 n1_199658_240608 n1_199658_237264 0.011
R14-3950-100 n1_199658_243952 n1_199658_240608 0.011
R14-3951-100 n1_199658_244814 n1_199658_243952 0.00283553
R14-3952-100 n1_199658_247296 n1_199658_244814 0.00816447
R14-3953-100 n1_199658_250640 n1_199658_247296 0.011
R14-3954-100 n1_199658_253984 n1_199658_250640 0.011
R14-3955-100 n1_199658_257328 n1_199658_253984 0.011
R14-3956-100 n1_199658_260672 n1_199658_257328 0.011
R14-3957-100 n1_199658_264016 n1_199658_260672 0.011
R14-3958-100 n1_199658_266702 n1_199658_264016 0.00883553
R14-3959-100 n1_199658_267360 n1_199658_266702 0.00216447
R14-3960-100 n1_199658_270704 n1_199658_267360 0.011
R14-3961-100 n1_199658_274048 n1_199658_270704 0.011
R14-3962-100 n1_199658_277392 n1_199658_274048 0.011
R14-3963-100 n1_199658_280736 n1_199658_277392 0.011
R14-3964-100 n1_199658_284080 n1_199658_280736 0.011
R14-3965-100 n1_199658_287424 n1_199658_284080 0.011
R14-3966-100 n1_199658_288590 n1_199658_287424 0.00383553
R14-3967-100 n1_199658_290768 n1_199658_288590 0.007164470000000001
R14-3968-100 n1_199658_294112 n1_199658_290768 0.011
R14-3969-100 n1_199658_297456 n1_199658_294112 0.011
R14-3970-100 n1_199658_300800 n1_199658_297456 0.011
R14-3971-100 n1_199658_304144 n1_199658_300800 0.011
R14-3972-100 n1_199658_307488 n1_199658_304144 0.011
R14-3973-100 n1_199658_310832 n1_199658_307488 0.011
R14-3974-100 n1_199658_311086 n1_199658_310832 0.000835526
R14-3975-100 n1_199658_314176 n1_199658_311086 0.0101645
R14-3976-100 n1_199658_317520 n1_199658_314176 0.011
R14-3977-100 n1_199658_320864 n1_199658_317520 0.011
R14-3978-100 n1_199658_324208 n1_199658_320864 0.011
R14-3979-100 n1_199658_327552 n1_199658_324208 0.011
R14-3980-100 n1_199658_330896 n1_199658_327552 0.011
R14-3981-100 n1_199658_332974 n1_199658_330896 0.006835529999999999
R14-3982-100 n1_199658_334240 n1_199658_332974 0.00416447
R14-3983-100 n1_199658_337584 n1_199658_334240 0.011
R14-3984-100 n1_199658_340928 n1_199658_337584 0.011
R14-3985-100 n1_199658_344272 n1_199658_340928 0.011
R14-3986-100 n1_199658_347616 n1_199658_344272 0.011
R14-3987-100 n1_199658_350960 n1_199658_347616 0.011
R14-3988-100 n1_199658_354304 n1_199658_350960 0.011
R14-3989-100 n1_199658_355470 n1_199658_354304 0.00383553
R14-3990-100 n1_199658_357648 n1_199658_355470 0.007164470000000001
R14-3991-100 n1_199658_360992 n1_199658_357648 0.011
R14-3992-100 n1_199658_364336 n1_199658_360992 0.011
R14-3993-100 n1_199658_367680 n1_199658_364336 0.011
R14-3994-100 n1_199658_371024 n1_199658_367680 0.011
R14-3995-100 n1_199658_374368 n1_199658_371024 0.011
R14-3996-100 n1_199658_377358 n1_199658_374368 0.00983553
R14-3997-100 n1_199658_377712 n1_199658_377358 0.00116447
R14-3998-100 n1_199658_381056 n1_199658_377712 0.011
R14-3999-100 n1_199658_384400 n1_199658_381056 0.011
R14-4000-100 n1_199658_387744 n1_199658_384400 0.011
R14-4001-100 n1_199658_391088 n1_199658_387744 0.011
R14-4002-100 n1_199658_394432 n1_199658_391088 0.011
R14-4003-100 n1_199658_397776 n1_199658_394432 0.011
R14-4004-100 n1_199658_399854 n1_199658_397776 0.006835529999999999
R14-4005-100 n1_199658_401120 n1_199658_399854 0.00416447
R14-4006-100 n1_199658_404464 n1_199658_401120 0.011
R14-4007-100 n1_199658_407808 n1_199658_404464 0.011
R14-4008-100 n1_199658_411152 n1_199658_407808 0.011
R14-4009-100 n1_199658_414496 n1_199658_411152 0.011
R14-4010-100 n1_199658_417840 n1_199658_414496 0.011
R14-4011-100 n1_199658_421184 n1_199658_417840 0.011
R14-4012-100 n1_199658_421742 n1_199658_421184 0.0018355300000000001
R14-4013-100 n1_199658_424528 n1_199658_421742 0.00916447
R14-4014-100 n1_199658_427872 n1_199658_424528 0.011
R14-4015-100 n1_199658_431216 n1_199658_427872 0.011
R14-4016-100 n1_199658_434560 n1_199658_431216 0.011
R14-4017-100 n1_199658_437904 n1_199658_434560 0.011
R14-4018-100 n1_199658_441248 n1_199658_437904 0.011
R14-4019-100 n1_199658_444238 n1_199658_441248 0.00983553
R14-4020-100 n1_199658_444592 n1_199658_444238 0.00116447
R14-4021-100 n1_199658_447936 n1_199658_444592 0.011
R14-4022-100 n1_199658_451280 n1_199658_447936 0.011
R14-4023-100 n1_199658_454624 n1_199658_451280 0.011
R14-4024-100 n1_199658_457968 n1_199658_454624 0.011
R14-4025-100 n1_199658_461312 n1_199658_457968 0.011
R14-4026-100 n1_199658_464656 n1_199658_461312 0.011
R14-4027-100 n1_199658_466126 n1_199658_464656 0.004835529999999999
R14-4028-100 n1_199658_468000 n1_199658_466126 0.00616447
R14-4029-100 n1_199658_471344 n1_199658_468000 0.011
R14-4030-100 n1_199658_474688 n1_199658_471344 0.011
R14-4031-100 n1_199658_478032 n1_199658_474688 0.011
R14-4032-100 n1_199658_481376 n1_199658_478032 0.011
R14-4033-100 n1_199658_484720 n1_199658_481376 0.011
R14-4034-100 n1_199658_488064 n1_199658_484720 0.011
R14-4035-100 n1_199658_488622 n1_199658_488064 0.0018355300000000001
R14-4036-100 n1_199658_491408 n1_199658_488622 0.00916447
R14-4037-100 n1_199658_494752 n1_199658_491408 0.011
R14-4038-100 n1_199658_498096 n1_199658_494752 0.011
R14-4039-100 n1_199658_501440 n1_199658_498096 0.011
R14-4040-100 n1_199658_504784 n1_199658_501440 0.011
R14-4041-100 n1_199658_508128 n1_199658_504784 0.011
R14-4042-100 n1_199658_510510 n1_199658_508128 0.00783553
R14-4043-100 n1_199658_511472 n1_199658_510510 0.00316447
R14-4044-100 n1_199658_514816 n1_199658_511472 0.011
R14-4045-100 n1_199658_518160 n1_199658_514816 0.011
R14-4046-100 n1_199658_521504 n1_199658_518160 0.011
R14-4047-100 n1_199658_524848 n1_199658_521504 0.011
R14-4048-100 n1_199658_528192 n1_199658_524848 0.011
R14-4049-100 n1_199658_531536 n1_199658_528192 0.011
R14-4050-100 n1_199658_532398 n1_199658_531536 0.00283553
R14-4051-100 n1_199658_534880 n1_199658_532398 0.00816447
R14-4052-100 n1_199658_538224 n1_199658_534880 0.011
R14-4053-100 n1_199658_541568 n1_199658_538224 0.011
R14-4054-100 n1_199658_544912 n1_199658_541568 0.011
R14-4055-100 n1_199658_548256 n1_199658_544912 0.011
R14-4056-100 n1_199658_551600 n1_199658_548256 0.011
R14-4057-100 n1_199658_554894 n1_199658_551600 0.010835500000000001
R14-4058-100 n1_199658_554944 n1_199658_554894 0.000164474
R14-4059-100 n1_199658_558288 n1_199658_554944 0.011
R14-4060-100 n1_199658_561632 n1_199658_558288 0.011
R14-4061-100 n1_199658_564976 n1_199658_561632 0.011
R14-4062-100 n1_199658_568320 n1_199658_564976 0.011
R14-4063-100 n1_199658_571664 n1_199658_568320 0.011
R14-4064-100 n1_199658_575008 n1_199658_571664 0.011
R14-4065-100 n1_199658_576782 n1_199658_575008 0.00583553
R14-4066-100 n1_199658_578352 n1_199658_576782 0.00516447
R14-4067-100 n1_199658_581696 n1_199658_578352 0.011
R14-4068-100 n1_199658_585040 n1_199658_581696 0.011
R14-4069-100 n1_199658_588384 n1_199658_585040 0.011
R14-4070-100 n1_199658_591728 n1_199658_588384 0.011
R14-4071-100 n1_199658_595072 n1_199658_591728 0.011
R14-4072-100 n1_199658_598416 n1_199658_595072 0.011
R14-4073-100 n1_199658_599278 n1_199658_598416 0.00283553
R14-4074-100 n1_199658_601760 n1_199658_599278 0.00816447
R14-4075-100 n1_199658_605104 n1_199658_601760 0.011
R14-4076-100 n1_199658_608448 n1_199658_605104 0.011
R14-4077-100 n1_199658_611792 n1_199658_608448 0.011
R14-4078-100 n1_199658_615136 n1_199658_611792 0.011
R14-4079-100 n1_199658_618480 n1_199658_615136 0.011
R14-4080-100 n1_199658_624152 n1_199658_618480 0.018657899999999998
R14-4081-100 n1_199658_626152 n1_199658_624152 0.00657895
R14-4082-100 n1_177466_46000 n1_177466_44000 0.00657895
R14-4083-100 n1_177466_50000 n1_177466_46000 0.0131579
R14-4084-100 n1_177466_53344 n1_177466_50000 0.011
R14-4085-100 n1_177466_56688 n1_177466_53344 0.011
R14-4086-100 n1_177466_60032 n1_177466_56688 0.011
R14-4087-100 n1_177466_63376 n1_177466_60032 0.011
R14-4088-100 n1_177466_66720 n1_177466_63376 0.011
R14-4089-100 n1_177466_67278 n1_177466_66720 0.0018355300000000001
R14-4090-100 n1_177466_70064 n1_177466_67278 0.00916447
R14-4091-100 n1_177466_73408 n1_177466_70064 0.011
R14-4092-100 n1_177466_76752 n1_177466_73408 0.011
R14-4093-100 n1_177466_80096 n1_177466_76752 0.011
R14-4094-100 n1_177466_83440 n1_177466_80096 0.011
R14-4095-100 n1_177466_86784 n1_177466_83440 0.011
R14-4096-100 n1_177466_89166 n1_177466_86784 0.00783553
R14-4097-100 n1_177466_90128 n1_177466_89166 0.00316447
R14-4098-100 n1_177466_93472 n1_177466_90128 0.011
R14-4099-100 n1_177466_96816 n1_177466_93472 0.011
R14-4100-100 n1_177466_100160 n1_177466_96816 0.011
R14-4101-100 n1_177466_103504 n1_177466_100160 0.011
R14-4102-100 n1_177466_106848 n1_177466_103504 0.011
R14-4103-100 n1_177466_110192 n1_177466_106848 0.011
R14-4104-100 n1_177466_111662 n1_177466_110192 0.004835529999999999
R14-4105-100 n1_177466_113536 n1_177466_111662 0.00616447
R14-4106-100 n1_177466_116880 n1_177466_113536 0.011
R14-4107-100 n1_177466_120224 n1_177466_116880 0.011
R14-4108-100 n1_177466_123568 n1_177466_120224 0.011
R14-4109-100 n1_177466_126912 n1_177466_123568 0.011
R14-4110-100 n1_177466_130256 n1_177466_126912 0.011
R14-4111-100 n1_177466_133550 n1_177466_130256 0.010835500000000001
R14-4112-100 n1_177466_133600 n1_177466_133550 0.000164474
R14-4113-100 n1_177466_136944 n1_177466_133600 0.011
R14-4114-100 n1_177466_140288 n1_177466_136944 0.011
R14-4115-100 n1_177466_143632 n1_177466_140288 0.011
R14-4116-100 n1_177466_146976 n1_177466_143632 0.011
R14-4117-100 n1_177466_150320 n1_177466_146976 0.011
R14-4118-100 n1_177466_153664 n1_177466_150320 0.011
R14-4119-100 n1_177466_156046 n1_177466_153664 0.00783553
R14-4120-100 n1_177466_157008 n1_177466_156046 0.00316447
R14-4121-100 n1_177466_160352 n1_177466_157008 0.011
R14-4122-100 n1_177466_163696 n1_177466_160352 0.011
R14-4123-100 n1_177466_167040 n1_177466_163696 0.011
R14-4124-100 n1_177466_170384 n1_177466_167040 0.011
R14-4125-100 n1_177466_173728 n1_177466_170384 0.011
R14-4126-100 n1_177466_177072 n1_177466_173728 0.011
R14-4127-100 n1_177466_177934 n1_177466_177072 0.00283553
R14-4128-100 n1_177466_180416 n1_177466_177934 0.00816447
R14-4129-100 n1_177466_183760 n1_177466_180416 0.011
R14-4130-100 n1_177466_187104 n1_177466_183760 0.011
R14-4131-100 n1_177466_190448 n1_177466_187104 0.011
R14-4132-100 n1_177466_193792 n1_177466_190448 0.011
R14-4133-100 n1_177466_197136 n1_177466_193792 0.011
R14-4134-100 n1_177466_200430 n1_177466_197136 0.010835500000000001
R14-4135-100 n1_177466_200480 n1_177466_200430 0.000164474
R14-4136-100 n1_177466_203824 n1_177466_200480 0.011
R14-4137-100 n1_177466_207168 n1_177466_203824 0.011
R14-4138-100 n1_177466_210512 n1_177466_207168 0.011
R14-4139-100 n1_177466_213856 n1_177466_210512 0.011
R14-4140-100 n1_177466_217200 n1_177466_213856 0.011
R14-4141-100 n1_177466_220544 n1_177466_217200 0.011
R14-4142-100 n1_177466_222318 n1_177466_220544 0.00583553
R14-4143-100 n1_177466_223888 n1_177466_222318 0.00516447
R14-4144-100 n1_177466_227232 n1_177466_223888 0.011
R14-4145-100 n1_177466_230576 n1_177466_227232 0.011
R14-4146-100 n1_177466_233920 n1_177466_230576 0.011
R14-4147-100 n1_177466_237264 n1_177466_233920 0.011
R14-4148-100 n1_177466_240608 n1_177466_237264 0.011
R14-4149-100 n1_177466_243952 n1_177466_240608 0.011
R14-4150-100 n1_177466_244814 n1_177466_243952 0.00283553
R14-4151-100 n1_177466_247296 n1_177466_244814 0.00816447
R14-4152-100 n1_177466_250640 n1_177466_247296 0.011
R14-4153-100 n1_177466_253984 n1_177466_250640 0.011
R14-4154-100 n1_177466_257328 n1_177466_253984 0.011
R14-4155-100 n1_177466_260672 n1_177466_257328 0.011
R14-4156-100 n1_177466_264016 n1_177466_260672 0.011
R14-4157-100 n1_177466_266702 n1_177466_264016 0.00883553
R14-4158-100 n1_177466_267360 n1_177466_266702 0.00216447
R14-4159-100 n1_177466_270704 n1_177466_267360 0.011
R14-4160-100 n1_177466_274048 n1_177466_270704 0.011
R14-4161-100 n1_177466_277392 n1_177466_274048 0.011
R14-4162-100 n1_177466_280736 n1_177466_277392 0.011
R14-4163-100 n1_177466_284080 n1_177466_280736 0.011
R14-4164-100 n1_177466_287424 n1_177466_284080 0.011
R14-4165-100 n1_177466_288590 n1_177466_287424 0.00383553
R14-4166-100 n1_177466_290768 n1_177466_288590 0.007164470000000001
R14-4167-100 n1_177466_294112 n1_177466_290768 0.011
R14-4168-100 n1_177466_297456 n1_177466_294112 0.011
R14-4169-100 n1_177466_300800 n1_177466_297456 0.011
R14-4170-100 n1_177466_304144 n1_177466_300800 0.011
R14-4171-100 n1_177466_307488 n1_177466_304144 0.011
R14-4172-100 n1_177466_310832 n1_177466_307488 0.011
R14-4173-100 n1_177466_311086 n1_177466_310832 0.000835526
R14-4174-100 n1_177466_314176 n1_177466_311086 0.0101645
R14-4175-100 n1_177466_317520 n1_177466_314176 0.011
R14-4176-100 n1_177466_320864 n1_177466_317520 0.011
R14-4177-100 n1_177466_324208 n1_177466_320864 0.011
R14-4178-100 n1_177466_327552 n1_177466_324208 0.011
R14-4179-100 n1_177466_330896 n1_177466_327552 0.011
R14-4180-100 n1_177466_332974 n1_177466_330896 0.006835529999999999
R14-4181-100 n1_177466_334240 n1_177466_332974 0.00416447
R14-4182-100 n1_177466_337584 n1_177466_334240 0.011
R14-4183-100 n1_177466_340928 n1_177466_337584 0.011
R14-4184-100 n1_177466_344272 n1_177466_340928 0.011
R14-4185-100 n1_177466_347616 n1_177466_344272 0.011
R14-4186-100 n1_177466_350960 n1_177466_347616 0.011
R14-4187-100 n1_177466_354304 n1_177466_350960 0.011
R14-4188-100 n1_177466_355470 n1_177466_354304 0.00383553
R14-4189-100 n1_177466_357648 n1_177466_355470 0.007164470000000001
R14-4190-100 n1_177466_360992 n1_177466_357648 0.011
R14-4191-100 n1_177466_364336 n1_177466_360992 0.011
R14-4192-100 n1_177466_367680 n1_177466_364336 0.011
R14-4193-100 n1_177466_371024 n1_177466_367680 0.011
R14-4194-100 n1_177466_374368 n1_177466_371024 0.011
R14-4195-100 n1_177466_377358 n1_177466_374368 0.00983553
R14-4196-100 n1_177466_377712 n1_177466_377358 0.00116447
R14-4197-100 n1_177466_381056 n1_177466_377712 0.011
R14-4198-100 n1_177466_384400 n1_177466_381056 0.011
R14-4199-100 n1_177466_387744 n1_177466_384400 0.011
R14-4200-100 n1_177466_391088 n1_177466_387744 0.011
R14-4201-100 n1_177466_394432 n1_177466_391088 0.011
R14-4202-100 n1_177466_397776 n1_177466_394432 0.011
R14-4203-100 n1_177466_399854 n1_177466_397776 0.006835529999999999
R14-4204-100 n1_177466_401120 n1_177466_399854 0.00416447
R14-4205-100 n1_177466_404464 n1_177466_401120 0.011
R14-4206-100 n1_177466_407808 n1_177466_404464 0.011
R14-4207-100 n1_177466_411152 n1_177466_407808 0.011
R14-4208-100 n1_177466_414496 n1_177466_411152 0.011
R14-4209-100 n1_177466_417840 n1_177466_414496 0.011
R14-4210-100 n1_177466_421184 n1_177466_417840 0.011
R14-4211-100 n1_177466_421742 n1_177466_421184 0.0018355300000000001
R14-4212-100 n1_177466_424528 n1_177466_421742 0.00916447
R14-4213-100 n1_177466_427872 n1_177466_424528 0.011
R14-4214-100 n1_177466_431216 n1_177466_427872 0.011
R14-4215-100 n1_177466_434560 n1_177466_431216 0.011
R14-4216-100 n1_177466_437904 n1_177466_434560 0.011
R14-4217-100 n1_177466_441248 n1_177466_437904 0.011
R14-4218-100 n1_177466_444238 n1_177466_441248 0.00983553
R14-4219-100 n1_177466_444592 n1_177466_444238 0.00116447
R14-4220-100 n1_177466_447936 n1_177466_444592 0.011
R14-4221-100 n1_177466_451280 n1_177466_447936 0.011
R14-4222-100 n1_177466_454624 n1_177466_451280 0.011
R14-4223-100 n1_177466_457968 n1_177466_454624 0.011
R14-4224-100 n1_177466_461312 n1_177466_457968 0.011
R14-4225-100 n1_177466_464656 n1_177466_461312 0.011
R14-4226-100 n1_177466_466126 n1_177466_464656 0.004835529999999999
R14-4227-100 n1_177466_468000 n1_177466_466126 0.00616447
R14-4228-100 n1_177466_471344 n1_177466_468000 0.011
R14-4229-100 n1_177466_474688 n1_177466_471344 0.011
R14-4230-100 n1_177466_478032 n1_177466_474688 0.011
R14-4231-100 n1_177466_481376 n1_177466_478032 0.011
R14-4232-100 n1_177466_484720 n1_177466_481376 0.011
R14-4233-100 n1_177466_488064 n1_177466_484720 0.011
R14-4234-100 n1_177466_488622 n1_177466_488064 0.0018355300000000001
R14-4235-100 n1_177466_491408 n1_177466_488622 0.00916447
R14-4236-100 n1_177466_494752 n1_177466_491408 0.011
R14-4237-100 n1_177466_498096 n1_177466_494752 0.011
R14-4238-100 n1_177466_501440 n1_177466_498096 0.011
R14-4239-100 n1_177466_504784 n1_177466_501440 0.011
R14-4240-100 n1_177466_508128 n1_177466_504784 0.011
R14-4241-100 n1_177466_510510 n1_177466_508128 0.00783553
R14-4242-100 n1_177466_511472 n1_177466_510510 0.00316447
R14-4243-100 n1_177466_514816 n1_177466_511472 0.011
R14-4244-100 n1_177466_518160 n1_177466_514816 0.011
R14-4245-100 n1_177466_521504 n1_177466_518160 0.011
R14-4246-100 n1_177466_524848 n1_177466_521504 0.011
R14-4247-100 n1_177466_528192 n1_177466_524848 0.011
R14-4248-100 n1_177466_531536 n1_177466_528192 0.011
R14-4249-100 n1_177466_532398 n1_177466_531536 0.00283553
R14-4250-100 n1_177466_534880 n1_177466_532398 0.00816447
R14-4251-100 n1_177466_538224 n1_177466_534880 0.011
R14-4252-100 n1_177466_541568 n1_177466_538224 0.011
R14-4253-100 n1_177466_544912 n1_177466_541568 0.011
R14-4254-100 n1_177466_548256 n1_177466_544912 0.011
R14-4255-100 n1_177466_551600 n1_177466_548256 0.011
R14-4256-100 n1_177466_554894 n1_177466_551600 0.010835500000000001
R14-4257-100 n1_177466_554944 n1_177466_554894 0.000164474
R14-4258-100 n1_177466_558288 n1_177466_554944 0.011
R14-4259-100 n1_177466_561632 n1_177466_558288 0.011
R14-4260-100 n1_177466_564976 n1_177466_561632 0.011
R14-4261-100 n1_177466_568320 n1_177466_564976 0.011
R14-4262-100 n1_177466_571664 n1_177466_568320 0.011
R14-4263-100 n1_177466_575008 n1_177466_571664 0.011
R14-4264-100 n1_177466_576782 n1_177466_575008 0.00583553
R14-4265-100 n1_177466_578352 n1_177466_576782 0.00516447
R14-4266-100 n1_177466_581696 n1_177466_578352 0.011
R14-4267-100 n1_177466_585040 n1_177466_581696 0.011
R14-4268-100 n1_177466_588384 n1_177466_585040 0.011
R14-4269-100 n1_177466_591728 n1_177466_588384 0.011
R14-4270-100 n1_177466_595072 n1_177466_591728 0.011
R14-4271-100 n1_177466_598416 n1_177466_595072 0.011
R14-4272-100 n1_177466_599278 n1_177466_598416 0.00283553
R14-4273-100 n1_177466_601760 n1_177466_599278 0.00816447
R14-4274-100 n1_177466_605104 n1_177466_601760 0.011
R14-4275-100 n1_177466_608448 n1_177466_605104 0.011
R14-4276-100 n1_177466_611792 n1_177466_608448 0.011
R14-4277-100 n1_177466_615136 n1_177466_611792 0.011
R14-4278-100 n1_177466_618480 n1_177466_615136 0.011
R14-4279-100 n1_177466_624152 n1_177466_618480 0.018657899999999998
R14-4280-100 n1_177466_626152 n1_177466_624152 0.00657895
R14-4281-100 n1_154970_46000 n1_154970_44000 0.00657895
R14-4282-100 n1_154970_50000 n1_154970_46000 0.0131579
R14-4283-100 n1_154970_53344 n1_154970_50000 0.011
R14-4284-100 n1_154970_56688 n1_154970_53344 0.011
R14-4285-100 n1_154970_60032 n1_154970_56688 0.011
R14-4286-100 n1_154970_63376 n1_154970_60032 0.011
R14-4287-100 n1_154970_66720 n1_154970_63376 0.011
R14-4288-100 n1_154970_67278 n1_154970_66720 0.0018355300000000001
R14-4289-100 n1_154970_70064 n1_154970_67278 0.00916447
R14-4290-100 n1_154970_73408 n1_154970_70064 0.011
R14-4291-100 n1_154970_76752 n1_154970_73408 0.011
R14-4292-100 n1_154970_80096 n1_154970_76752 0.011
R14-4293-100 n1_154970_83440 n1_154970_80096 0.011
R14-4294-100 n1_154970_86784 n1_154970_83440 0.011
R14-4295-100 n1_154970_89166 n1_154970_86784 0.00783553
R14-4296-100 n1_154970_90128 n1_154970_89166 0.00316447
R14-4297-100 n1_154970_93472 n1_154970_90128 0.011
R14-4298-100 n1_154970_96816 n1_154970_93472 0.011
R14-4299-100 n1_154970_100160 n1_154970_96816 0.011
R14-4300-100 n1_154970_103504 n1_154970_100160 0.011
R14-4301-100 n1_154970_106848 n1_154970_103504 0.011
R14-4302-100 n1_154970_110192 n1_154970_106848 0.011
R14-4303-100 n1_154970_111662 n1_154970_110192 0.004835529999999999
R14-4304-100 n1_154970_113536 n1_154970_111662 0.00616447
R14-4305-100 n1_154970_116880 n1_154970_113536 0.011
R14-4306-100 n1_154970_120224 n1_154970_116880 0.011
R14-4307-100 n1_154970_123568 n1_154970_120224 0.011
R14-4308-100 n1_154970_126912 n1_154970_123568 0.011
R14-4309-100 n1_154970_130256 n1_154970_126912 0.011
R14-4310-100 n1_154970_133550 n1_154970_130256 0.010835500000000001
R14-4311-100 n1_154970_133600 n1_154970_133550 0.000164474
R14-4312-100 n1_154970_136944 n1_154970_133600 0.011
R14-4313-100 n1_154970_140288 n1_154970_136944 0.011
R14-4314-100 n1_154970_143632 n1_154970_140288 0.011
R14-4315-100 n1_154970_146976 n1_154970_143632 0.011
R14-4316-100 n1_154970_150320 n1_154970_146976 0.011
R14-4317-100 n1_154970_153664 n1_154970_150320 0.011
R14-4318-100 n1_154970_156046 n1_154970_153664 0.00783553
R14-4319-100 n1_154970_157008 n1_154970_156046 0.00316447
R14-4320-100 n1_154970_160352 n1_154970_157008 0.011
R14-4321-100 n1_154970_163696 n1_154970_160352 0.011
R14-4322-100 n1_154970_167040 n1_154970_163696 0.011
R14-4323-100 n1_154970_170384 n1_154970_167040 0.011
R14-4324-100 n1_154970_173728 n1_154970_170384 0.011
R14-4325-100 n1_154970_177072 n1_154970_173728 0.011
R14-4326-100 n1_154970_177934 n1_154970_177072 0.00283553
R14-4327-100 n1_154970_180416 n1_154970_177934 0.00816447
R14-4328-100 n1_154970_183760 n1_154970_180416 0.011
R14-4329-100 n1_154970_187104 n1_154970_183760 0.011
R14-4330-100 n1_154970_190448 n1_154970_187104 0.011
R14-4331-100 n1_154970_193792 n1_154970_190448 0.011
R14-4332-100 n1_154970_197136 n1_154970_193792 0.011
R14-4333-100 n1_154970_200430 n1_154970_197136 0.010835500000000001
R14-4334-100 n1_154970_200480 n1_154970_200430 0.000164474
R14-4335-100 n1_154970_203824 n1_154970_200480 0.011
R14-4336-100 n1_154970_207168 n1_154970_203824 0.011
R14-4337-100 n1_154970_210512 n1_154970_207168 0.011
R14-4338-100 n1_154970_213856 n1_154970_210512 0.011
R14-4339-100 n1_154970_217200 n1_154970_213856 0.011
R14-4340-100 n1_154970_220544 n1_154970_217200 0.011
R14-4341-100 n1_154970_222318 n1_154970_220544 0.00583553
R14-4342-100 n1_154970_223888 n1_154970_222318 0.00516447
R14-4343-100 n1_154970_227232 n1_154970_223888 0.011
R14-4344-100 n1_154970_230576 n1_154970_227232 0.011
R14-4345-100 n1_154970_233920 n1_154970_230576 0.011
R14-4346-100 n1_154970_237264 n1_154970_233920 0.011
R14-4347-100 n1_154970_240608 n1_154970_237264 0.011
R14-4348-100 n1_154970_243952 n1_154970_240608 0.011
R14-4349-100 n1_154970_244814 n1_154970_243952 0.00283553
R14-4350-100 n1_154970_247296 n1_154970_244814 0.00816447
R14-4351-100 n1_154970_250640 n1_154970_247296 0.011
R14-4352-100 n1_154970_253984 n1_154970_250640 0.011
R14-4353-100 n1_154970_257328 n1_154970_253984 0.011
R14-4354-100 n1_154970_260672 n1_154970_257328 0.011
R14-4355-100 n1_154970_264016 n1_154970_260672 0.011
R14-4356-100 n1_154970_266702 n1_154970_264016 0.00883553
R14-4357-100 n1_154970_267360 n1_154970_266702 0.00216447
R14-4358-100 n1_154970_270704 n1_154970_267360 0.011
R14-4359-100 n1_154970_274048 n1_154970_270704 0.011
R14-4360-100 n1_154970_277392 n1_154970_274048 0.011
R14-4361-100 n1_154970_280736 n1_154970_277392 0.011
R14-4362-100 n1_154970_284080 n1_154970_280736 0.011
R14-4363-100 n1_154970_287424 n1_154970_284080 0.011
R14-4364-100 n1_154970_288590 n1_154970_287424 0.00383553
R14-4365-100 n1_154970_290768 n1_154970_288590 0.007164470000000001
R14-4366-100 n1_154970_294112 n1_154970_290768 0.011
R14-4367-100 n1_154970_297456 n1_154970_294112 0.011
R14-4368-100 n1_154970_300800 n1_154970_297456 0.011
R14-4369-100 n1_154970_304144 n1_154970_300800 0.011
R14-4370-100 n1_154970_307488 n1_154970_304144 0.011
R14-4371-100 n1_154970_310832 n1_154970_307488 0.011
R14-4372-100 n1_154970_311086 n1_154970_310832 0.000835526
R14-4373-100 n1_154970_314176 n1_154970_311086 0.0101645
R14-4374-100 n1_154970_317520 n1_154970_314176 0.011
R14-4375-100 n1_154970_320864 n1_154970_317520 0.011
R14-4376-100 n1_154970_324208 n1_154970_320864 0.011
R14-4377-100 n1_154970_327552 n1_154970_324208 0.011
R14-4378-100 n1_154970_330896 n1_154970_327552 0.011
R14-4379-100 n1_154970_332974 n1_154970_330896 0.006835529999999999
R14-4380-100 n1_154970_334240 n1_154970_332974 0.00416447
R14-4381-100 n1_154970_337584 n1_154970_334240 0.011
R14-4382-100 n1_154970_340928 n1_154970_337584 0.011
R14-4383-100 n1_154970_344272 n1_154970_340928 0.011
R14-4384-100 n1_154970_347616 n1_154970_344272 0.011
R14-4385-100 n1_154970_350960 n1_154970_347616 0.011
R14-4386-100 n1_154970_354304 n1_154970_350960 0.011
R14-4387-100 n1_154970_355470 n1_154970_354304 0.00383553
R14-4388-100 n1_154970_357648 n1_154970_355470 0.007164470000000001
R14-4389-100 n1_154970_360992 n1_154970_357648 0.011
R14-4390-100 n1_154970_364336 n1_154970_360992 0.011
R14-4391-100 n1_154970_367680 n1_154970_364336 0.011
R14-4392-100 n1_154970_371024 n1_154970_367680 0.011
R14-4393-100 n1_154970_374368 n1_154970_371024 0.011
R14-4394-100 n1_154970_377358 n1_154970_374368 0.00983553
R14-4395-100 n1_154970_377712 n1_154970_377358 0.00116447
R14-4396-100 n1_154970_381056 n1_154970_377712 0.011
R14-4397-100 n1_154970_384400 n1_154970_381056 0.011
R14-4398-100 n1_154970_387744 n1_154970_384400 0.011
R14-4399-100 n1_154970_391088 n1_154970_387744 0.011
R14-4400-100 n1_154970_394432 n1_154970_391088 0.011
R14-4401-100 n1_154970_397776 n1_154970_394432 0.011
R14-4402-100 n1_154970_399854 n1_154970_397776 0.006835529999999999
R14-4403-100 n1_154970_401120 n1_154970_399854 0.00416447
R14-4404-100 n1_154970_404464 n1_154970_401120 0.011
R14-4405-100 n1_154970_407808 n1_154970_404464 0.011
R14-4406-100 n1_154970_411152 n1_154970_407808 0.011
R14-4407-100 n1_154970_414496 n1_154970_411152 0.011
R14-4408-100 n1_154970_417840 n1_154970_414496 0.011
R14-4409-100 n1_154970_421184 n1_154970_417840 0.011
R14-4410-100 n1_154970_421742 n1_154970_421184 0.0018355300000000001
R14-4411-100 n1_154970_424528 n1_154970_421742 0.00916447
R14-4412-100 n1_154970_427872 n1_154970_424528 0.011
R14-4413-100 n1_154970_431216 n1_154970_427872 0.011
R14-4414-100 n1_154970_434560 n1_154970_431216 0.011
R14-4415-100 n1_154970_437904 n1_154970_434560 0.011
R14-4416-100 n1_154970_441248 n1_154970_437904 0.011
R14-4417-100 n1_154970_444238 n1_154970_441248 0.00983553
R14-4418-100 n1_154970_444592 n1_154970_444238 0.00116447
R14-4419-100 n1_154970_447936 n1_154970_444592 0.011
R14-4420-100 n1_154970_451280 n1_154970_447936 0.011
R14-4421-100 n1_154970_454624 n1_154970_451280 0.011
R14-4422-100 n1_154970_457968 n1_154970_454624 0.011
R14-4423-100 n1_154970_461312 n1_154970_457968 0.011
R14-4424-100 n1_154970_464656 n1_154970_461312 0.011
R14-4425-100 n1_154970_466126 n1_154970_464656 0.004835529999999999
R14-4426-100 n1_154970_468000 n1_154970_466126 0.00616447
R14-4427-100 n1_154970_471344 n1_154970_468000 0.011
R14-4428-100 n1_154970_474688 n1_154970_471344 0.011
R14-4429-100 n1_154970_478032 n1_154970_474688 0.011
R14-4430-100 n1_154970_481376 n1_154970_478032 0.011
R14-4431-100 n1_154970_484720 n1_154970_481376 0.011
R14-4432-100 n1_154970_488064 n1_154970_484720 0.011
R14-4433-100 n1_154970_488622 n1_154970_488064 0.0018355300000000001
R14-4434-100 n1_154970_491408 n1_154970_488622 0.00916447
R14-4435-100 n1_154970_494752 n1_154970_491408 0.011
R14-4436-100 n1_154970_498096 n1_154970_494752 0.011
R14-4437-100 n1_154970_501440 n1_154970_498096 0.011
R14-4438-100 n1_154970_504784 n1_154970_501440 0.011
R14-4439-100 n1_154970_508128 n1_154970_504784 0.011
R14-4440-100 n1_154970_510510 n1_154970_508128 0.00783553
R14-4441-100 n1_154970_511472 n1_154970_510510 0.00316447
R14-4442-100 n1_154970_514816 n1_154970_511472 0.011
R14-4443-100 n1_154970_518160 n1_154970_514816 0.011
R14-4444-100 n1_154970_521504 n1_154970_518160 0.011
R14-4445-100 n1_154970_524848 n1_154970_521504 0.011
R14-4446-100 n1_154970_528192 n1_154970_524848 0.011
R14-4447-100 n1_154970_531536 n1_154970_528192 0.011
R14-4448-100 n1_154970_532398 n1_154970_531536 0.00283553
R14-4449-100 n1_154970_534880 n1_154970_532398 0.00816447
R14-4450-100 n1_154970_538224 n1_154970_534880 0.011
R14-4451-100 n1_154970_541568 n1_154970_538224 0.011
R14-4452-100 n1_154970_544912 n1_154970_541568 0.011
R14-4453-100 n1_154970_548256 n1_154970_544912 0.011
R14-4454-100 n1_154970_551600 n1_154970_548256 0.011
R14-4455-100 n1_154970_554894 n1_154970_551600 0.010835500000000001
R14-4456-100 n1_154970_554944 n1_154970_554894 0.000164474
R14-4457-100 n1_154970_558288 n1_154970_554944 0.011
R14-4458-100 n1_154970_561632 n1_154970_558288 0.011
R14-4459-100 n1_154970_564976 n1_154970_561632 0.011
R14-4460-100 n1_154970_568320 n1_154970_564976 0.011
R14-4461-100 n1_154970_571664 n1_154970_568320 0.011
R14-4462-100 n1_154970_575008 n1_154970_571664 0.011
R14-4463-100 n1_154970_576782 n1_154970_575008 0.00583553
R14-4464-100 n1_154970_578352 n1_154970_576782 0.00516447
R14-4465-100 n1_154970_581696 n1_154970_578352 0.011
R14-4466-100 n1_154970_585040 n1_154970_581696 0.011
R14-4467-100 n1_154970_588384 n1_154970_585040 0.011
R14-4468-100 n1_154970_591728 n1_154970_588384 0.011
R14-4469-100 n1_154970_595072 n1_154970_591728 0.011
R14-4470-100 n1_154970_598416 n1_154970_595072 0.011
R14-4471-100 n1_154970_599278 n1_154970_598416 0.00283553
R14-4472-100 n1_154970_601760 n1_154970_599278 0.00816447
R14-4473-100 n1_154970_605104 n1_154970_601760 0.011
R14-4474-100 n1_154970_608448 n1_154970_605104 0.011
R14-4475-100 n1_154970_611792 n1_154970_608448 0.011
R14-4476-100 n1_154970_615136 n1_154970_611792 0.011
R14-4477-100 n1_154970_618480 n1_154970_615136 0.011
R14-4478-100 n1_154970_624152 n1_154970_618480 0.018657899999999998
R14-4479-100 n1_154970_626152 n1_154970_624152 0.00657895
R14-4480-100 n1_132778_46000 n1_132778_44000 0.00657895
R14-4481-100 n1_132778_50000 n1_132778_46000 0.0131579
R14-4482-100 n1_132778_53344 n1_132778_50000 0.011
R14-4483-100 n1_132778_56688 n1_132778_53344 0.011
R14-4484-100 n1_132778_60032 n1_132778_56688 0.011
R14-4485-100 n1_132778_63376 n1_132778_60032 0.011
R14-4486-100 n1_132778_66720 n1_132778_63376 0.011
R14-4487-100 n1_132778_67278 n1_132778_66720 0.0018355300000000001
R14-4488-100 n1_132778_70064 n1_132778_67278 0.00916447
R14-4489-100 n1_132778_73408 n1_132778_70064 0.011
R14-4490-100 n1_132778_76752 n1_132778_73408 0.011
R14-4491-100 n1_132778_80096 n1_132778_76752 0.011
R14-4492-100 n1_132778_83440 n1_132778_80096 0.011
R14-4493-100 n1_132778_86784 n1_132778_83440 0.011
R14-4494-100 n1_132778_89166 n1_132778_86784 0.00783553
R14-4495-100 n1_132778_90128 n1_132778_89166 0.00316447
R14-4496-100 n1_132778_93472 n1_132778_90128 0.011
R14-4497-100 n1_132778_96816 n1_132778_93472 0.011
R14-4498-100 n1_132778_100160 n1_132778_96816 0.011
R14-4499-100 n1_132778_103504 n1_132778_100160 0.011
R14-4500-100 n1_132778_106848 n1_132778_103504 0.011
R14-4501-100 n1_132778_110192 n1_132778_106848 0.011
R14-4502-100 n1_132778_111662 n1_132778_110192 0.004835529999999999
R14-4503-100 n1_132778_113536 n1_132778_111662 0.00616447
R14-4504-100 n1_132778_116880 n1_132778_113536 0.011
R14-4505-100 n1_132778_120224 n1_132778_116880 0.011
R14-4506-100 n1_132778_123568 n1_132778_120224 0.011
R14-4507-100 n1_132778_126912 n1_132778_123568 0.011
R14-4508-100 n1_132778_130256 n1_132778_126912 0.011
R14-4509-100 n1_132778_133550 n1_132778_130256 0.010835500000000001
R14-4510-100 n1_132778_133600 n1_132778_133550 0.000164474
R14-4511-100 n1_132778_136944 n1_132778_133600 0.011
R14-4512-100 n1_132778_140288 n1_132778_136944 0.011
R14-4513-100 n1_132778_143632 n1_132778_140288 0.011
R14-4514-100 n1_132778_146976 n1_132778_143632 0.011
R14-4515-100 n1_132778_150320 n1_132778_146976 0.011
R14-4516-100 n1_132778_153664 n1_132778_150320 0.011
R14-4517-100 n1_132778_156046 n1_132778_153664 0.00783553
R14-4518-100 n1_132778_157008 n1_132778_156046 0.00316447
R14-4519-100 n1_132778_160352 n1_132778_157008 0.011
R14-4520-100 n1_132778_163696 n1_132778_160352 0.011
R14-4521-100 n1_132778_167040 n1_132778_163696 0.011
R14-4522-100 n1_132778_170384 n1_132778_167040 0.011
R14-4523-100 n1_132778_173728 n1_132778_170384 0.011
R14-4524-100 n1_132778_177072 n1_132778_173728 0.011
R14-4525-100 n1_132778_177934 n1_132778_177072 0.00283553
R14-4526-100 n1_132778_180416 n1_132778_177934 0.00816447
R14-4527-100 n1_132778_183760 n1_132778_180416 0.011
R14-4528-100 n1_132778_187104 n1_132778_183760 0.011
R14-4529-100 n1_132778_190448 n1_132778_187104 0.011
R14-4530-100 n1_132778_193792 n1_132778_190448 0.011
R14-4531-100 n1_132778_197136 n1_132778_193792 0.011
R14-4532-100 n1_132778_200430 n1_132778_197136 0.010835500000000001
R14-4533-100 n1_132778_200480 n1_132778_200430 0.000164474
R14-4534-100 n1_132778_203824 n1_132778_200480 0.011
R14-4535-100 n1_132778_207168 n1_132778_203824 0.011
R14-4536-100 n1_132778_210512 n1_132778_207168 0.011
R14-4537-100 n1_132778_213856 n1_132778_210512 0.011
R14-4538-100 n1_132778_217200 n1_132778_213856 0.011
R14-4539-100 n1_132778_220544 n1_132778_217200 0.011
R14-4540-100 n1_132778_222318 n1_132778_220544 0.00583553
R14-4541-100 n1_132778_223888 n1_132778_222318 0.00516447
R14-4542-100 n1_132778_227232 n1_132778_223888 0.011
R14-4543-100 n1_132778_230576 n1_132778_227232 0.011
R14-4544-100 n1_132778_233920 n1_132778_230576 0.011
R14-4545-100 n1_132778_237264 n1_132778_233920 0.011
R14-4546-100 n1_132778_240608 n1_132778_237264 0.011
R14-4547-100 n1_132778_243952 n1_132778_240608 0.011
R14-4548-100 n1_132778_244814 n1_132778_243952 0.00283553
R14-4549-100 n1_132778_247296 n1_132778_244814 0.00816447
R14-4550-100 n1_132778_250640 n1_132778_247296 0.011
R14-4551-100 n1_132778_253984 n1_132778_250640 0.011
R14-4552-100 n1_132778_257328 n1_132778_253984 0.011
R14-4553-100 n1_132778_260672 n1_132778_257328 0.011
R14-4554-100 n1_132778_264016 n1_132778_260672 0.011
R14-4555-100 n1_132778_266702 n1_132778_264016 0.00883553
R14-4556-100 n1_132778_267360 n1_132778_266702 0.00216447
R14-4557-100 n1_132778_270704 n1_132778_267360 0.011
R14-4558-100 n1_132778_274048 n1_132778_270704 0.011
R14-4559-100 n1_132778_277392 n1_132778_274048 0.011
R14-4560-100 n1_132778_280736 n1_132778_277392 0.011
R14-4561-100 n1_132778_284080 n1_132778_280736 0.011
R14-4562-100 n1_132778_287424 n1_132778_284080 0.011
R14-4563-100 n1_132778_288590 n1_132778_287424 0.00383553
R14-4564-100 n1_132778_290768 n1_132778_288590 0.007164470000000001
R14-4565-100 n1_132778_294112 n1_132778_290768 0.011
R14-4566-100 n1_132778_297456 n1_132778_294112 0.011
R14-4567-100 n1_132778_300800 n1_132778_297456 0.011
R14-4568-100 n1_132778_304144 n1_132778_300800 0.011
R14-4569-100 n1_132778_307488 n1_132778_304144 0.011
R14-4570-100 n1_132778_310832 n1_132778_307488 0.011
R14-4571-100 n1_132778_311086 n1_132778_310832 0.000835526
R14-4572-100 n1_132778_314176 n1_132778_311086 0.0101645
R14-4573-100 n1_132778_317520 n1_132778_314176 0.011
R14-4574-100 n1_132778_320864 n1_132778_317520 0.011
R14-4575-100 n1_132778_324208 n1_132778_320864 0.011
R14-4576-100 n1_132778_327552 n1_132778_324208 0.011
R14-4577-100 n1_132778_330896 n1_132778_327552 0.011
R14-4578-100 n1_132778_332974 n1_132778_330896 0.006835529999999999
R14-4579-100 n1_132778_334240 n1_132778_332974 0.00416447
R14-4580-100 n1_132778_337584 n1_132778_334240 0.011
R14-4581-100 n1_132778_340928 n1_132778_337584 0.011
R14-4582-100 n1_132778_344272 n1_132778_340928 0.011
R14-4583-100 n1_132778_347616 n1_132778_344272 0.011
R14-4584-100 n1_132778_350960 n1_132778_347616 0.011
R14-4585-100 n1_132778_354304 n1_132778_350960 0.011
R14-4586-100 n1_132778_355470 n1_132778_354304 0.00383553
R14-4587-100 n1_132778_357648 n1_132778_355470 0.007164470000000001
R14-4588-100 n1_132778_360992 n1_132778_357648 0.011
R14-4589-100 n1_132778_364336 n1_132778_360992 0.011
R14-4590-100 n1_132778_367680 n1_132778_364336 0.011
R14-4591-100 n1_132778_371024 n1_132778_367680 0.011
R14-4592-100 n1_132778_374368 n1_132778_371024 0.011
R14-4593-100 n1_132778_377358 n1_132778_374368 0.00983553
R14-4594-100 n1_132778_377712 n1_132778_377358 0.00116447
R14-4595-100 n1_132778_381056 n1_132778_377712 0.011
R14-4596-100 n1_132778_384400 n1_132778_381056 0.011
R14-4597-100 n1_132778_387744 n1_132778_384400 0.011
R14-4598-100 n1_132778_391088 n1_132778_387744 0.011
R14-4599-100 n1_132778_394432 n1_132778_391088 0.011
R14-4600-100 n1_132778_397776 n1_132778_394432 0.011
R14-4601-100 n1_132778_399854 n1_132778_397776 0.006835529999999999
R14-4602-100 n1_132778_401120 n1_132778_399854 0.00416447
R14-4603-100 n1_132778_404464 n1_132778_401120 0.011
R14-4604-100 n1_132778_407808 n1_132778_404464 0.011
R14-4605-100 n1_132778_411152 n1_132778_407808 0.011
R14-4606-100 n1_132778_414496 n1_132778_411152 0.011
R14-4607-100 n1_132778_417840 n1_132778_414496 0.011
R14-4608-100 n1_132778_421184 n1_132778_417840 0.011
R14-4609-100 n1_132778_421742 n1_132778_421184 0.0018355300000000001
R14-4610-100 n1_132778_424528 n1_132778_421742 0.00916447
R14-4611-100 n1_132778_427872 n1_132778_424528 0.011
R14-4612-100 n1_132778_431216 n1_132778_427872 0.011
R14-4613-100 n1_132778_434560 n1_132778_431216 0.011
R14-4614-100 n1_132778_437904 n1_132778_434560 0.011
R14-4615-100 n1_132778_441248 n1_132778_437904 0.011
R14-4616-100 n1_132778_444238 n1_132778_441248 0.00983553
R14-4617-100 n1_132778_444592 n1_132778_444238 0.00116447
R14-4618-100 n1_132778_447936 n1_132778_444592 0.011
R14-4619-100 n1_132778_451280 n1_132778_447936 0.011
R14-4620-100 n1_132778_454624 n1_132778_451280 0.011
R14-4621-100 n1_132778_457968 n1_132778_454624 0.011
R14-4622-100 n1_132778_461312 n1_132778_457968 0.011
R14-4623-100 n1_132778_464656 n1_132778_461312 0.011
R14-4624-100 n1_132778_466126 n1_132778_464656 0.004835529999999999
R14-4625-100 n1_132778_468000 n1_132778_466126 0.00616447
R14-4626-100 n1_132778_471344 n1_132778_468000 0.011
R14-4627-100 n1_132778_474688 n1_132778_471344 0.011
R14-4628-100 n1_132778_478032 n1_132778_474688 0.011
R14-4629-100 n1_132778_481376 n1_132778_478032 0.011
R14-4630-100 n1_132778_484720 n1_132778_481376 0.011
R14-4631-100 n1_132778_488064 n1_132778_484720 0.011
R14-4632-100 n1_132778_488622 n1_132778_488064 0.0018355300000000001
R14-4633-100 n1_132778_491408 n1_132778_488622 0.00916447
R14-4634-100 n1_132778_494752 n1_132778_491408 0.011
R14-4635-100 n1_132778_498096 n1_132778_494752 0.011
R14-4636-100 n1_132778_501440 n1_132778_498096 0.011
R14-4637-100 n1_132778_504784 n1_132778_501440 0.011
R14-4638-100 n1_132778_508128 n1_132778_504784 0.011
R14-4639-100 n1_132778_510510 n1_132778_508128 0.00783553
R14-4640-100 n1_132778_511472 n1_132778_510510 0.00316447
R14-4641-100 n1_132778_514816 n1_132778_511472 0.011
R14-4642-100 n1_132778_518160 n1_132778_514816 0.011
R14-4643-100 n1_132778_521504 n1_132778_518160 0.011
R14-4644-100 n1_132778_524848 n1_132778_521504 0.011
R14-4645-100 n1_132778_528192 n1_132778_524848 0.011
R14-4646-100 n1_132778_531536 n1_132778_528192 0.011
R14-4647-100 n1_132778_532398 n1_132778_531536 0.00283553
R14-4648-100 n1_132778_534880 n1_132778_532398 0.00816447
R14-4649-100 n1_132778_538224 n1_132778_534880 0.011
R14-4650-100 n1_132778_541568 n1_132778_538224 0.011
R14-4651-100 n1_132778_544912 n1_132778_541568 0.011
R14-4652-100 n1_132778_548256 n1_132778_544912 0.011
R14-4653-100 n1_132778_551600 n1_132778_548256 0.011
R14-4654-100 n1_132778_554894 n1_132778_551600 0.010835500000000001
R14-4655-100 n1_132778_554944 n1_132778_554894 0.000164474
R14-4656-100 n1_132778_558288 n1_132778_554944 0.011
R14-4657-100 n1_132778_561632 n1_132778_558288 0.011
R14-4658-100 n1_132778_564976 n1_132778_561632 0.011
R14-4659-100 n1_132778_568320 n1_132778_564976 0.011
R14-4660-100 n1_132778_571664 n1_132778_568320 0.011
R14-4661-100 n1_132778_575008 n1_132778_571664 0.011
R14-4662-100 n1_132778_576782 n1_132778_575008 0.00583553
R14-4663-100 n1_132778_578352 n1_132778_576782 0.00516447
R14-4664-100 n1_132778_581696 n1_132778_578352 0.011
R14-4665-100 n1_132778_585040 n1_132778_581696 0.011
R14-4666-100 n1_132778_588384 n1_132778_585040 0.011
R14-4667-100 n1_132778_591728 n1_132778_588384 0.011
R14-4668-100 n1_132778_595072 n1_132778_591728 0.011
R14-4669-100 n1_132778_598416 n1_132778_595072 0.011
R14-4670-100 n1_132778_599278 n1_132778_598416 0.00283553
R14-4671-100 n1_132778_601760 n1_132778_599278 0.00816447
R14-4672-100 n1_132778_605104 n1_132778_601760 0.011
R14-4673-100 n1_132778_608448 n1_132778_605104 0.011
R14-4674-100 n1_132778_611792 n1_132778_608448 0.011
R14-4675-100 n1_132778_615136 n1_132778_611792 0.011
R14-4676-100 n1_132778_618480 n1_132778_615136 0.011
R14-4677-100 n1_132778_624152 n1_132778_618480 0.018657899999999998
R14-4678-100 n1_132778_626152 n1_132778_624152 0.00657895
R14-4679-100 n1_110282_46000 n1_110282_44000 0.00657895
R14-4680-100 n1_110282_50000 n1_110282_46000 0.0131579
R14-4681-100 n1_110282_53344 n1_110282_50000 0.011
R14-4682-100 n1_110282_56688 n1_110282_53344 0.011
R14-4683-100 n1_110282_60032 n1_110282_56688 0.011
R14-4684-100 n1_110282_63376 n1_110282_60032 0.011
R14-4685-100 n1_110282_66720 n1_110282_63376 0.011
R14-4686-100 n1_110282_67278 n1_110282_66720 0.0018355300000000001
R14-4687-100 n1_110282_70064 n1_110282_67278 0.00916447
R14-4688-100 n1_110282_73408 n1_110282_70064 0.011
R14-4689-100 n1_110282_76752 n1_110282_73408 0.011
R14-4690-100 n1_110282_80096 n1_110282_76752 0.011
R14-4691-100 n1_110282_83440 n1_110282_80096 0.011
R14-4692-100 n1_110282_86784 n1_110282_83440 0.011
R14-4693-100 n1_110282_89166 n1_110282_86784 0.00783553
R14-4694-100 n1_110282_90128 n1_110282_89166 0.00316447
R14-4695-100 n1_110282_93472 n1_110282_90128 0.011
R14-4696-100 n1_110282_96816 n1_110282_93472 0.011
R14-4697-100 n1_110282_100160 n1_110282_96816 0.011
R14-4698-100 n1_110282_103504 n1_110282_100160 0.011
R14-4699-100 n1_110282_106848 n1_110282_103504 0.011
R14-4700-100 n1_110282_110192 n1_110282_106848 0.011
R14-4701-100 n1_110282_111662 n1_110282_110192 0.004835529999999999
R14-4702-100 n1_110282_113536 n1_110282_111662 0.00616447
R14-4703-100 n1_110282_116880 n1_110282_113536 0.011
R14-4704-100 n1_110282_120224 n1_110282_116880 0.011
R14-4705-100 n1_110282_123568 n1_110282_120224 0.011
R14-4706-100 n1_110282_126912 n1_110282_123568 0.011
R14-4707-100 n1_110282_130256 n1_110282_126912 0.011
R14-4708-100 n1_110282_133550 n1_110282_130256 0.010835500000000001
R14-4709-100 n1_110282_133600 n1_110282_133550 0.000164474
R14-4710-100 n1_110282_136944 n1_110282_133600 0.011
R14-4711-100 n1_110282_140288 n1_110282_136944 0.011
R14-4712-100 n1_110282_143632 n1_110282_140288 0.011
R14-4713-100 n1_110282_146976 n1_110282_143632 0.011
R14-4714-100 n1_110282_150320 n1_110282_146976 0.011
R14-4715-100 n1_110282_153664 n1_110282_150320 0.011
R14-4716-100 n1_110282_156046 n1_110282_153664 0.00783553
R14-4717-100 n1_110282_157008 n1_110282_156046 0.00316447
R14-4718-100 n1_110282_160352 n1_110282_157008 0.011
R14-4719-100 n1_110282_163696 n1_110282_160352 0.011
R14-4720-100 n1_110282_167040 n1_110282_163696 0.011
R14-4721-100 n1_110282_170384 n1_110282_167040 0.011
R14-4722-100 n1_110282_173728 n1_110282_170384 0.011
R14-4723-100 n1_110282_177072 n1_110282_173728 0.011
R14-4724-100 n1_110282_177934 n1_110282_177072 0.00283553
R14-4725-100 n1_110282_180416 n1_110282_177934 0.00816447
R14-4726-100 n1_110282_183760 n1_110282_180416 0.011
R14-4727-100 n1_110282_187104 n1_110282_183760 0.011
R14-4728-100 n1_110282_190448 n1_110282_187104 0.011
R14-4729-100 n1_110282_193792 n1_110282_190448 0.011
R14-4730-100 n1_110282_197136 n1_110282_193792 0.011
R14-4731-100 n1_110282_200430 n1_110282_197136 0.010835500000000001
R14-4732-100 n1_110282_200480 n1_110282_200430 0.000164474
R14-4733-100 n1_110282_203824 n1_110282_200480 0.011
R14-4734-100 n1_110282_207168 n1_110282_203824 0.011
R14-4735-100 n1_110282_210512 n1_110282_207168 0.011
R14-4736-100 n1_110282_213856 n1_110282_210512 0.011
R14-4737-100 n1_110282_217200 n1_110282_213856 0.011
R14-4738-100 n1_110282_220544 n1_110282_217200 0.011
R14-4739-100 n1_110282_222318 n1_110282_220544 0.00583553
R14-4740-100 n1_110282_223888 n1_110282_222318 0.00516447
R14-4741-100 n1_110282_227232 n1_110282_223888 0.011
R14-4742-100 n1_110282_230576 n1_110282_227232 0.011
R14-4743-100 n1_110282_233920 n1_110282_230576 0.011
R14-4744-100 n1_110282_237264 n1_110282_233920 0.011
R14-4745-100 n1_110282_240608 n1_110282_237264 0.011
R14-4746-100 n1_110282_243952 n1_110282_240608 0.011
R14-4747-100 n1_110282_244814 n1_110282_243952 0.00283553
R14-4748-100 n1_110282_247296 n1_110282_244814 0.00816447
R14-4749-100 n1_110282_250640 n1_110282_247296 0.011
R14-4750-100 n1_110282_253984 n1_110282_250640 0.011
R14-4751-100 n1_110282_257328 n1_110282_253984 0.011
R14-4752-100 n1_110282_260672 n1_110282_257328 0.011
R14-4753-100 n1_110282_264016 n1_110282_260672 0.011
R14-4754-100 n1_110282_266702 n1_110282_264016 0.00883553
R14-4755-100 n1_110282_267360 n1_110282_266702 0.00216447
R14-4756-100 n1_110282_270704 n1_110282_267360 0.011
R14-4757-100 n1_110282_274048 n1_110282_270704 0.011
R14-4758-100 n1_110282_277392 n1_110282_274048 0.011
R14-4759-100 n1_110282_280736 n1_110282_277392 0.011
R14-4760-100 n1_110282_284080 n1_110282_280736 0.011
R14-4761-100 n1_110282_287424 n1_110282_284080 0.011
R14-4762-100 n1_110282_288590 n1_110282_287424 0.00383553
R14-4763-100 n1_110282_290768 n1_110282_288590 0.007164470000000001
R14-4764-100 n1_110282_294112 n1_110282_290768 0.011
R14-4765-100 n1_110282_297456 n1_110282_294112 0.011
R14-4766-100 n1_110282_300800 n1_110282_297456 0.011
R14-4767-100 n1_110282_304144 n1_110282_300800 0.011
R14-4768-100 n1_110282_307488 n1_110282_304144 0.011
R14-4769-100 n1_110282_310832 n1_110282_307488 0.011
R14-4770-100 n1_110282_311086 n1_110282_310832 0.000835526
R14-4771-100 n1_110282_314176 n1_110282_311086 0.0101645
R14-4772-100 n1_110282_317520 n1_110282_314176 0.011
R14-4773-100 n1_110282_320864 n1_110282_317520 0.011
R14-4774-100 n1_110282_324208 n1_110282_320864 0.011
R14-4775-100 n1_110282_327552 n1_110282_324208 0.011
R14-4776-100 n1_110282_330896 n1_110282_327552 0.011
R14-4777-100 n1_110282_332974 n1_110282_330896 0.006835529999999999
R14-4778-100 n1_110282_334240 n1_110282_332974 0.00416447
R14-4779-100 n1_110282_337584 n1_110282_334240 0.011
R14-4780-100 n1_110282_340928 n1_110282_337584 0.011
R14-4781-100 n1_110282_344272 n1_110282_340928 0.011
R14-4782-100 n1_110282_347616 n1_110282_344272 0.011
R14-4783-100 n1_110282_350960 n1_110282_347616 0.011
R14-4784-100 n1_110282_354304 n1_110282_350960 0.011
R14-4785-100 n1_110282_355470 n1_110282_354304 0.00383553
R14-4786-100 n1_110282_357648 n1_110282_355470 0.007164470000000001
R14-4787-100 n1_110282_360992 n1_110282_357648 0.011
R14-4788-100 n1_110282_364336 n1_110282_360992 0.011
R14-4789-100 n1_110282_367680 n1_110282_364336 0.011
R14-4790-100 n1_110282_371024 n1_110282_367680 0.011
R14-4791-100 n1_110282_374368 n1_110282_371024 0.011
R14-4792-100 n1_110282_377358 n1_110282_374368 0.00983553
R14-4793-100 n1_110282_377712 n1_110282_377358 0.00116447
R14-4794-100 n1_110282_381056 n1_110282_377712 0.011
R14-4795-100 n1_110282_384400 n1_110282_381056 0.011
R14-4796-100 n1_110282_387744 n1_110282_384400 0.011
R14-4797-100 n1_110282_391088 n1_110282_387744 0.011
R14-4798-100 n1_110282_394432 n1_110282_391088 0.011
R14-4799-100 n1_110282_397776 n1_110282_394432 0.011
R14-4800-100 n1_110282_399854 n1_110282_397776 0.006835529999999999
R14-4801-100 n1_110282_401120 n1_110282_399854 0.00416447
R14-4802-100 n1_110282_404464 n1_110282_401120 0.011
R14-4803-100 n1_110282_407808 n1_110282_404464 0.011
R14-4804-100 n1_110282_411152 n1_110282_407808 0.011
R14-4805-100 n1_110282_414496 n1_110282_411152 0.011
R14-4806-100 n1_110282_417840 n1_110282_414496 0.011
R14-4807-100 n1_110282_421184 n1_110282_417840 0.011
R14-4808-100 n1_110282_421742 n1_110282_421184 0.0018355300000000001
R14-4809-100 n1_110282_424528 n1_110282_421742 0.00916447
R14-4810-100 n1_110282_427872 n1_110282_424528 0.011
R14-4811-100 n1_110282_431216 n1_110282_427872 0.011
R14-4812-100 n1_110282_434560 n1_110282_431216 0.011
R14-4813-100 n1_110282_437904 n1_110282_434560 0.011
R14-4814-100 n1_110282_441248 n1_110282_437904 0.011
R14-4815-100 n1_110282_444238 n1_110282_441248 0.00983553
R14-4816-100 n1_110282_444592 n1_110282_444238 0.00116447
R14-4817-100 n1_110282_447936 n1_110282_444592 0.011
R14-4818-100 n1_110282_451280 n1_110282_447936 0.011
R14-4819-100 n1_110282_454624 n1_110282_451280 0.011
R14-4820-100 n1_110282_457968 n1_110282_454624 0.011
R14-4821-100 n1_110282_461312 n1_110282_457968 0.011
R14-4822-100 n1_110282_464656 n1_110282_461312 0.011
R14-4823-100 n1_110282_466126 n1_110282_464656 0.004835529999999999
R14-4824-100 n1_110282_468000 n1_110282_466126 0.00616447
R14-4825-100 n1_110282_471344 n1_110282_468000 0.011
R14-4826-100 n1_110282_474688 n1_110282_471344 0.011
R14-4827-100 n1_110282_478032 n1_110282_474688 0.011
R14-4828-100 n1_110282_481376 n1_110282_478032 0.011
R14-4829-100 n1_110282_484720 n1_110282_481376 0.011
R14-4830-100 n1_110282_488064 n1_110282_484720 0.011
R14-4831-100 n1_110282_488622 n1_110282_488064 0.0018355300000000001
R14-4832-100 n1_110282_491408 n1_110282_488622 0.00916447
R14-4833-100 n1_110282_494752 n1_110282_491408 0.011
R14-4834-100 n1_110282_498096 n1_110282_494752 0.011
R14-4835-100 n1_110282_501440 n1_110282_498096 0.011
R14-4836-100 n1_110282_504784 n1_110282_501440 0.011
R14-4837-100 n1_110282_508128 n1_110282_504784 0.011
R14-4838-100 n1_110282_510510 n1_110282_508128 0.00783553
R14-4839-100 n1_110282_511472 n1_110282_510510 0.00316447
R14-4840-100 n1_110282_514816 n1_110282_511472 0.011
R14-4841-100 n1_110282_518160 n1_110282_514816 0.011
R14-4842-100 n1_110282_521504 n1_110282_518160 0.011
R14-4843-100 n1_110282_524848 n1_110282_521504 0.011
R14-4844-100 n1_110282_528192 n1_110282_524848 0.011
R14-4845-100 n1_110282_531536 n1_110282_528192 0.011
R14-4846-100 n1_110282_532398 n1_110282_531536 0.00283553
R14-4847-100 n1_110282_534880 n1_110282_532398 0.00816447
R14-4848-100 n1_110282_538224 n1_110282_534880 0.011
R14-4849-100 n1_110282_541568 n1_110282_538224 0.011
R14-4850-100 n1_110282_544912 n1_110282_541568 0.011
R14-4851-100 n1_110282_548256 n1_110282_544912 0.011
R14-4852-100 n1_110282_551600 n1_110282_548256 0.011
R14-4853-100 n1_110282_554894 n1_110282_551600 0.010835500000000001
R14-4854-100 n1_110282_554944 n1_110282_554894 0.000164474
R14-4855-100 n1_110282_558288 n1_110282_554944 0.011
R14-4856-100 n1_110282_561632 n1_110282_558288 0.011
R14-4857-100 n1_110282_564976 n1_110282_561632 0.011
R14-4858-100 n1_110282_568320 n1_110282_564976 0.011
R14-4859-100 n1_110282_571664 n1_110282_568320 0.011
R14-4860-100 n1_110282_575008 n1_110282_571664 0.011
R14-4861-100 n1_110282_576782 n1_110282_575008 0.00583553
R14-4862-100 n1_110282_578352 n1_110282_576782 0.00516447
R14-4863-100 n1_110282_581696 n1_110282_578352 0.011
R14-4864-100 n1_110282_585040 n1_110282_581696 0.011
R14-4865-100 n1_110282_588384 n1_110282_585040 0.011
R14-4866-100 n1_110282_591728 n1_110282_588384 0.011
R14-4867-100 n1_110282_595072 n1_110282_591728 0.011
R14-4868-100 n1_110282_598416 n1_110282_595072 0.011
R14-4869-100 n1_110282_599278 n1_110282_598416 0.00283553
R14-4870-100 n1_110282_601760 n1_110282_599278 0.00816447
R14-4871-100 n1_110282_605104 n1_110282_601760 0.011
R14-4872-100 n1_110282_608448 n1_110282_605104 0.011
R14-4873-100 n1_110282_611792 n1_110282_608448 0.011
R14-4874-100 n1_110282_615136 n1_110282_611792 0.011
R14-4875-100 n1_110282_618480 n1_110282_615136 0.011
R14-4876-100 n1_110282_624152 n1_110282_618480 0.018657899999999998
R14-4877-100 n1_110282_626152 n1_110282_624152 0.00657895
R14-4878-100 n1_88090_46000 n1_88090_44000 0.00657895
R14-4879-100 n1_88090_50000 n1_88090_46000 0.0131579
R14-4880-100 n1_88090_53344 n1_88090_50000 0.011
R14-4881-100 n1_88090_56688 n1_88090_53344 0.011
R14-4882-100 n1_88090_60032 n1_88090_56688 0.011
R14-4883-100 n1_88090_63376 n1_88090_60032 0.011
R14-4884-100 n1_88090_66720 n1_88090_63376 0.011
R14-4885-100 n1_88090_67278 n1_88090_66720 0.0018355300000000001
R14-4886-100 n1_88090_70064 n1_88090_67278 0.00916447
R14-4887-100 n1_88090_73408 n1_88090_70064 0.011
R14-4888-100 n1_88090_76752 n1_88090_73408 0.011
R14-4889-100 n1_88090_80096 n1_88090_76752 0.011
R14-4890-100 n1_88090_83440 n1_88090_80096 0.011
R14-4891-100 n1_88090_86784 n1_88090_83440 0.011
R14-4892-100 n1_88090_89166 n1_88090_86784 0.00783553
R14-4893-100 n1_88090_90128 n1_88090_89166 0.00316447
R14-4894-100 n1_88090_93472 n1_88090_90128 0.011
R14-4895-100 n1_88090_96816 n1_88090_93472 0.011
R14-4896-100 n1_88090_100160 n1_88090_96816 0.011
R14-4897-100 n1_88090_103504 n1_88090_100160 0.011
R14-4898-100 n1_88090_106848 n1_88090_103504 0.011
R14-4899-100 n1_88090_110192 n1_88090_106848 0.011
R14-4900-100 n1_88090_111662 n1_88090_110192 0.004835529999999999
R14-4901-100 n1_88090_113536 n1_88090_111662 0.00616447
R14-4902-100 n1_88090_116880 n1_88090_113536 0.011
R14-4903-100 n1_88090_120224 n1_88090_116880 0.011
R14-4904-100 n1_88090_123568 n1_88090_120224 0.011
R14-4905-100 n1_88090_126912 n1_88090_123568 0.011
R14-4906-100 n1_88090_130256 n1_88090_126912 0.011
R14-4907-100 n1_88090_133550 n1_88090_130256 0.010835500000000001
R14-4908-100 n1_88090_133600 n1_88090_133550 0.000164474
R14-4909-100 n1_88090_136944 n1_88090_133600 0.011
R14-4910-100 n1_88090_140288 n1_88090_136944 0.011
R14-4911-100 n1_88090_143632 n1_88090_140288 0.011
R14-4912-100 n1_88090_146976 n1_88090_143632 0.011
R14-4913-100 n1_88090_150320 n1_88090_146976 0.011
R14-4914-100 n1_88090_153664 n1_88090_150320 0.011
R14-4915-100 n1_88090_156046 n1_88090_153664 0.00783553
R14-4916-100 n1_88090_157008 n1_88090_156046 0.00316447
R14-4917-100 n1_88090_160352 n1_88090_157008 0.011
R14-4918-100 n1_88090_163696 n1_88090_160352 0.011
R14-4919-100 n1_88090_167040 n1_88090_163696 0.011
R14-4920-100 n1_88090_170384 n1_88090_167040 0.011
R14-4921-100 n1_88090_173728 n1_88090_170384 0.011
R14-4922-100 n1_88090_177072 n1_88090_173728 0.011
R14-4923-100 n1_88090_177934 n1_88090_177072 0.00283553
R14-4924-100 n1_88090_180416 n1_88090_177934 0.00816447
R14-4925-100 n1_88090_183760 n1_88090_180416 0.011
R14-4926-100 n1_88090_187104 n1_88090_183760 0.011
R14-4927-100 n1_88090_190448 n1_88090_187104 0.011
R14-4928-100 n1_88090_193792 n1_88090_190448 0.011
R14-4929-100 n1_88090_197136 n1_88090_193792 0.011
R14-4930-100 n1_88090_200430 n1_88090_197136 0.010835500000000001
R14-4931-100 n1_88090_200480 n1_88090_200430 0.000164474
R14-4932-100 n1_88090_203824 n1_88090_200480 0.011
R14-4933-100 n1_88090_207168 n1_88090_203824 0.011
R14-4934-100 n1_88090_210512 n1_88090_207168 0.011
R14-4935-100 n1_88090_213856 n1_88090_210512 0.011
R14-4936-100 n1_88090_217200 n1_88090_213856 0.011
R14-4937-100 n1_88090_220544 n1_88090_217200 0.011
R14-4938-100 n1_88090_222318 n1_88090_220544 0.00583553
R14-4939-100 n1_88090_223888 n1_88090_222318 0.00516447
R14-4940-100 n1_88090_227232 n1_88090_223888 0.011
R14-4941-100 n1_88090_230576 n1_88090_227232 0.011
R14-4942-100 n1_88090_233920 n1_88090_230576 0.011
R14-4943-100 n1_88090_237264 n1_88090_233920 0.011
R14-4944-100 n1_88090_240608 n1_88090_237264 0.011
R14-4945-100 n1_88090_243952 n1_88090_240608 0.011
R14-4946-100 n1_88090_244814 n1_88090_243952 0.00283553
R14-4947-100 n1_88090_247296 n1_88090_244814 0.00816447
R14-4948-100 n1_88090_250640 n1_88090_247296 0.011
R14-4949-100 n1_88090_253984 n1_88090_250640 0.011
R14-4950-100 n1_88090_257328 n1_88090_253984 0.011
R14-4951-100 n1_88090_260672 n1_88090_257328 0.011
R14-4952-100 n1_88090_264016 n1_88090_260672 0.011
R14-4953-100 n1_88090_266702 n1_88090_264016 0.00883553
R14-4954-100 n1_88090_267360 n1_88090_266702 0.00216447
R14-4955-100 n1_88090_270704 n1_88090_267360 0.011
R14-4956-100 n1_88090_274048 n1_88090_270704 0.011
R14-4957-100 n1_88090_277392 n1_88090_274048 0.011
R14-4958-100 n1_88090_280736 n1_88090_277392 0.011
R14-4959-100 n1_88090_284080 n1_88090_280736 0.011
R14-4960-100 n1_88090_287424 n1_88090_284080 0.011
R14-4961-100 n1_88090_288590 n1_88090_287424 0.00383553
R14-4962-100 n1_88090_290768 n1_88090_288590 0.007164470000000001
R14-4963-100 n1_88090_294112 n1_88090_290768 0.011
R14-4964-100 n1_88090_297456 n1_88090_294112 0.011
R14-4965-100 n1_88090_300800 n1_88090_297456 0.011
R14-4966-100 n1_88090_304144 n1_88090_300800 0.011
R14-4967-100 n1_88090_307488 n1_88090_304144 0.011
R14-4968-100 n1_88090_310832 n1_88090_307488 0.011
R14-4969-100 n1_88090_311086 n1_88090_310832 0.000835526
R14-4970-100 n1_88090_314176 n1_88090_311086 0.0101645
R14-4971-100 n1_88090_317520 n1_88090_314176 0.011
R14-4972-100 n1_88090_320864 n1_88090_317520 0.011
R14-4973-100 n1_88090_324208 n1_88090_320864 0.011
R14-4974-100 n1_88090_327552 n1_88090_324208 0.011
R14-4975-100 n1_88090_330896 n1_88090_327552 0.011
R14-4976-100 n1_88090_332974 n1_88090_330896 0.006835529999999999
R14-4977-100 n1_88090_334240 n1_88090_332974 0.00416447
R14-4978-100 n1_88090_337584 n1_88090_334240 0.011
R14-4979-100 n1_88090_340928 n1_88090_337584 0.011
R14-4980-100 n1_88090_344272 n1_88090_340928 0.011
R14-4981-100 n1_88090_347616 n1_88090_344272 0.011
R14-4982-100 n1_88090_350960 n1_88090_347616 0.011
R14-4983-100 n1_88090_354304 n1_88090_350960 0.011
R14-4984-100 n1_88090_355470 n1_88090_354304 0.00383553
R14-4985-100 n1_88090_357648 n1_88090_355470 0.007164470000000001
R14-4986-100 n1_88090_360992 n1_88090_357648 0.011
R14-4987-100 n1_88090_364336 n1_88090_360992 0.011
R14-4988-100 n1_88090_367680 n1_88090_364336 0.011
R14-4989-100 n1_88090_371024 n1_88090_367680 0.011
R14-4990-100 n1_88090_374368 n1_88090_371024 0.011
R14-4991-100 n1_88090_377358 n1_88090_374368 0.00983553
R14-4992-100 n1_88090_377712 n1_88090_377358 0.00116447
R14-4993-100 n1_88090_381056 n1_88090_377712 0.011
R14-4994-100 n1_88090_384400 n1_88090_381056 0.011
R14-4995-100 n1_88090_387744 n1_88090_384400 0.011
R14-4996-100 n1_88090_391088 n1_88090_387744 0.011
R14-4997-100 n1_88090_394432 n1_88090_391088 0.011
R14-4998-100 n1_88090_397776 n1_88090_394432 0.011
R14-4999-100 n1_88090_399854 n1_88090_397776 0.006835529999999999
R14-5000-100 n1_88090_401120 n1_88090_399854 0.00416447
R14-5001-100 n1_88090_404464 n1_88090_401120 0.011
R14-5002-100 n1_88090_407808 n1_88090_404464 0.011
R14-5003-100 n1_88090_411152 n1_88090_407808 0.011
R14-5004-100 n1_88090_414496 n1_88090_411152 0.011
R14-5005-100 n1_88090_417840 n1_88090_414496 0.011
R14-5006-100 n1_88090_421184 n1_88090_417840 0.011
R14-5007-100 n1_88090_421742 n1_88090_421184 0.0018355300000000001
R14-5008-100 n1_88090_424528 n1_88090_421742 0.00916447
R14-5009-100 n1_88090_427872 n1_88090_424528 0.011
R14-5010-100 n1_88090_431216 n1_88090_427872 0.011
R14-5011-100 n1_88090_434560 n1_88090_431216 0.011
R14-5012-100 n1_88090_437904 n1_88090_434560 0.011
R14-5013-100 n1_88090_441248 n1_88090_437904 0.011
R14-5014-100 n1_88090_444238 n1_88090_441248 0.00983553
R14-5015-100 n1_88090_444592 n1_88090_444238 0.00116447
R14-5016-100 n1_88090_447936 n1_88090_444592 0.011
R14-5017-100 n1_88090_451280 n1_88090_447936 0.011
R14-5018-100 n1_88090_454624 n1_88090_451280 0.011
R14-5019-100 n1_88090_457968 n1_88090_454624 0.011
R14-5020-100 n1_88090_461312 n1_88090_457968 0.011
R14-5021-100 n1_88090_464656 n1_88090_461312 0.011
R14-5022-100 n1_88090_466126 n1_88090_464656 0.004835529999999999
R14-5023-100 n1_88090_468000 n1_88090_466126 0.00616447
R14-5024-100 n1_88090_471344 n1_88090_468000 0.011
R14-5025-100 n1_88090_474688 n1_88090_471344 0.011
R14-5026-100 n1_88090_478032 n1_88090_474688 0.011
R14-5027-100 n1_88090_481376 n1_88090_478032 0.011
R14-5028-100 n1_88090_484720 n1_88090_481376 0.011
R14-5029-100 n1_88090_488064 n1_88090_484720 0.011
R14-5030-100 n1_88090_488622 n1_88090_488064 0.0018355300000000001
R14-5031-100 n1_88090_491408 n1_88090_488622 0.00916447
R14-5032-100 n1_88090_494752 n1_88090_491408 0.011
R14-5033-100 n1_88090_498096 n1_88090_494752 0.011
R14-5034-100 n1_88090_501440 n1_88090_498096 0.011
R14-5035-100 n1_88090_504784 n1_88090_501440 0.011
R14-5036-100 n1_88090_508128 n1_88090_504784 0.011
R14-5037-100 n1_88090_510510 n1_88090_508128 0.00783553
R14-5038-100 n1_88090_511472 n1_88090_510510 0.00316447
R14-5039-100 n1_88090_514816 n1_88090_511472 0.011
R14-5040-100 n1_88090_518160 n1_88090_514816 0.011
R14-5041-100 n1_88090_521504 n1_88090_518160 0.011
R14-5042-100 n1_88090_524848 n1_88090_521504 0.011
R14-5043-100 n1_88090_528192 n1_88090_524848 0.011
R14-5044-100 n1_88090_531536 n1_88090_528192 0.011
R14-5045-100 n1_88090_532398 n1_88090_531536 0.00283553
R14-5046-100 n1_88090_534880 n1_88090_532398 0.00816447
R14-5047-100 n1_88090_538224 n1_88090_534880 0.011
R14-5048-100 n1_88090_541568 n1_88090_538224 0.011
R14-5049-100 n1_88090_544912 n1_88090_541568 0.011
R14-5050-100 n1_88090_548256 n1_88090_544912 0.011
R14-5051-100 n1_88090_551600 n1_88090_548256 0.011
R14-5052-100 n1_88090_554894 n1_88090_551600 0.010835500000000001
R14-5053-100 n1_88090_554944 n1_88090_554894 0.000164474
R14-5054-100 n1_88090_558288 n1_88090_554944 0.011
R14-5055-100 n1_88090_561632 n1_88090_558288 0.011
R14-5056-100 n1_88090_564976 n1_88090_561632 0.011
R14-5057-100 n1_88090_568320 n1_88090_564976 0.011
R14-5058-100 n1_88090_571664 n1_88090_568320 0.011
R14-5059-100 n1_88090_575008 n1_88090_571664 0.011
R14-5060-100 n1_88090_576782 n1_88090_575008 0.00583553
R14-5061-100 n1_88090_578352 n1_88090_576782 0.00516447
R14-5062-100 n1_88090_581696 n1_88090_578352 0.011
R14-5063-100 n1_88090_585040 n1_88090_581696 0.011
R14-5064-100 n1_88090_588384 n1_88090_585040 0.011
R14-5065-100 n1_88090_591728 n1_88090_588384 0.011
R14-5066-100 n1_88090_595072 n1_88090_591728 0.011
R14-5067-100 n1_88090_598416 n1_88090_595072 0.011
R14-5068-100 n1_88090_599278 n1_88090_598416 0.00283553
R14-5069-100 n1_88090_601760 n1_88090_599278 0.00816447
R14-5070-100 n1_88090_605104 n1_88090_601760 0.011
R14-5071-100 n1_88090_608448 n1_88090_605104 0.011
R14-5072-100 n1_88090_611792 n1_88090_608448 0.011
R14-5073-100 n1_88090_615136 n1_88090_611792 0.011
R14-5074-100 n1_88090_618480 n1_88090_615136 0.011
R14-5075-100 n1_88090_624152 n1_88090_618480 0.018657899999999998
R14-5076-100 n1_88090_626152 n1_88090_624152 0.00657895
R14-5077-100 n1_65594_46000 n1_65594_44000 0.00657895
R14-5078-100 n1_65594_50000 n1_65594_46000 0.0131579
R14-5079-100 n1_65594_53344 n1_65594_50000 0.011
R14-5080-100 n1_65594_56688 n1_65594_53344 0.011
R14-5081-100 n1_65594_60032 n1_65594_56688 0.011
R14-5082-100 n1_65594_63376 n1_65594_60032 0.011
R14-5083-100 n1_65594_66720 n1_65594_63376 0.011
R14-5084-100 n1_65594_67278 n1_65594_66720 0.0018355300000000001
R14-5085-100 n1_65594_70064 n1_65594_67278 0.00916447
R14-5086-100 n1_65594_73408 n1_65594_70064 0.011
R14-5087-100 n1_65594_76752 n1_65594_73408 0.011
R14-5088-100 n1_65594_80096 n1_65594_76752 0.011
R14-5089-100 n1_65594_83440 n1_65594_80096 0.011
R14-5090-100 n1_65594_86784 n1_65594_83440 0.011
R14-5091-100 n1_65594_89166 n1_65594_86784 0.00783553
R14-5092-100 n1_65594_90128 n1_65594_89166 0.00316447
R14-5093-100 n1_65594_93472 n1_65594_90128 0.011
R14-5094-100 n1_65594_96816 n1_65594_93472 0.011
R14-5095-100 n1_65594_100160 n1_65594_96816 0.011
R14-5096-100 n1_65594_103504 n1_65594_100160 0.011
R14-5097-100 n1_65594_106848 n1_65594_103504 0.011
R14-5098-100 n1_65594_110192 n1_65594_106848 0.011
R14-5099-100 n1_65594_111662 n1_65594_110192 0.004835529999999999
R14-5100-100 n1_65594_113536 n1_65594_111662 0.00616447
R14-5101-100 n1_65594_116880 n1_65594_113536 0.011
R14-5102-100 n1_65594_120224 n1_65594_116880 0.011
R14-5103-100 n1_65594_123568 n1_65594_120224 0.011
R14-5104-100 n1_65594_126912 n1_65594_123568 0.011
R14-5105-100 n1_65594_130256 n1_65594_126912 0.011
R14-5106-100 n1_65594_133550 n1_65594_130256 0.010835500000000001
R14-5107-100 n1_65594_133600 n1_65594_133550 0.000164474
R14-5108-100 n1_65594_136944 n1_65594_133600 0.011
R14-5109-100 n1_65594_140288 n1_65594_136944 0.011
R14-5110-100 n1_65594_143632 n1_65594_140288 0.011
R14-5111-100 n1_65594_146976 n1_65594_143632 0.011
R14-5112-100 n1_65594_150320 n1_65594_146976 0.011
R14-5113-100 n1_65594_153664 n1_65594_150320 0.011
R14-5114-100 n1_65594_156046 n1_65594_153664 0.00783553
R14-5115-100 n1_65594_157008 n1_65594_156046 0.00316447
R14-5116-100 n1_65594_160352 n1_65594_157008 0.011
R14-5117-100 n1_65594_163696 n1_65594_160352 0.011
R14-5118-100 n1_65594_167040 n1_65594_163696 0.011
R14-5119-100 n1_65594_170384 n1_65594_167040 0.011
R14-5120-100 n1_65594_173728 n1_65594_170384 0.011
R14-5121-100 n1_65594_177072 n1_65594_173728 0.011
R14-5122-100 n1_65594_177934 n1_65594_177072 0.00283553
R14-5123-100 n1_65594_180416 n1_65594_177934 0.00816447
R14-5124-100 n1_65594_183760 n1_65594_180416 0.011
R14-5125-100 n1_65594_187104 n1_65594_183760 0.011
R14-5126-100 n1_65594_190448 n1_65594_187104 0.011
R14-5127-100 n1_65594_193792 n1_65594_190448 0.011
R14-5128-100 n1_65594_197136 n1_65594_193792 0.011
R14-5129-100 n1_65594_200430 n1_65594_197136 0.010835500000000001
R14-5130-100 n1_65594_200480 n1_65594_200430 0.000164474
R14-5131-100 n1_65594_203824 n1_65594_200480 0.011
R14-5132-100 n1_65594_207168 n1_65594_203824 0.011
R14-5133-100 n1_65594_210512 n1_65594_207168 0.011
R14-5134-100 n1_65594_213856 n1_65594_210512 0.011
R14-5135-100 n1_65594_217200 n1_65594_213856 0.011
R14-5136-100 n1_65594_220544 n1_65594_217200 0.011
R14-5137-100 n1_65594_222318 n1_65594_220544 0.00583553
R14-5138-100 n1_65594_223888 n1_65594_222318 0.00516447
R14-5139-100 n1_65594_227232 n1_65594_223888 0.011
R14-5140-100 n1_65594_230576 n1_65594_227232 0.011
R14-5141-100 n1_65594_233920 n1_65594_230576 0.011
R14-5142-100 n1_65594_237264 n1_65594_233920 0.011
R14-5143-100 n1_65594_240608 n1_65594_237264 0.011
R14-5144-100 n1_65594_243952 n1_65594_240608 0.011
R14-5145-100 n1_65594_244814 n1_65594_243952 0.00283553
R14-5146-100 n1_65594_247296 n1_65594_244814 0.00816447
R14-5147-100 n1_65594_250640 n1_65594_247296 0.011
R14-5148-100 n1_65594_253984 n1_65594_250640 0.011
R14-5149-100 n1_65594_257328 n1_65594_253984 0.011
R14-5150-100 n1_65594_260672 n1_65594_257328 0.011
R14-5151-100 n1_65594_264016 n1_65594_260672 0.011
R14-5152-100 n1_65594_266702 n1_65594_264016 0.00883553
R14-5153-100 n1_65594_267360 n1_65594_266702 0.00216447
R14-5154-100 n1_65594_270704 n1_65594_267360 0.011
R14-5155-100 n1_65594_274048 n1_65594_270704 0.011
R14-5156-100 n1_65594_277392 n1_65594_274048 0.011
R14-5157-100 n1_65594_280736 n1_65594_277392 0.011
R14-5158-100 n1_65594_284080 n1_65594_280736 0.011
R14-5159-100 n1_65594_287424 n1_65594_284080 0.011
R14-5160-100 n1_65594_288590 n1_65594_287424 0.00383553
R14-5161-100 n1_65594_290768 n1_65594_288590 0.007164470000000001
R14-5162-100 n1_65594_294112 n1_65594_290768 0.011
R14-5163-100 n1_65594_297456 n1_65594_294112 0.011
R14-5164-100 n1_65594_300800 n1_65594_297456 0.011
R14-5165-100 n1_65594_304144 n1_65594_300800 0.011
R14-5166-100 n1_65594_307488 n1_65594_304144 0.011
R14-5167-100 n1_65594_310832 n1_65594_307488 0.011
R14-5168-100 n1_65594_311086 n1_65594_310832 0.000835526
R14-5169-100 n1_65594_314176 n1_65594_311086 0.0101645
R14-5170-100 n1_65594_317520 n1_65594_314176 0.011
R14-5171-100 n1_65594_320864 n1_65594_317520 0.011
R14-5172-100 n1_65594_324208 n1_65594_320864 0.011
R14-5173-100 n1_65594_327552 n1_65594_324208 0.011
R14-5174-100 n1_65594_330896 n1_65594_327552 0.011
R14-5175-100 n1_65594_332974 n1_65594_330896 0.006835529999999999
R14-5176-100 n1_65594_334240 n1_65594_332974 0.00416447
R14-5177-100 n1_65594_337584 n1_65594_334240 0.011
R14-5178-100 n1_65594_340928 n1_65594_337584 0.011
R14-5179-100 n1_65594_344272 n1_65594_340928 0.011
R14-5180-100 n1_65594_347616 n1_65594_344272 0.011
R14-5181-100 n1_65594_350960 n1_65594_347616 0.011
R14-5182-100 n1_65594_354304 n1_65594_350960 0.011
R14-5183-100 n1_65594_355470 n1_65594_354304 0.00383553
R14-5184-100 n1_65594_357648 n1_65594_355470 0.007164470000000001
R14-5185-100 n1_65594_360992 n1_65594_357648 0.011
R14-5186-100 n1_65594_364336 n1_65594_360992 0.011
R14-5187-100 n1_65594_367680 n1_65594_364336 0.011
R14-5188-100 n1_65594_371024 n1_65594_367680 0.011
R14-5189-100 n1_65594_374368 n1_65594_371024 0.011
R14-5190-100 n1_65594_377358 n1_65594_374368 0.00983553
R14-5191-100 n1_65594_377712 n1_65594_377358 0.00116447
R14-5192-100 n1_65594_381056 n1_65594_377712 0.011
R14-5193-100 n1_65594_384400 n1_65594_381056 0.011
R14-5194-100 n1_65594_387744 n1_65594_384400 0.011
R14-5195-100 n1_65594_391088 n1_65594_387744 0.011
R14-5196-100 n1_65594_394432 n1_65594_391088 0.011
R14-5197-100 n1_65594_397776 n1_65594_394432 0.011
R14-5198-100 n1_65594_399854 n1_65594_397776 0.006835529999999999
R14-5199-100 n1_65594_401120 n1_65594_399854 0.00416447
R14-5200-100 n1_65594_404464 n1_65594_401120 0.011
R14-5201-100 n1_65594_407808 n1_65594_404464 0.011
R14-5202-100 n1_65594_411152 n1_65594_407808 0.011
R14-5203-100 n1_65594_414496 n1_65594_411152 0.011
R14-5204-100 n1_65594_417840 n1_65594_414496 0.011
R14-5205-100 n1_65594_421184 n1_65594_417840 0.011
R14-5206-100 n1_65594_421742 n1_65594_421184 0.0018355300000000001
R14-5207-100 n1_65594_424528 n1_65594_421742 0.00916447
R14-5208-100 n1_65594_427872 n1_65594_424528 0.011
R14-5209-100 n1_65594_431216 n1_65594_427872 0.011
R14-5210-100 n1_65594_434560 n1_65594_431216 0.011
R14-5211-100 n1_65594_437904 n1_65594_434560 0.011
R14-5212-100 n1_65594_441248 n1_65594_437904 0.011
R14-5213-100 n1_65594_444238 n1_65594_441248 0.00983553
R14-5214-100 n1_65594_444592 n1_65594_444238 0.00116447
R14-5215-100 n1_65594_447936 n1_65594_444592 0.011
R14-5216-100 n1_65594_451280 n1_65594_447936 0.011
R14-5217-100 n1_65594_454624 n1_65594_451280 0.011
R14-5218-100 n1_65594_457968 n1_65594_454624 0.011
R14-5219-100 n1_65594_461312 n1_65594_457968 0.011
R14-5220-100 n1_65594_464656 n1_65594_461312 0.011
R14-5221-100 n1_65594_466126 n1_65594_464656 0.004835529999999999
R14-5222-100 n1_65594_468000 n1_65594_466126 0.00616447
R14-5223-100 n1_65594_471344 n1_65594_468000 0.011
R14-5224-100 n1_65594_474688 n1_65594_471344 0.011
R14-5225-100 n1_65594_478032 n1_65594_474688 0.011
R14-5226-100 n1_65594_481376 n1_65594_478032 0.011
R14-5227-100 n1_65594_484720 n1_65594_481376 0.011
R14-5228-100 n1_65594_488064 n1_65594_484720 0.011
R14-5229-100 n1_65594_488622 n1_65594_488064 0.0018355300000000001
R14-5230-100 n1_65594_491408 n1_65594_488622 0.00916447
R14-5231-100 n1_65594_494752 n1_65594_491408 0.011
R14-5232-100 n1_65594_498096 n1_65594_494752 0.011
R14-5233-100 n1_65594_501440 n1_65594_498096 0.011
R14-5234-100 n1_65594_504784 n1_65594_501440 0.011
R14-5235-100 n1_65594_508128 n1_65594_504784 0.011
R14-5236-100 n1_65594_510510 n1_65594_508128 0.00783553
R14-5237-100 n1_65594_511472 n1_65594_510510 0.00316447
R14-5238-100 n1_65594_514816 n1_65594_511472 0.011
R14-5239-100 n1_65594_518160 n1_65594_514816 0.011
R14-5240-100 n1_65594_521504 n1_65594_518160 0.011
R14-5241-100 n1_65594_524848 n1_65594_521504 0.011
R14-5242-100 n1_65594_528192 n1_65594_524848 0.011
R14-5243-100 n1_65594_531536 n1_65594_528192 0.011
R14-5244-100 n1_65594_532398 n1_65594_531536 0.00283553
R14-5245-100 n1_65594_534880 n1_65594_532398 0.00816447
R14-5246-100 n1_65594_538224 n1_65594_534880 0.011
R14-5247-100 n1_65594_541568 n1_65594_538224 0.011
R14-5248-100 n1_65594_544912 n1_65594_541568 0.011
R14-5249-100 n1_65594_548256 n1_65594_544912 0.011
R14-5250-100 n1_65594_551600 n1_65594_548256 0.011
R14-5251-100 n1_65594_554894 n1_65594_551600 0.010835500000000001
R14-5252-100 n1_65594_554944 n1_65594_554894 0.000164474
R14-5253-100 n1_65594_558288 n1_65594_554944 0.011
R14-5254-100 n1_65594_561632 n1_65594_558288 0.011
R14-5255-100 n1_65594_564976 n1_65594_561632 0.011
R14-5256-100 n1_65594_568320 n1_65594_564976 0.011
R14-5257-100 n1_65594_571664 n1_65594_568320 0.011
R14-5258-100 n1_65594_575008 n1_65594_571664 0.011
R14-5259-100 n1_65594_576782 n1_65594_575008 0.00583553
R14-5260-100 n1_65594_578352 n1_65594_576782 0.00516447
R14-5261-100 n1_65594_581696 n1_65594_578352 0.011
R14-5262-100 n1_65594_585040 n1_65594_581696 0.011
R14-5263-100 n1_65594_588384 n1_65594_585040 0.011
R14-5264-100 n1_65594_591728 n1_65594_588384 0.011
R14-5265-100 n1_65594_595072 n1_65594_591728 0.011
R14-5266-100 n1_65594_598416 n1_65594_595072 0.011
R14-5267-100 n1_65594_599278 n1_65594_598416 0.00283553
R14-5268-100 n1_65594_601760 n1_65594_599278 0.00816447
R14-5269-100 n1_65594_605104 n1_65594_601760 0.011
R14-5270-100 n1_65594_608448 n1_65594_605104 0.011
R14-5271-100 n1_65594_611792 n1_65594_608448 0.011
R14-5272-100 n1_65594_615136 n1_65594_611792 0.011
R14-5273-100 n1_65594_618480 n1_65594_615136 0.011
R14-5274-100 n1_65594_624152 n1_65594_618480 0.018657899999999998
R14-5275-100 n1_65594_626152 n1_65594_624152 0.00657895
R14-5276-100 n1_46000_28 n1_46000_0 7e-05
R14-5277-100 n1_46000_46000 n1_46000_28 0.11493
R14-5278-100 n1_46000_50000 n1_46000_46000 0.01
R14-5279-100 n1_46000_53344 n1_46000_50000 0.00836
R14-5280-100 n1_46000_56688 n1_46000_53344 0.00836
R14-5281-100 n1_46000_60032 n1_46000_56688 0.00836
R14-5282-100 n1_46000_63376 n1_46000_60032 0.00836
R14-5283-100 n1_46000_66720 n1_46000_63376 0.00836
R14-5284-100 n1_46000_67278 n1_46000_66720 0.001395
R14-5285-100 n1_46000_70064 n1_46000_67278 0.006965000000000001
R14-5286-100 n1_46000_73408 n1_46000_70064 0.00836
R14-5287-100 n1_46000_76752 n1_46000_73408 0.00836
R14-5288-100 n1_46000_80096 n1_46000_76752 0.00836
R14-5289-100 n1_46000_83440 n1_46000_80096 0.00836
R14-5290-100 n1_46000_86784 n1_46000_83440 0.00836
R14-5291-100 n1_46000_89166 n1_46000_86784 0.005955
R14-5292-100 n1_46000_90128 n1_46000_89166 0.002405
R14-5293-100 n1_46000_93472 n1_46000_90128 0.00836
R14-5294-100 n1_46000_96816 n1_46000_93472 0.00836
R14-5295-100 n1_46000_100160 n1_46000_96816 0.00836
R14-5296-100 n1_46000_103504 n1_46000_100160 0.00836
R14-5297-100 n1_46000_106848 n1_46000_103504 0.00836
R14-5298-100 n1_46000_110192 n1_46000_106848 0.00836
R14-5299-100 n1_46000_111662 n1_46000_110192 0.003675
R14-5300-100 n1_46000_113536 n1_46000_111662 0.004685
R14-5301-100 n1_46000_116880 n1_46000_113536 0.00836
R14-5302-100 n1_46000_120224 n1_46000_116880 0.00836
R14-5303-100 n1_46000_123568 n1_46000_120224 0.00836
R14-5304-100 n1_46000_126912 n1_46000_123568 0.00836
R14-5305-100 n1_46000_130256 n1_46000_126912 0.00836
R14-5306-100 n1_46000_133550 n1_46000_130256 0.008235000000000001
R14-5307-100 n1_46000_133600 n1_46000_133550 0.000125
R14-5308-100 n1_46000_136944 n1_46000_133600 0.00836
R14-5309-100 n1_46000_140288 n1_46000_136944 0.00836
R14-5310-100 n1_46000_143632 n1_46000_140288 0.00836
R14-5311-100 n1_46000_146976 n1_46000_143632 0.00836
R14-5312-100 n1_46000_150320 n1_46000_146976 0.00836
R14-5313-100 n1_46000_153664 n1_46000_150320 0.00836
R14-5314-100 n1_46000_156046 n1_46000_153664 0.005955
R14-5315-100 n1_46000_157008 n1_46000_156046 0.002405
R14-5316-100 n1_46000_160352 n1_46000_157008 0.00836
R14-5317-100 n1_46000_163696 n1_46000_160352 0.00836
R14-5318-100 n1_46000_167040 n1_46000_163696 0.00836
R14-5319-100 n1_46000_170384 n1_46000_167040 0.00836
R14-5320-100 n1_46000_173728 n1_46000_170384 0.00836
R14-5321-100 n1_46000_177072 n1_46000_173728 0.00836
R14-5322-100 n1_46000_177934 n1_46000_177072 0.002155
R14-5323-100 n1_46000_180416 n1_46000_177934 0.0062050000000000004
R14-5324-100 n1_46000_183760 n1_46000_180416 0.00836
R14-5325-100 n1_46000_187104 n1_46000_183760 0.00836
R14-5326-100 n1_46000_190448 n1_46000_187104 0.00836
R14-5327-100 n1_46000_193792 n1_46000_190448 0.00836
R14-5328-100 n1_46000_197136 n1_46000_193792 0.00836
R14-5329-100 n1_46000_200430 n1_46000_197136 0.008235000000000001
R14-5330-100 n1_46000_200480 n1_46000_200430 0.000125
R14-5331-100 n1_46000_203824 n1_46000_200480 0.00836
R14-5332-100 n1_46000_207168 n1_46000_203824 0.00836
R14-5333-100 n1_46000_210512 n1_46000_207168 0.00836
R14-5334-100 n1_46000_213856 n1_46000_210512 0.00836
R14-5335-100 n1_46000_217200 n1_46000_213856 0.00836
R14-5336-100 n1_46000_220544 n1_46000_217200 0.00836
R14-5337-100 n1_46000_222318 n1_46000_220544 0.004435
R14-5338-100 n1_46000_223888 n1_46000_222318 0.003925
R14-5339-100 n1_46000_227232 n1_46000_223888 0.00836
R14-5340-100 n1_46000_230576 n1_46000_227232 0.00836
R14-5341-100 n1_46000_233920 n1_46000_230576 0.00836
R14-5342-100 n1_46000_237264 n1_46000_233920 0.00836
R14-5343-100 n1_46000_240608 n1_46000_237264 0.00836
R14-5344-100 n1_46000_243952 n1_46000_240608 0.00836
R14-5345-100 n1_46000_244814 n1_46000_243952 0.002155
R14-5346-100 n1_46000_247296 n1_46000_244814 0.0062050000000000004
R14-5347-100 n1_46000_250640 n1_46000_247296 0.00836
R14-5348-100 n1_46000_253984 n1_46000_250640 0.00836
R14-5349-100 n1_46000_257328 n1_46000_253984 0.00836
R14-5350-100 n1_46000_260672 n1_46000_257328 0.00836
R14-5351-100 n1_46000_264016 n1_46000_260672 0.00836
R14-5352-100 n1_46000_266702 n1_46000_264016 0.0067150000000000005
R14-5353-100 n1_46000_267360 n1_46000_266702 0.001645
R14-5354-100 n1_46000_270704 n1_46000_267360 0.00836
R14-5355-100 n1_46000_274048 n1_46000_270704 0.00836
R14-5356-100 n1_46000_277392 n1_46000_274048 0.00836
R14-5357-100 n1_46000_280736 n1_46000_277392 0.00836
R14-5358-100 n1_46000_284080 n1_46000_280736 0.00836
R14-5359-100 n1_46000_287424 n1_46000_284080 0.00836
R14-5360-100 n1_46000_288590 n1_46000_287424 0.002915
R14-5361-100 n1_46000_290768 n1_46000_288590 0.005445
R14-5362-100 n1_46000_294112 n1_46000_290768 0.00836
R14-5363-100 n1_46000_297456 n1_46000_294112 0.00836
R14-5364-100 n1_46000_300800 n1_46000_297456 0.00836
R14-5365-100 n1_46000_304144 n1_46000_300800 0.00836
R14-5366-100 n1_46000_307488 n1_46000_304144 0.00836
R14-5367-100 n1_46000_310832 n1_46000_307488 0.00836
R14-5368-100 n1_46000_311086 n1_46000_310832 0.0006349999999999999
R14-5369-100 n1_46000_314176 n1_46000_311086 0.007725
R14-5370-100 n1_46000_317520 n1_46000_314176 0.00836
R14-5371-100 n1_46000_320864 n1_46000_317520 0.00836
R14-5372-100 n1_46000_324208 n1_46000_320864 0.00836
R14-5373-100 n1_46000_327552 n1_46000_324208 0.00836
R14-5374-100 n1_46000_330896 n1_46000_327552 0.00836
R14-5375-100 n1_46000_332974 n1_46000_330896 0.005195
R14-5376-100 n1_46000_334240 n1_46000_332974 0.003165
R14-5377-100 n1_46000_337584 n1_46000_334240 0.00836
R14-5378-100 n1_46000_340928 n1_46000_337584 0.00836
R14-5379-100 n1_46000_344272 n1_46000_340928 0.00836
R14-5380-100 n1_46000_347616 n1_46000_344272 0.00836
R14-5381-100 n1_46000_350960 n1_46000_347616 0.00836
R14-5382-100 n1_46000_354304 n1_46000_350960 0.00836
R14-5383-100 n1_46000_355470 n1_46000_354304 0.002915
R14-5384-100 n1_46000_357648 n1_46000_355470 0.005445
R14-5385-100 n1_46000_360992 n1_46000_357648 0.00836
R14-5386-100 n1_46000_364336 n1_46000_360992 0.00836
R14-5387-100 n1_46000_367680 n1_46000_364336 0.00836
R14-5388-100 n1_46000_371024 n1_46000_367680 0.00836
R14-5389-100 n1_46000_374368 n1_46000_371024 0.00836
R14-5390-100 n1_46000_377358 n1_46000_374368 0.007475
R14-5391-100 n1_46000_377712 n1_46000_377358 0.000885
R14-5392-100 n1_46000_381056 n1_46000_377712 0.00836
R14-5393-100 n1_46000_384400 n1_46000_381056 0.00836
R14-5394-100 n1_46000_387744 n1_46000_384400 0.00836
R14-5395-100 n1_46000_391088 n1_46000_387744 0.00836
R14-5396-100 n1_46000_394432 n1_46000_391088 0.00836
R14-5397-100 n1_46000_397776 n1_46000_394432 0.00836
R14-5398-100 n1_46000_399854 n1_46000_397776 0.005195
R14-5399-100 n1_46000_401120 n1_46000_399854 0.003165
R14-5400-100 n1_46000_404464 n1_46000_401120 0.00836
R14-5401-100 n1_46000_407808 n1_46000_404464 0.00836
R14-5402-100 n1_46000_411152 n1_46000_407808 0.00836
R14-5403-100 n1_46000_414496 n1_46000_411152 0.00836
R14-5404-100 n1_46000_417840 n1_46000_414496 0.00836
R14-5405-100 n1_46000_421184 n1_46000_417840 0.00836
R14-5406-100 n1_46000_421742 n1_46000_421184 0.001395
R14-5407-100 n1_46000_424528 n1_46000_421742 0.006965000000000001
R14-5408-100 n1_46000_427872 n1_46000_424528 0.00836
R14-5409-100 n1_46000_431216 n1_46000_427872 0.00836
R14-5410-100 n1_46000_434560 n1_46000_431216 0.00836
R14-5411-100 n1_46000_437904 n1_46000_434560 0.00836
R14-5412-100 n1_46000_441248 n1_46000_437904 0.00836
R14-5413-100 n1_46000_444238 n1_46000_441248 0.007475
R14-5414-100 n1_46000_444592 n1_46000_444238 0.000885
R14-5415-100 n1_46000_447936 n1_46000_444592 0.00836
R14-5416-100 n1_46000_451280 n1_46000_447936 0.00836
R14-5417-100 n1_46000_454624 n1_46000_451280 0.00836
R14-5418-100 n1_46000_457968 n1_46000_454624 0.00836
R14-5419-100 n1_46000_461312 n1_46000_457968 0.00836
R14-5420-100 n1_46000_464656 n1_46000_461312 0.00836
R14-5421-100 n1_46000_466126 n1_46000_464656 0.003675
R14-5422-100 n1_46000_468000 n1_46000_466126 0.004685
R14-5423-100 n1_46000_471344 n1_46000_468000 0.00836
R14-5424-100 n1_46000_474688 n1_46000_471344 0.00836
R14-5425-100 n1_46000_478032 n1_46000_474688 0.00836
R14-5426-100 n1_46000_481376 n1_46000_478032 0.00836
R14-5427-100 n1_46000_484720 n1_46000_481376 0.00836
R14-5428-100 n1_46000_488064 n1_46000_484720 0.00836
R14-5429-100 n1_46000_488622 n1_46000_488064 0.001395
R14-5430-100 n1_46000_491408 n1_46000_488622 0.006965000000000001
R14-5431-100 n1_46000_494752 n1_46000_491408 0.00836
R14-5432-100 n1_46000_498096 n1_46000_494752 0.00836
R14-5433-100 n1_46000_501440 n1_46000_498096 0.00836
R14-5434-100 n1_46000_504784 n1_46000_501440 0.00836
R14-5435-100 n1_46000_508128 n1_46000_504784 0.00836
R14-5436-100 n1_46000_510510 n1_46000_508128 0.005955
R14-5437-100 n1_46000_511472 n1_46000_510510 0.002405
R14-5438-100 n1_46000_514816 n1_46000_511472 0.00836
R14-5439-100 n1_46000_518160 n1_46000_514816 0.00836
R14-5440-100 n1_46000_521504 n1_46000_518160 0.00836
R14-5441-100 n1_46000_524848 n1_46000_521504 0.00836
R14-5442-100 n1_46000_528192 n1_46000_524848 0.00836
R14-5443-100 n1_46000_531536 n1_46000_528192 0.00836
R14-5444-100 n1_46000_532398 n1_46000_531536 0.002155
R14-5445-100 n1_46000_534880 n1_46000_532398 0.0062050000000000004
R14-5446-100 n1_46000_538224 n1_46000_534880 0.00836
R14-5447-100 n1_46000_541568 n1_46000_538224 0.00836
R14-5448-100 n1_46000_544912 n1_46000_541568 0.00836
R14-5449-100 n1_46000_548256 n1_46000_544912 0.00836
R14-5450-100 n1_46000_551600 n1_46000_548256 0.00836
R14-5451-100 n1_46000_554894 n1_46000_551600 0.008235000000000001
R14-5452-100 n1_46000_554944 n1_46000_554894 0.000125
R14-5453-100 n1_46000_558288 n1_46000_554944 0.00836
R14-5454-100 n1_46000_561632 n1_46000_558288 0.00836
R14-5455-100 n1_46000_564976 n1_46000_561632 0.00836
R14-5456-100 n1_46000_568320 n1_46000_564976 0.00836
R14-5457-100 n1_46000_571664 n1_46000_568320 0.00836
R14-5458-100 n1_46000_575008 n1_46000_571664 0.00836
R14-5459-100 n1_46000_576782 n1_46000_575008 0.004435
R14-5460-100 n1_46000_578352 n1_46000_576782 0.003925
R14-5461-100 n1_46000_581696 n1_46000_578352 0.00836
R14-5462-100 n1_46000_585040 n1_46000_581696 0.00836
R14-5463-100 n1_46000_588384 n1_46000_585040 0.00836
R14-5464-100 n1_46000_591728 n1_46000_588384 0.00836
R14-5465-100 n1_46000_595072 n1_46000_591728 0.00836
R14-5466-100 n1_46000_598416 n1_46000_595072 0.00836
R14-5467-100 n1_46000_599278 n1_46000_598416 0.002155
R14-5468-100 n1_46000_601760 n1_46000_599278 0.0062050000000000004
R14-5469-100 n1_46000_605104 n1_46000_601760 0.00836
R14-5470-100 n1_46000_608448 n1_46000_605104 0.00836
R14-5471-100 n1_46000_611792 n1_46000_608448 0.00836
R14-5472-100 n1_46000_615136 n1_46000_611792 0.00836
R14-5473-100 n1_46000_618480 n1_46000_615136 0.00836
R14-5474-100 n1_46000_624152 n1_46000_618480 0.014180000000000002
R14-5475-100 n1_46000_670124 n1_46000_624152 0.11493
R14-5476-100 n1_46000_670152 n1_46000_670124 7e-05
R15-100-100 n1_0_46000 n1_28_46000 7e-05
R15-100-101 n1_28_46000 n1_46000_46000 0.11493
R15-100-102 n1_46000_46000 n1_65594_46000 0.048985
R15-100-103 n1_65594_46000 n1_88090_46000 0.05624
R15-100-104 n1_88090_46000 n1_110282_46000 0.055479999999999995
R15-100-105 n1_110282_46000 n1_132778_46000 0.05624
R15-100-106 n1_132778_46000 n1_154970_46000 0.055479999999999995
R15-100-107 n1_154970_46000 n1_177466_46000 0.05624
R15-100-108 n1_177466_46000 n1_199658_46000 0.055479999999999995
R15-100-109 n1_199658_46000 n1_221850_46000 0.055479999999999995
R15-100-110 n1_221850_46000 n1_244346_46000 0.05624
R15-100-111 n1_244346_46000 n1_266538_46000 0.055479999999999995
R15-100-112 n1_266538_46000 n1_289034_46000 0.05624
R15-100-113 n1_289034_46000 n1_311226_46000 0.055479999999999995
R15-100-114 n1_311226_46000 n1_333722_46000 0.05624
R15-100-115 n1_333722_46000 n1_355914_46000 0.055479999999999995
R15-100-116 n1_355914_46000 n1_378410_46000 0.05624
R15-100-117 n1_378410_46000 n1_400602_46000 0.055479999999999995
R15-100-118 n1_400602_46000 n1_422794_46000 0.055479999999999995
R15-100-119 n1_422794_46000 n1_445290_46000 0.05624
R15-100-120 n1_445290_46000 n1_467482_46000 0.055479999999999995
R15-100-121 n1_467482_46000 n1_489978_46000 0.05624
R15-100-122 n1_489978_46000 n1_512170_46000 0.055479999999999995
R15-100-123 n1_512170_46000 n1_534666_46000 0.05624
R15-100-124 n1_534666_46000 n1_556858_46000 0.055479999999999995
R15-100-125 n1_556858_46000 n1_579050_46000 0.055479999999999995
R15-100-126 n1_579050_46000 n1_601546_46000 0.05624
R15-100-127 n1_601546_46000 n1_625064_46000 0.058795
R15-100-128 n1_625064_46000 n1_671036_46000 0.11493
R15-100-129 n1_671036_46000 n1_671064_46000 7e-05
R15-101-100 n1_44000_67278 n1_46000_67278 0.00657895
R15-101-101 n1_46000_67278 n1_65594_67278 0.0644539
R15-101-102 n1_65594_67278 n1_88090_67278 0.074
R15-101-103 n1_88090_67278 n1_110282_67278 0.073
R15-101-104 n1_110282_67278 n1_132778_67278 0.074
R15-101-105 n1_132778_67278 n1_154970_67278 0.073
R15-101-106 n1_154970_67278 n1_177466_67278 0.074
R15-101-107 n1_177466_67278 n1_199658_67278 0.073
R15-101-108 n1_199658_67278 n1_221850_67278 0.073
R15-101-109 n1_221850_67278 n1_244346_67278 0.074
R15-101-110 n1_244346_67278 n1_266538_67278 0.073
R15-101-111 n1_266538_67278 n1_289034_67278 0.074
R15-101-112 n1_289034_67278 n1_311226_67278 0.073
R15-101-113 n1_311226_67278 n1_333722_67278 0.074
R15-101-114 n1_333722_67278 n1_355914_67278 0.073
R15-101-115 n1_355914_67278 n1_378410_67278 0.074
R15-101-116 n1_378410_67278 n1_400602_67278 0.073
R15-101-117 n1_400602_67278 n1_422794_67278 0.073
R15-101-118 n1_422794_67278 n1_445290_67278 0.074
R15-101-119 n1_445290_67278 n1_467482_67278 0.073
R15-101-120 n1_467482_67278 n1_489978_67278 0.074
R15-101-121 n1_489978_67278 n1_512170_67278 0.073
R15-101-122 n1_512170_67278 n1_534666_67278 0.074
R15-101-123 n1_534666_67278 n1_556858_67278 0.073
R15-101-124 n1_556858_67278 n1_579050_67278 0.073
R15-101-125 n1_579050_67278 n1_601546_67278 0.074
R15-101-126 n1_601546_67278 n1_625064_67278 0.07736180000000001
R15-101-127 n1_625064_67278 n1_627064_67278 0.00657895
R15-102-100 n1_44000_89166 n1_46000_89166 0.00657895
R15-102-101 n1_46000_89166 n1_65594_89166 0.0644539
R15-102-102 n1_65594_89166 n1_88090_89166 0.074
R15-102-103 n1_88090_89166 n1_110282_89166 0.073
R15-102-104 n1_110282_89166 n1_132778_89166 0.074
R15-102-105 n1_132778_89166 n1_154970_89166 0.073
R15-102-106 n1_154970_89166 n1_177466_89166 0.074
R15-102-107 n1_177466_89166 n1_199658_89166 0.073
R15-102-108 n1_199658_89166 n1_221850_89166 0.073
R15-102-109 n1_221850_89166 n1_244346_89166 0.074
R15-102-110 n1_244346_89166 n1_266538_89166 0.073
R15-102-111 n1_266538_89166 n1_289034_89166 0.074
R15-102-112 n1_289034_89166 n1_311226_89166 0.073
R15-102-113 n1_311226_89166 n1_333722_89166 0.074
R15-102-114 n1_333722_89166 n1_355914_89166 0.073
R15-102-115 n1_355914_89166 n1_378410_89166 0.074
R15-102-116 n1_378410_89166 n1_400602_89166 0.073
R15-102-117 n1_400602_89166 n1_422794_89166 0.073
R15-102-118 n1_422794_89166 n1_445290_89166 0.074
R15-102-119 n1_445290_89166 n1_467482_89166 0.073
R15-102-120 n1_467482_89166 n1_489978_89166 0.074
R15-102-121 n1_489978_89166 n1_512170_89166 0.073
R15-102-122 n1_512170_89166 n1_534666_89166 0.074
R15-102-123 n1_534666_89166 n1_556858_89166 0.073
R15-102-124 n1_556858_89166 n1_579050_89166 0.073
R15-102-125 n1_579050_89166 n1_601546_89166 0.074
R15-102-126 n1_601546_89166 n1_625064_89166 0.07736180000000001
R15-102-127 n1_625064_89166 n1_627064_89166 0.00657895
R15-103-100 n1_44000_111662 n1_46000_111662 0.00657895
R15-103-101 n1_46000_111662 n1_65594_111662 0.0644539
R15-103-102 n1_65594_111662 n1_88090_111662 0.074
R15-103-103 n1_88090_111662 n1_110282_111662 0.073
R15-103-104 n1_110282_111662 n1_132778_111662 0.074
R15-103-105 n1_132778_111662 n1_154970_111662 0.073
R15-103-106 n1_154970_111662 n1_177466_111662 0.074
R15-103-107 n1_177466_111662 n1_199658_111662 0.073
R15-103-108 n1_199658_111662 n1_221850_111662 0.073
R15-103-109 n1_221850_111662 n1_244346_111662 0.074
R15-103-110 n1_244346_111662 n1_266538_111662 0.073
R15-103-111 n1_266538_111662 n1_289034_111662 0.074
R15-103-112 n1_289034_111662 n1_311226_111662 0.073
R15-103-113 n1_311226_111662 n1_333722_111662 0.074
R15-103-114 n1_333722_111662 n1_355914_111662 0.073
R15-103-115 n1_355914_111662 n1_378410_111662 0.074
R15-103-116 n1_378410_111662 n1_400602_111662 0.073
R15-103-117 n1_400602_111662 n1_422794_111662 0.073
R15-103-118 n1_422794_111662 n1_445290_111662 0.074
R15-103-119 n1_445290_111662 n1_467482_111662 0.073
R15-103-120 n1_467482_111662 n1_489978_111662 0.074
R15-103-121 n1_489978_111662 n1_512170_111662 0.073
R15-103-122 n1_512170_111662 n1_534666_111662 0.074
R15-103-123 n1_534666_111662 n1_556858_111662 0.073
R15-103-124 n1_556858_111662 n1_579050_111662 0.073
R15-103-125 n1_579050_111662 n1_601546_111662 0.074
R15-103-126 n1_601546_111662 n1_625064_111662 0.07736180000000001
R15-103-127 n1_625064_111662 n1_627064_111662 0.00657895
R15-104-100 n1_44000_133550 n1_46000_133550 0.00657895
R15-104-101 n1_46000_133550 n1_65594_133550 0.0644539
R15-104-102 n1_65594_133550 n1_88090_133550 0.074
R15-104-103 n1_88090_133550 n1_110282_133550 0.073
R15-104-104 n1_110282_133550 n1_132778_133550 0.074
R15-104-105 n1_132778_133550 n1_154970_133550 0.073
R15-104-106 n1_154970_133550 n1_177466_133550 0.074
R15-104-107 n1_177466_133550 n1_199658_133550 0.073
R15-104-108 n1_199658_133550 n1_221850_133550 0.073
R15-104-109 n1_221850_133550 n1_244346_133550 0.074
R15-104-110 n1_244346_133550 n1_266538_133550 0.073
R15-104-111 n1_266538_133550 n1_289034_133550 0.074
R15-104-112 n1_289034_133550 n1_311226_133550 0.073
R15-104-113 n1_311226_133550 n1_333722_133550 0.074
R15-104-114 n1_333722_133550 n1_355914_133550 0.073
R15-104-115 n1_355914_133550 n1_378410_133550 0.074
R15-104-116 n1_378410_133550 n1_400602_133550 0.073
R15-104-117 n1_400602_133550 n1_422794_133550 0.073
R15-104-118 n1_422794_133550 n1_445290_133550 0.074
R15-104-119 n1_445290_133550 n1_467482_133550 0.073
R15-104-120 n1_467482_133550 n1_489978_133550 0.074
R15-104-121 n1_489978_133550 n1_512170_133550 0.073
R15-104-122 n1_512170_133550 n1_534666_133550 0.074
R15-104-123 n1_534666_133550 n1_556858_133550 0.073
R15-104-124 n1_556858_133550 n1_579050_133550 0.073
R15-104-125 n1_579050_133550 n1_601546_133550 0.074
R15-104-126 n1_601546_133550 n1_625064_133550 0.07736180000000001
R15-104-127 n1_625064_133550 n1_627064_133550 0.00657895
R15-105-100 n1_44000_156046 n1_46000_156046 0.00657895
R15-105-101 n1_46000_156046 n1_65594_156046 0.0644539
R15-105-102 n1_65594_156046 n1_88090_156046 0.074
R15-105-103 n1_88090_156046 n1_110282_156046 0.073
R15-105-104 n1_110282_156046 n1_132778_156046 0.074
R15-105-105 n1_132778_156046 n1_154970_156046 0.073
R15-105-106 n1_154970_156046 n1_177466_156046 0.074
R15-105-107 n1_177466_156046 n1_199658_156046 0.073
R15-105-108 n1_199658_156046 n1_221850_156046 0.073
R15-105-109 n1_221850_156046 n1_244346_156046 0.074
R15-105-110 n1_244346_156046 n1_266538_156046 0.073
R15-105-111 n1_266538_156046 n1_289034_156046 0.074
R15-105-112 n1_289034_156046 n1_311226_156046 0.073
R15-105-113 n1_311226_156046 n1_333722_156046 0.074
R15-105-114 n1_333722_156046 n1_355914_156046 0.073
R15-105-115 n1_355914_156046 n1_378410_156046 0.074
R15-105-116 n1_378410_156046 n1_400602_156046 0.073
R15-105-117 n1_400602_156046 n1_422794_156046 0.073
R15-105-118 n1_422794_156046 n1_445290_156046 0.074
R15-105-119 n1_445290_156046 n1_467482_156046 0.073
R15-105-120 n1_467482_156046 n1_489978_156046 0.074
R15-105-121 n1_489978_156046 n1_512170_156046 0.073
R15-105-122 n1_512170_156046 n1_534666_156046 0.074
R15-105-123 n1_534666_156046 n1_556858_156046 0.073
R15-105-124 n1_556858_156046 n1_579050_156046 0.073
R15-105-125 n1_579050_156046 n1_601546_156046 0.074
R15-105-126 n1_601546_156046 n1_625064_156046 0.07736180000000001
R15-105-127 n1_625064_156046 n1_627064_156046 0.00657895
R15-106-100 n1_44000_177934 n1_46000_177934 0.00657895
R15-106-101 n1_46000_177934 n1_65594_177934 0.0644539
R15-106-102 n1_65594_177934 n1_88090_177934 0.074
R15-106-103 n1_88090_177934 n1_110282_177934 0.073
R15-106-104 n1_110282_177934 n1_132778_177934 0.074
R15-106-105 n1_132778_177934 n1_154970_177934 0.073
R15-106-106 n1_154970_177934 n1_177466_177934 0.074
R15-106-107 n1_177466_177934 n1_199658_177934 0.073
R15-106-108 n1_199658_177934 n1_221850_177934 0.073
R15-106-109 n1_221850_177934 n1_244346_177934 0.074
R15-106-110 n1_244346_177934 n1_266538_177934 0.073
R15-106-111 n1_266538_177934 n1_289034_177934 0.074
R15-106-112 n1_289034_177934 n1_311226_177934 0.073
R15-106-113 n1_311226_177934 n1_333722_177934 0.074
R15-106-114 n1_333722_177934 n1_355914_177934 0.073
R15-106-115 n1_355914_177934 n1_378410_177934 0.074
R15-106-116 n1_378410_177934 n1_400602_177934 0.073
R15-106-117 n1_400602_177934 n1_422794_177934 0.073
R15-106-118 n1_422794_177934 n1_445290_177934 0.074
R15-106-119 n1_445290_177934 n1_467482_177934 0.073
R15-106-120 n1_467482_177934 n1_489978_177934 0.074
R15-106-121 n1_489978_177934 n1_512170_177934 0.073
R15-106-122 n1_512170_177934 n1_534666_177934 0.074
R15-106-123 n1_534666_177934 n1_556858_177934 0.073
R15-106-124 n1_556858_177934 n1_579050_177934 0.073
R15-106-125 n1_579050_177934 n1_601546_177934 0.074
R15-106-126 n1_601546_177934 n1_625064_177934 0.07736180000000001
R15-106-127 n1_625064_177934 n1_627064_177934 0.00657895
R15-107-100 n1_44000_200430 n1_46000_200430 0.00657895
R15-107-101 n1_46000_200430 n1_65594_200430 0.0644539
R15-107-102 n1_65594_200430 n1_88090_200430 0.074
R15-107-103 n1_88090_200430 n1_110282_200430 0.073
R15-107-104 n1_110282_200430 n1_132778_200430 0.074
R15-107-105 n1_132778_200430 n1_154970_200430 0.073
R15-107-106 n1_154970_200430 n1_177466_200430 0.074
R15-107-107 n1_177466_200430 n1_199658_200430 0.073
R15-107-108 n1_199658_200430 n1_221850_200430 0.073
R15-107-109 n1_221850_200430 n1_244346_200430 0.074
R15-107-110 n1_244346_200430 n1_266538_200430 0.073
R15-107-111 n1_266538_200430 n1_289034_200430 0.074
R15-107-112 n1_289034_200430 n1_311226_200430 0.073
R15-107-113 n1_311226_200430 n1_333722_200430 0.074
R15-107-114 n1_333722_200430 n1_355914_200430 0.073
R15-107-115 n1_355914_200430 n1_378410_200430 0.074
R15-107-116 n1_378410_200430 n1_400602_200430 0.073
R15-107-117 n1_400602_200430 n1_422794_200430 0.073
R15-107-118 n1_422794_200430 n1_445290_200430 0.074
R15-107-119 n1_445290_200430 n1_467482_200430 0.073
R15-107-120 n1_467482_200430 n1_489978_200430 0.074
R15-107-121 n1_489978_200430 n1_512170_200430 0.073
R15-107-122 n1_512170_200430 n1_534666_200430 0.074
R15-107-123 n1_534666_200430 n1_556858_200430 0.073
R15-107-124 n1_556858_200430 n1_579050_200430 0.073
R15-107-125 n1_579050_200430 n1_601546_200430 0.074
R15-107-126 n1_601546_200430 n1_625064_200430 0.07736180000000001
R15-107-127 n1_625064_200430 n1_627064_200430 0.00657895
R15-108-100 n1_44000_222318 n1_46000_222318 0.00657895
R15-108-101 n1_46000_222318 n1_65594_222318 0.0644539
R15-108-102 n1_65594_222318 n1_88090_222318 0.074
R15-108-103 n1_88090_222318 n1_110282_222318 0.073
R15-108-104 n1_110282_222318 n1_132778_222318 0.074
R15-108-105 n1_132778_222318 n1_154970_222318 0.073
R15-108-106 n1_154970_222318 n1_177466_222318 0.074
R15-108-107 n1_177466_222318 n1_199658_222318 0.073
R15-108-108 n1_199658_222318 n1_221850_222318 0.073
R15-108-109 n1_221850_222318 n1_244346_222318 0.074
R15-108-110 n1_244346_222318 n1_266538_222318 0.073
R15-108-111 n1_266538_222318 n1_289034_222318 0.074
R15-108-112 n1_289034_222318 n1_311226_222318 0.073
R15-108-113 n1_311226_222318 n1_333722_222318 0.074
R15-108-114 n1_333722_222318 n1_355914_222318 0.073
R15-108-115 n1_355914_222318 n1_378410_222318 0.074
R15-108-116 n1_378410_222318 n1_400602_222318 0.073
R15-108-117 n1_400602_222318 n1_422794_222318 0.073
R15-108-118 n1_422794_222318 n1_445290_222318 0.074
R15-108-119 n1_445290_222318 n1_467482_222318 0.073
R15-108-120 n1_467482_222318 n1_489978_222318 0.074
R15-108-121 n1_489978_222318 n1_512170_222318 0.073
R15-108-122 n1_512170_222318 n1_534666_222318 0.074
R15-108-123 n1_534666_222318 n1_556858_222318 0.073
R15-108-124 n1_556858_222318 n1_579050_222318 0.073
R15-108-125 n1_579050_222318 n1_601546_222318 0.074
R15-108-126 n1_601546_222318 n1_625064_222318 0.07736180000000001
R15-108-127 n1_625064_222318 n1_627064_222318 0.00657895
R15-109-100 n1_44000_244814 n1_46000_244814 0.00657895
R15-109-101 n1_46000_244814 n1_65594_244814 0.0644539
R15-109-102 n1_65594_244814 n1_88090_244814 0.074
R15-109-103 n1_88090_244814 n1_110282_244814 0.073
R15-109-104 n1_110282_244814 n1_132778_244814 0.074
R15-109-105 n1_132778_244814 n1_154970_244814 0.073
R15-109-106 n1_154970_244814 n1_177466_244814 0.074
R15-109-107 n1_177466_244814 n1_199658_244814 0.073
R15-109-108 n1_199658_244814 n1_221850_244814 0.073
R15-109-109 n1_221850_244814 n1_244346_244814 0.074
R15-109-110 n1_244346_244814 n1_266538_244814 0.073
R15-109-111 n1_266538_244814 n1_289034_244814 0.074
R15-109-112 n1_289034_244814 n1_311226_244814 0.073
R15-109-113 n1_311226_244814 n1_333722_244814 0.074
R15-109-114 n1_333722_244814 n1_355914_244814 0.073
R15-109-115 n1_355914_244814 n1_378410_244814 0.074
R15-109-116 n1_378410_244814 n1_400602_244814 0.073
R15-109-117 n1_400602_244814 n1_422794_244814 0.073
R15-109-118 n1_422794_244814 n1_445290_244814 0.074
R15-109-119 n1_445290_244814 n1_467482_244814 0.073
R15-109-120 n1_467482_244814 n1_489978_244814 0.074
R15-109-121 n1_489978_244814 n1_512170_244814 0.073
R15-109-122 n1_512170_244814 n1_534666_244814 0.074
R15-109-123 n1_534666_244814 n1_556858_244814 0.073
R15-109-124 n1_556858_244814 n1_579050_244814 0.073
R15-109-125 n1_579050_244814 n1_601546_244814 0.074
R15-109-126 n1_601546_244814 n1_625064_244814 0.07736180000000001
R15-109-127 n1_625064_244814 n1_627064_244814 0.00657895
R15-110-100 n1_44000_266702 n1_46000_266702 0.00657895
R15-110-101 n1_46000_266702 n1_65594_266702 0.0644539
R15-110-102 n1_65594_266702 n1_88090_266702 0.074
R15-110-103 n1_88090_266702 n1_110282_266702 0.073
R15-110-104 n1_110282_266702 n1_132778_266702 0.074
R15-110-105 n1_132778_266702 n1_154970_266702 0.073
R15-110-106 n1_154970_266702 n1_177466_266702 0.074
R15-110-107 n1_177466_266702 n1_199658_266702 0.073
R15-110-108 n1_199658_266702 n1_221850_266702 0.073
R15-110-109 n1_221850_266702 n1_244346_266702 0.074
R15-110-110 n1_244346_266702 n1_266538_266702 0.073
R15-110-111 n1_266538_266702 n1_289034_266702 0.074
R15-110-112 n1_289034_266702 n1_311226_266702 0.073
R15-110-113 n1_311226_266702 n1_333722_266702 0.074
R15-110-114 n1_333722_266702 n1_355914_266702 0.073
R15-110-115 n1_355914_266702 n1_378410_266702 0.074
R15-110-116 n1_378410_266702 n1_400602_266702 0.073
R15-110-117 n1_400602_266702 n1_422794_266702 0.073
R15-110-118 n1_422794_266702 n1_445290_266702 0.074
R15-110-119 n1_445290_266702 n1_467482_266702 0.073
R15-110-120 n1_467482_266702 n1_489978_266702 0.074
R15-110-121 n1_489978_266702 n1_512170_266702 0.073
R15-110-122 n1_512170_266702 n1_534666_266702 0.074
R15-110-123 n1_534666_266702 n1_556858_266702 0.073
R15-110-124 n1_556858_266702 n1_579050_266702 0.073
R15-110-125 n1_579050_266702 n1_601546_266702 0.074
R15-110-126 n1_601546_266702 n1_625064_266702 0.07736180000000001
R15-110-127 n1_625064_266702 n1_627064_266702 0.00657895
R15-111-100 n1_44000_288590 n1_46000_288590 0.00657895
R15-111-101 n1_46000_288590 n1_65594_288590 0.0644539
R15-111-102 n1_65594_288590 n1_88090_288590 0.074
R15-111-103 n1_88090_288590 n1_110282_288590 0.073
R15-111-104 n1_110282_288590 n1_132778_288590 0.074
R15-111-105 n1_132778_288590 n1_154970_288590 0.073
R15-111-106 n1_154970_288590 n1_177466_288590 0.074
R15-111-107 n1_177466_288590 n1_199658_288590 0.073
R15-111-108 n1_199658_288590 n1_221850_288590 0.073
R15-111-109 n1_221850_288590 n1_244346_288590 0.074
R15-111-110 n1_244346_288590 n1_266538_288590 0.073
R15-111-111 n1_266538_288590 n1_289034_288590 0.074
R15-111-112 n1_289034_288590 n1_311226_288590 0.073
R15-111-113 n1_311226_288590 n1_333722_288590 0.074
R15-111-114 n1_333722_288590 n1_355914_288590 0.073
R15-111-115 n1_355914_288590 n1_378410_288590 0.074
R15-111-116 n1_378410_288590 n1_400602_288590 0.073
R15-111-117 n1_400602_288590 n1_422794_288590 0.073
R15-111-118 n1_422794_288590 n1_445290_288590 0.074
R15-111-119 n1_445290_288590 n1_467482_288590 0.073
R15-111-120 n1_467482_288590 n1_489978_288590 0.074
R15-111-121 n1_489978_288590 n1_512170_288590 0.073
R15-111-122 n1_512170_288590 n1_534666_288590 0.074
R15-111-123 n1_534666_288590 n1_556858_288590 0.073
R15-111-124 n1_556858_288590 n1_579050_288590 0.073
R15-111-125 n1_579050_288590 n1_601546_288590 0.074
R15-111-126 n1_601546_288590 n1_625064_288590 0.07736180000000001
R15-111-127 n1_625064_288590 n1_627064_288590 0.00657895
R15-112-100 n1_44000_311086 n1_46000_311086 0.00657895
R15-112-101 n1_46000_311086 n1_65594_311086 0.0644539
R15-112-102 n1_65594_311086 n1_88090_311086 0.074
R15-112-103 n1_88090_311086 n1_110282_311086 0.073
R15-112-104 n1_110282_311086 n1_132778_311086 0.074
R15-112-105 n1_132778_311086 n1_154970_311086 0.073
R15-112-106 n1_154970_311086 n1_177466_311086 0.074
R15-112-107 n1_177466_311086 n1_199658_311086 0.073
R15-112-108 n1_199658_311086 n1_221850_311086 0.073
R15-112-109 n1_221850_311086 n1_244346_311086 0.074
R15-112-110 n1_244346_311086 n1_266538_311086 0.073
R15-112-111 n1_266538_311086 n1_289034_311086 0.074
R15-112-112 n1_289034_311086 n1_311226_311086 0.073
R15-112-113 n1_311226_311086 n1_333722_311086 0.074
R15-112-114 n1_333722_311086 n1_355914_311086 0.073
R15-112-115 n1_355914_311086 n1_378410_311086 0.074
R15-112-116 n1_378410_311086 n1_400602_311086 0.073
R15-112-117 n1_400602_311086 n1_422794_311086 0.073
R15-112-118 n1_422794_311086 n1_445290_311086 0.074
R15-112-119 n1_445290_311086 n1_467482_311086 0.073
R15-112-120 n1_467482_311086 n1_489978_311086 0.074
R15-112-121 n1_489978_311086 n1_512170_311086 0.073
R15-112-122 n1_512170_311086 n1_534666_311086 0.074
R15-112-123 n1_534666_311086 n1_556858_311086 0.073
R15-112-124 n1_556858_311086 n1_579050_311086 0.073
R15-112-125 n1_579050_311086 n1_601546_311086 0.074
R15-112-126 n1_601546_311086 n1_625064_311086 0.07736180000000001
R15-112-127 n1_625064_311086 n1_627064_311086 0.00657895
R15-113-100 n1_44000_332974 n1_46000_332974 0.00657895
R15-113-101 n1_46000_332974 n1_65594_332974 0.0644539
R15-113-102 n1_65594_332974 n1_88090_332974 0.074
R15-113-103 n1_88090_332974 n1_110282_332974 0.073
R15-113-104 n1_110282_332974 n1_132778_332974 0.074
R15-113-105 n1_132778_332974 n1_154970_332974 0.073
R15-113-106 n1_154970_332974 n1_177466_332974 0.074
R15-113-107 n1_177466_332974 n1_199658_332974 0.073
R15-113-108 n1_199658_332974 n1_221850_332974 0.073
R15-113-109 n1_221850_332974 n1_244346_332974 0.074
R15-113-110 n1_244346_332974 n1_266538_332974 0.073
R15-113-111 n1_266538_332974 n1_289034_332974 0.074
R15-113-112 n1_289034_332974 n1_311226_332974 0.073
R15-113-113 n1_311226_332974 n1_333722_332974 0.074
R15-113-114 n1_333722_332974 n1_355914_332974 0.073
R15-113-115 n1_355914_332974 n1_378410_332974 0.074
R15-113-116 n1_378410_332974 n1_400602_332974 0.073
R15-113-117 n1_400602_332974 n1_422794_332974 0.073
R15-113-118 n1_422794_332974 n1_445290_332974 0.074
R15-113-119 n1_445290_332974 n1_467482_332974 0.073
R15-113-120 n1_467482_332974 n1_489978_332974 0.074
R15-113-121 n1_489978_332974 n1_512170_332974 0.073
R15-113-122 n1_512170_332974 n1_534666_332974 0.074
R15-113-123 n1_534666_332974 n1_556858_332974 0.073
R15-113-124 n1_556858_332974 n1_579050_332974 0.073
R15-113-125 n1_579050_332974 n1_601546_332974 0.074
R15-113-126 n1_601546_332974 n1_625064_332974 0.07736180000000001
R15-113-127 n1_625064_332974 n1_627064_332974 0.00657895
R15-114-100 n1_44000_355470 n1_46000_355470 0.00657895
R15-114-101 n1_46000_355470 n1_65594_355470 0.0644539
R15-114-102 n1_65594_355470 n1_88090_355470 0.074
R15-114-103 n1_88090_355470 n1_110282_355470 0.073
R15-114-104 n1_110282_355470 n1_132778_355470 0.074
R15-114-105 n1_132778_355470 n1_154970_355470 0.073
R15-114-106 n1_154970_355470 n1_177466_355470 0.074
R15-114-107 n1_177466_355470 n1_199658_355470 0.073
R15-114-108 n1_199658_355470 n1_221850_355470 0.073
R15-114-109 n1_221850_355470 n1_244346_355470 0.074
R15-114-110 n1_244346_355470 n1_266538_355470 0.073
R15-114-111 n1_266538_355470 n1_289034_355470 0.074
R15-114-112 n1_289034_355470 n1_311226_355470 0.073
R15-114-113 n1_311226_355470 n1_333722_355470 0.074
R15-114-114 n1_333722_355470 n1_355914_355470 0.073
R15-114-115 n1_355914_355470 n1_378410_355470 0.074
R15-114-116 n1_378410_355470 n1_400602_355470 0.073
R15-114-117 n1_400602_355470 n1_422794_355470 0.073
R15-114-118 n1_422794_355470 n1_445290_355470 0.074
R15-114-119 n1_445290_355470 n1_467482_355470 0.073
R15-114-120 n1_467482_355470 n1_489978_355470 0.074
R15-114-121 n1_489978_355470 n1_512170_355470 0.073
R15-114-122 n1_512170_355470 n1_534666_355470 0.074
R15-114-123 n1_534666_355470 n1_556858_355470 0.073
R15-114-124 n1_556858_355470 n1_579050_355470 0.073
R15-114-125 n1_579050_355470 n1_601546_355470 0.074
R15-114-126 n1_601546_355470 n1_625064_355470 0.07736180000000001
R15-114-127 n1_625064_355470 n1_627064_355470 0.00657895
R15-115-100 n1_44000_377358 n1_46000_377358 0.00657895
R15-115-101 n1_46000_377358 n1_65594_377358 0.0644539
R15-115-102 n1_65594_377358 n1_88090_377358 0.074
R15-115-103 n1_88090_377358 n1_110282_377358 0.073
R15-115-104 n1_110282_377358 n1_132778_377358 0.074
R15-115-105 n1_132778_377358 n1_154970_377358 0.073
R15-115-106 n1_154970_377358 n1_177466_377358 0.074
R15-115-107 n1_177466_377358 n1_199658_377358 0.073
R15-115-108 n1_199658_377358 n1_221850_377358 0.073
R15-115-109 n1_221850_377358 n1_244346_377358 0.074
R15-115-110 n1_244346_377358 n1_266538_377358 0.073
R15-115-111 n1_266538_377358 n1_289034_377358 0.074
R15-115-112 n1_289034_377358 n1_311226_377358 0.073
R15-115-113 n1_311226_377358 n1_333722_377358 0.074
R15-115-114 n1_333722_377358 n1_355914_377358 0.073
R15-115-115 n1_355914_377358 n1_378410_377358 0.074
R15-115-116 n1_378410_377358 n1_400602_377358 0.073
R15-115-117 n1_400602_377358 n1_422794_377358 0.073
R15-115-118 n1_422794_377358 n1_445290_377358 0.074
R15-115-119 n1_445290_377358 n1_467482_377358 0.073
R15-115-120 n1_467482_377358 n1_489978_377358 0.074
R15-115-121 n1_489978_377358 n1_512170_377358 0.073
R15-115-122 n1_512170_377358 n1_534666_377358 0.074
R15-115-123 n1_534666_377358 n1_556858_377358 0.073
R15-115-124 n1_556858_377358 n1_579050_377358 0.073
R15-115-125 n1_579050_377358 n1_601546_377358 0.074
R15-115-126 n1_601546_377358 n1_625064_377358 0.07736180000000001
R15-115-127 n1_625064_377358 n1_627064_377358 0.00657895
R15-116-100 n1_44000_399854 n1_46000_399854 0.00657895
R15-116-101 n1_46000_399854 n1_65594_399854 0.0644539
R15-116-102 n1_65594_399854 n1_88090_399854 0.074
R15-116-103 n1_88090_399854 n1_110282_399854 0.073
R15-116-104 n1_110282_399854 n1_132778_399854 0.074
R15-116-105 n1_132778_399854 n1_154970_399854 0.073
R15-116-106 n1_154970_399854 n1_177466_399854 0.074
R15-116-107 n1_177466_399854 n1_199658_399854 0.073
R15-116-108 n1_199658_399854 n1_221850_399854 0.073
R15-116-109 n1_221850_399854 n1_244346_399854 0.074
R15-116-110 n1_244346_399854 n1_266538_399854 0.073
R15-116-111 n1_266538_399854 n1_289034_399854 0.074
R15-116-112 n1_289034_399854 n1_311226_399854 0.073
R15-116-113 n1_311226_399854 n1_333722_399854 0.074
R15-116-114 n1_333722_399854 n1_355914_399854 0.073
R15-116-115 n1_355914_399854 n1_378410_399854 0.074
R15-116-116 n1_378410_399854 n1_400602_399854 0.073
R15-116-117 n1_400602_399854 n1_422794_399854 0.073
R15-116-118 n1_422794_399854 n1_445290_399854 0.074
R15-116-119 n1_445290_399854 n1_467482_399854 0.073
R15-116-120 n1_467482_399854 n1_489978_399854 0.074
R15-116-121 n1_489978_399854 n1_512170_399854 0.073
R15-116-122 n1_512170_399854 n1_534666_399854 0.074
R15-116-123 n1_534666_399854 n1_556858_399854 0.073
R15-116-124 n1_556858_399854 n1_579050_399854 0.073
R15-116-125 n1_579050_399854 n1_601546_399854 0.074
R15-116-126 n1_601546_399854 n1_625064_399854 0.07736180000000001
R15-116-127 n1_625064_399854 n1_627064_399854 0.00657895
R15-117-100 n1_44000_421742 n1_46000_421742 0.00657895
R15-117-101 n1_46000_421742 n1_65594_421742 0.0644539
R15-117-102 n1_65594_421742 n1_88090_421742 0.074
R15-117-103 n1_88090_421742 n1_110282_421742 0.073
R15-117-104 n1_110282_421742 n1_132778_421742 0.074
R15-117-105 n1_132778_421742 n1_154970_421742 0.073
R15-117-106 n1_154970_421742 n1_177466_421742 0.074
R15-117-107 n1_177466_421742 n1_199658_421742 0.073
R15-117-108 n1_199658_421742 n1_221850_421742 0.073
R15-117-109 n1_221850_421742 n1_244346_421742 0.074
R15-117-110 n1_244346_421742 n1_266538_421742 0.073
R15-117-111 n1_266538_421742 n1_289034_421742 0.074
R15-117-112 n1_289034_421742 n1_311226_421742 0.073
R15-117-113 n1_311226_421742 n1_333722_421742 0.074
R15-117-114 n1_333722_421742 n1_355914_421742 0.073
R15-117-115 n1_355914_421742 n1_378410_421742 0.074
R15-117-116 n1_378410_421742 n1_400602_421742 0.073
R15-117-117 n1_400602_421742 n1_422794_421742 0.073
R15-117-118 n1_422794_421742 n1_445290_421742 0.074
R15-117-119 n1_445290_421742 n1_467482_421742 0.073
R15-117-120 n1_467482_421742 n1_489978_421742 0.074
R15-117-121 n1_489978_421742 n1_512170_421742 0.073
R15-117-122 n1_512170_421742 n1_534666_421742 0.074
R15-117-123 n1_534666_421742 n1_556858_421742 0.073
R15-117-124 n1_556858_421742 n1_579050_421742 0.073
R15-117-125 n1_579050_421742 n1_601546_421742 0.074
R15-117-126 n1_601546_421742 n1_625064_421742 0.07736180000000001
R15-117-127 n1_625064_421742 n1_627064_421742 0.00657895
R15-118-100 n1_44000_444238 n1_46000_444238 0.00657895
R15-118-101 n1_46000_444238 n1_65594_444238 0.0644539
R15-118-102 n1_65594_444238 n1_88090_444238 0.074
R15-118-103 n1_88090_444238 n1_110282_444238 0.073
R15-118-104 n1_110282_444238 n1_132778_444238 0.074
R15-118-105 n1_132778_444238 n1_154970_444238 0.073
R15-118-106 n1_154970_444238 n1_177466_444238 0.074
R15-118-107 n1_177466_444238 n1_199658_444238 0.073
R15-118-108 n1_199658_444238 n1_221850_444238 0.073
R15-118-109 n1_221850_444238 n1_244346_444238 0.074
R15-118-110 n1_244346_444238 n1_266538_444238 0.073
R15-118-111 n1_266538_444238 n1_289034_444238 0.074
R15-118-112 n1_289034_444238 n1_311226_444238 0.073
R15-118-113 n1_311226_444238 n1_333722_444238 0.074
R15-118-114 n1_333722_444238 n1_355914_444238 0.073
R15-118-115 n1_355914_444238 n1_378410_444238 0.074
R15-118-116 n1_378410_444238 n1_400602_444238 0.073
R15-118-117 n1_400602_444238 n1_422794_444238 0.073
R15-118-118 n1_422794_444238 n1_445290_444238 0.074
R15-118-119 n1_445290_444238 n1_467482_444238 0.073
R15-118-120 n1_467482_444238 n1_489978_444238 0.074
R15-118-121 n1_489978_444238 n1_512170_444238 0.073
R15-118-122 n1_512170_444238 n1_534666_444238 0.074
R15-118-123 n1_534666_444238 n1_556858_444238 0.073
R15-118-124 n1_556858_444238 n1_579050_444238 0.073
R15-118-125 n1_579050_444238 n1_601546_444238 0.074
R15-118-126 n1_601546_444238 n1_625064_444238 0.07736180000000001
R15-118-127 n1_625064_444238 n1_627064_444238 0.00657895
R15-119-100 n1_44000_466126 n1_46000_466126 0.00657895
R15-119-101 n1_46000_466126 n1_65594_466126 0.0644539
R15-119-102 n1_65594_466126 n1_88090_466126 0.074
R15-119-103 n1_88090_466126 n1_110282_466126 0.073
R15-119-104 n1_110282_466126 n1_132778_466126 0.074
R15-119-105 n1_132778_466126 n1_154970_466126 0.073
R15-119-106 n1_154970_466126 n1_177466_466126 0.074
R15-119-107 n1_177466_466126 n1_199658_466126 0.073
R15-119-108 n1_199658_466126 n1_221850_466126 0.073
R15-119-109 n1_221850_466126 n1_244346_466126 0.074
R15-119-110 n1_244346_466126 n1_266538_466126 0.073
R15-119-111 n1_266538_466126 n1_289034_466126 0.074
R15-119-112 n1_289034_466126 n1_311226_466126 0.073
R15-119-113 n1_311226_466126 n1_333722_466126 0.074
R15-119-114 n1_333722_466126 n1_355914_466126 0.073
R15-119-115 n1_355914_466126 n1_378410_466126 0.074
R15-119-116 n1_378410_466126 n1_400602_466126 0.073
R15-119-117 n1_400602_466126 n1_422794_466126 0.073
R15-119-118 n1_422794_466126 n1_445290_466126 0.074
R15-119-119 n1_445290_466126 n1_467482_466126 0.073
R15-119-120 n1_467482_466126 n1_489978_466126 0.074
R15-119-121 n1_489978_466126 n1_512170_466126 0.073
R15-119-122 n1_512170_466126 n1_534666_466126 0.074
R15-119-123 n1_534666_466126 n1_556858_466126 0.073
R15-119-124 n1_556858_466126 n1_579050_466126 0.073
R15-119-125 n1_579050_466126 n1_601546_466126 0.074
R15-119-126 n1_601546_466126 n1_625064_466126 0.07736180000000001
R15-119-127 n1_625064_466126 n1_627064_466126 0.00657895
R15-120-100 n1_44000_488622 n1_46000_488622 0.00657895
R15-120-101 n1_46000_488622 n1_65594_488622 0.0644539
R15-120-102 n1_65594_488622 n1_88090_488622 0.074
R15-120-103 n1_88090_488622 n1_110282_488622 0.073
R15-120-104 n1_110282_488622 n1_132778_488622 0.074
R15-120-105 n1_132778_488622 n1_154970_488622 0.073
R15-120-106 n1_154970_488622 n1_177466_488622 0.074
R15-120-107 n1_177466_488622 n1_199658_488622 0.073
R15-120-108 n1_199658_488622 n1_221850_488622 0.073
R15-120-109 n1_221850_488622 n1_244346_488622 0.074
R15-120-110 n1_244346_488622 n1_266538_488622 0.073
R15-120-111 n1_266538_488622 n1_289034_488622 0.074
R15-120-112 n1_289034_488622 n1_311226_488622 0.073
R15-120-113 n1_311226_488622 n1_333722_488622 0.074
R15-120-114 n1_333722_488622 n1_355914_488622 0.073
R15-120-115 n1_355914_488622 n1_378410_488622 0.074
R15-120-116 n1_378410_488622 n1_400602_488622 0.073
R15-120-117 n1_400602_488622 n1_422794_488622 0.073
R15-120-118 n1_422794_488622 n1_445290_488622 0.074
R15-120-119 n1_445290_488622 n1_467482_488622 0.073
R15-120-120 n1_467482_488622 n1_489978_488622 0.074
R15-120-121 n1_489978_488622 n1_512170_488622 0.073
R15-120-122 n1_512170_488622 n1_534666_488622 0.074
R15-120-123 n1_534666_488622 n1_556858_488622 0.073
R15-120-124 n1_556858_488622 n1_579050_488622 0.073
R15-120-125 n1_579050_488622 n1_601546_488622 0.074
R15-120-126 n1_601546_488622 n1_625064_488622 0.07736180000000001
R15-120-127 n1_625064_488622 n1_627064_488622 0.00657895
R15-121-100 n1_44000_510510 n1_46000_510510 0.00657895
R15-121-101 n1_46000_510510 n1_65594_510510 0.0644539
R15-121-102 n1_65594_510510 n1_88090_510510 0.074
R15-121-103 n1_88090_510510 n1_110282_510510 0.073
R15-121-104 n1_110282_510510 n1_132778_510510 0.074
R15-121-105 n1_132778_510510 n1_154970_510510 0.073
R15-121-106 n1_154970_510510 n1_177466_510510 0.074
R15-121-107 n1_177466_510510 n1_199658_510510 0.073
R15-121-108 n1_199658_510510 n1_221850_510510 0.073
R15-121-109 n1_221850_510510 n1_244346_510510 0.074
R15-121-110 n1_244346_510510 n1_266538_510510 0.073
R15-121-111 n1_266538_510510 n1_289034_510510 0.074
R15-121-112 n1_289034_510510 n1_311226_510510 0.073
R15-121-113 n1_311226_510510 n1_333722_510510 0.074
R15-121-114 n1_333722_510510 n1_355914_510510 0.073
R15-121-115 n1_355914_510510 n1_378410_510510 0.074
R15-121-116 n1_378410_510510 n1_400602_510510 0.073
R15-121-117 n1_400602_510510 n1_422794_510510 0.073
R15-121-118 n1_422794_510510 n1_445290_510510 0.074
R15-121-119 n1_445290_510510 n1_467482_510510 0.073
R15-121-120 n1_467482_510510 n1_489978_510510 0.074
R15-121-121 n1_489978_510510 n1_512170_510510 0.073
R15-121-122 n1_512170_510510 n1_534666_510510 0.074
R15-121-123 n1_534666_510510 n1_556858_510510 0.073
R15-121-124 n1_556858_510510 n1_579050_510510 0.073
R15-121-125 n1_579050_510510 n1_601546_510510 0.074
R15-121-126 n1_601546_510510 n1_625064_510510 0.07736180000000001
R15-121-127 n1_625064_510510 n1_627064_510510 0.00657895
R15-122-100 n1_44000_532398 n1_46000_532398 0.00657895
R15-122-101 n1_46000_532398 n1_65594_532398 0.0644539
R15-122-102 n1_65594_532398 n1_88090_532398 0.074
R15-122-103 n1_88090_532398 n1_110282_532398 0.073
R15-122-104 n1_110282_532398 n1_132778_532398 0.074
R15-122-105 n1_132778_532398 n1_154970_532398 0.073
R15-122-106 n1_154970_532398 n1_177466_532398 0.074
R15-122-107 n1_177466_532398 n1_199658_532398 0.073
R15-122-108 n1_199658_532398 n1_221850_532398 0.073
R15-122-109 n1_221850_532398 n1_244346_532398 0.074
R15-122-110 n1_244346_532398 n1_266538_532398 0.073
R15-122-111 n1_266538_532398 n1_289034_532398 0.074
R15-122-112 n1_289034_532398 n1_311226_532398 0.073
R15-122-113 n1_311226_532398 n1_333722_532398 0.074
R15-122-114 n1_333722_532398 n1_355914_532398 0.073
R15-122-115 n1_355914_532398 n1_378410_532398 0.074
R15-122-116 n1_378410_532398 n1_400602_532398 0.073
R15-122-117 n1_400602_532398 n1_422794_532398 0.073
R15-122-118 n1_422794_532398 n1_445290_532398 0.074
R15-122-119 n1_445290_532398 n1_467482_532398 0.073
R15-122-120 n1_467482_532398 n1_489978_532398 0.074
R15-122-121 n1_489978_532398 n1_512170_532398 0.073
R15-122-122 n1_512170_532398 n1_534666_532398 0.074
R15-122-123 n1_534666_532398 n1_556858_532398 0.073
R15-122-124 n1_556858_532398 n1_579050_532398 0.073
R15-122-125 n1_579050_532398 n1_601546_532398 0.074
R15-122-126 n1_601546_532398 n1_625064_532398 0.07736180000000001
R15-122-127 n1_625064_532398 n1_627064_532398 0.00657895
R15-123-100 n1_44000_554894 n1_46000_554894 0.00657895
R15-123-101 n1_46000_554894 n1_65594_554894 0.0644539
R15-123-102 n1_65594_554894 n1_88090_554894 0.074
R15-123-103 n1_88090_554894 n1_110282_554894 0.073
R15-123-104 n1_110282_554894 n1_132778_554894 0.074
R15-123-105 n1_132778_554894 n1_154970_554894 0.073
R15-123-106 n1_154970_554894 n1_177466_554894 0.074
R15-123-107 n1_177466_554894 n1_199658_554894 0.073
R15-123-108 n1_199658_554894 n1_221850_554894 0.073
R15-123-109 n1_221850_554894 n1_244346_554894 0.074
R15-123-110 n1_244346_554894 n1_266538_554894 0.073
R15-123-111 n1_266538_554894 n1_289034_554894 0.074
R15-123-112 n1_289034_554894 n1_311226_554894 0.073
R15-123-113 n1_311226_554894 n1_333722_554894 0.074
R15-123-114 n1_333722_554894 n1_355914_554894 0.073
R15-123-115 n1_355914_554894 n1_378410_554894 0.074
R15-123-116 n1_378410_554894 n1_400602_554894 0.073
R15-123-117 n1_400602_554894 n1_422794_554894 0.073
R15-123-118 n1_422794_554894 n1_445290_554894 0.074
R15-123-119 n1_445290_554894 n1_467482_554894 0.073
R15-123-120 n1_467482_554894 n1_489978_554894 0.074
R15-123-121 n1_489978_554894 n1_512170_554894 0.073
R15-123-122 n1_512170_554894 n1_534666_554894 0.074
R15-123-123 n1_534666_554894 n1_556858_554894 0.073
R15-123-124 n1_556858_554894 n1_579050_554894 0.073
R15-123-125 n1_579050_554894 n1_601546_554894 0.074
R15-123-126 n1_601546_554894 n1_625064_554894 0.07736180000000001
R15-123-127 n1_625064_554894 n1_627064_554894 0.00657895
R15-124-100 n1_44000_576782 n1_46000_576782 0.00657895
R15-124-101 n1_46000_576782 n1_65594_576782 0.0644539
R15-124-102 n1_65594_576782 n1_88090_576782 0.074
R15-124-103 n1_88090_576782 n1_110282_576782 0.073
R15-124-104 n1_110282_576782 n1_132778_576782 0.074
R15-124-105 n1_132778_576782 n1_154970_576782 0.073
R15-124-106 n1_154970_576782 n1_177466_576782 0.074
R15-124-107 n1_177466_576782 n1_199658_576782 0.073
R15-124-108 n1_199658_576782 n1_221850_576782 0.073
R15-124-109 n1_221850_576782 n1_244346_576782 0.074
R15-124-110 n1_244346_576782 n1_266538_576782 0.073
R15-124-111 n1_266538_576782 n1_289034_576782 0.074
R15-124-112 n1_289034_576782 n1_311226_576782 0.073
R15-124-113 n1_311226_576782 n1_333722_576782 0.074
R15-124-114 n1_333722_576782 n1_355914_576782 0.073
R15-124-115 n1_355914_576782 n1_378410_576782 0.074
R15-124-116 n1_378410_576782 n1_400602_576782 0.073
R15-124-117 n1_400602_576782 n1_422794_576782 0.073
R15-124-118 n1_422794_576782 n1_445290_576782 0.074
R15-124-119 n1_445290_576782 n1_467482_576782 0.073
R15-124-120 n1_467482_576782 n1_489978_576782 0.074
R15-124-121 n1_489978_576782 n1_512170_576782 0.073
R15-124-122 n1_512170_576782 n1_534666_576782 0.074
R15-124-123 n1_534666_576782 n1_556858_576782 0.073
R15-124-124 n1_556858_576782 n1_579050_576782 0.073
R15-124-125 n1_579050_576782 n1_601546_576782 0.074
R15-124-126 n1_601546_576782 n1_625064_576782 0.07736180000000001
R15-124-127 n1_625064_576782 n1_627064_576782 0.00657895
R15-125-100 n1_44000_599278 n1_46000_599278 0.00657895
R15-125-101 n1_46000_599278 n1_65594_599278 0.0644539
R15-125-102 n1_65594_599278 n1_88090_599278 0.074
R15-125-103 n1_88090_599278 n1_110282_599278 0.073
R15-125-104 n1_110282_599278 n1_132778_599278 0.074
R15-125-105 n1_132778_599278 n1_154970_599278 0.073
R15-125-106 n1_154970_599278 n1_177466_599278 0.074
R15-125-107 n1_177466_599278 n1_199658_599278 0.073
R15-125-108 n1_199658_599278 n1_221850_599278 0.073
R15-125-109 n1_221850_599278 n1_244346_599278 0.074
R15-125-110 n1_244346_599278 n1_266538_599278 0.073
R15-125-111 n1_266538_599278 n1_289034_599278 0.074
R15-125-112 n1_289034_599278 n1_311226_599278 0.073
R15-125-113 n1_311226_599278 n1_333722_599278 0.074
R15-125-114 n1_333722_599278 n1_355914_599278 0.073
R15-125-115 n1_355914_599278 n1_378410_599278 0.074
R15-125-116 n1_378410_599278 n1_400602_599278 0.073
R15-125-117 n1_400602_599278 n1_422794_599278 0.073
R15-125-118 n1_422794_599278 n1_445290_599278 0.074
R15-125-119 n1_445290_599278 n1_467482_599278 0.073
R15-125-120 n1_467482_599278 n1_489978_599278 0.074
R15-125-121 n1_489978_599278 n1_512170_599278 0.073
R15-125-122 n1_512170_599278 n1_534666_599278 0.074
R15-125-123 n1_534666_599278 n1_556858_599278 0.073
R15-125-124 n1_556858_599278 n1_579050_599278 0.073
R15-125-125 n1_579050_599278 n1_601546_599278 0.074
R15-125-126 n1_601546_599278 n1_625064_599278 0.07736180000000001
R15-125-127 n1_625064_599278 n1_627064_599278 0.00657895
R15-126-100 n1_0_624152 n1_28_624152 7e-05
R15-126-101 n1_28_624152 n1_46000_624152 0.11493
R15-126-102 n1_46000_624152 n1_65594_624152 0.048985
R15-126-103 n1_65594_624152 n1_88090_624152 0.05624
R15-126-104 n1_88090_624152 n1_110282_624152 0.055479999999999995
R15-126-105 n1_110282_624152 n1_132778_624152 0.05624
R15-126-106 n1_132778_624152 n1_154970_624152 0.055479999999999995
R15-126-107 n1_154970_624152 n1_177466_624152 0.05624
R15-126-108 n1_177466_624152 n1_199658_624152 0.055479999999999995
R15-126-109 n1_199658_624152 n1_221850_624152 0.055479999999999995
R15-126-110 n1_221850_624152 n1_244346_624152 0.05624
R15-126-111 n1_244346_624152 n1_266538_624152 0.055479999999999995
R15-126-112 n1_266538_624152 n1_289034_624152 0.05624
R15-126-113 n1_289034_624152 n1_311226_624152 0.055479999999999995
R15-126-114 n1_311226_624152 n1_333722_624152 0.05624
R15-126-115 n1_333722_624152 n1_355914_624152 0.055479999999999995
R15-126-116 n1_355914_624152 n1_378410_624152 0.05624
R15-126-117 n1_378410_624152 n1_400602_624152 0.055479999999999995
R15-126-118 n1_400602_624152 n1_422794_624152 0.055479999999999995
R15-126-119 n1_422794_624152 n1_445290_624152 0.05624
R15-126-120 n1_445290_624152 n1_467482_624152 0.055479999999999995
R15-126-121 n1_467482_624152 n1_489978_624152 0.05624
R15-126-122 n1_489978_624152 n1_512170_624152 0.055479999999999995
R15-126-123 n1_512170_624152 n1_534666_624152 0.05624
R15-126-124 n1_534666_624152 n1_556858_624152 0.055479999999999995
R15-126-125 n1_556858_624152 n1_579050_624152 0.055479999999999995
R15-126-126 n1_579050_624152 n1_601546_624152 0.05624
R15-126-127 n1_601546_624152 n1_625064_624152 0.058795
R15-126-128 n1_625064_624152 n1_671036_624152 0.11493
R15-126-129 n1_671036_624152 n1_671064_624152 7e-05
R11-100-100 n1_44000_50000 n1_46000_50000 0.357143
R11-101-100 n1_44000_50000 n1_46000_50000 0.333333
R11-101-101 n1_46000_50000 n1_48000_50000 0.357143
R11-102-100 n1_46000_50000 n1_48000_50000 0.333333
R11-102-101 n1_48000_50000 n1_65594_50000 3.14179
R11-102-102 n1_65594_50000 n1_88090_50000 4.0171399999999995
R11-102-103 n1_88090_50000 n1_110282_50000 3.96286
R11-102-104 n1_110282_50000 n1_132778_50000 4.0171399999999995
R11-102-105 n1_132778_50000 n1_154970_50000 3.96286
R11-102-106 n1_154970_50000 n1_177466_50000 4.0171399999999995
R11-102-107 n1_177466_50000 n1_199658_50000 3.96286
R11-102-108 n1_199658_50000 n1_221850_50000 3.96286
R11-102-109 n1_221850_50000 n1_244346_50000 4.0171399999999995
R11-102-110 n1_244346_50000 n1_266538_50000 3.96286
R11-102-111 n1_266538_50000 n1_289034_50000 4.0171399999999995
R11-102-112 n1_289034_50000 n1_311226_50000 3.96286
R11-102-113 n1_311226_50000 n1_333722_50000 4.0171399999999995
R11-102-114 n1_333722_50000 n1_355914_50000 3.96286
R11-102-115 n1_355914_50000 n1_378410_50000 4.0171399999999995
R11-102-116 n1_378410_50000 n1_400602_50000 3.96286
R11-102-117 n1_400602_50000 n1_422794_50000 3.96286
R11-102-118 n1_422794_50000 n1_445290_50000 4.0171399999999995
R11-102-119 n1_445290_50000 n1_467482_50000 3.96286
R11-102-120 n1_467482_50000 n1_489978_50000 4.0171399999999995
R11-102-121 n1_489978_50000 n1_512170_50000 3.96286
R11-102-122 n1_512170_50000 n1_534666_50000 4.0171399999999995
R11-102-123 n1_534666_50000 n1_556858_50000 3.96286
R11-102-124 n1_556858_50000 n1_579050_50000 3.96286
R11-102-125 n1_579050_50000 n1_601546_50000 4.0171399999999995
R11-102-126 n1_601546_50000 n1_623064_50000 3.8425
R11-102-127 n1_623064_50000 n1_625064_50000 0.357143
R11-103-100 n1_623064_50000 n1_625064_50000 0.333333
R11-103-101 n1_625064_50000 n1_627064_50000 0.333333
R11-104-100 n1_625064_50000 n1_627064_50000 0.357143
R11-105-100 n1_44000_53344 n1_46000_53344 0.357143
R11-106-100 n1_44000_53344 n1_46000_53344 0.333333
R11-106-101 n1_46000_53344 n1_48000_53344 0.357143
R11-107-100 n1_46000_53344 n1_48000_53344 0.333333
R11-107-101 n1_48000_53344 n1_65594_53344 3.14179
R11-107-102 n1_65594_53344 n1_88090_53344 4.0171399999999995
R11-107-103 n1_88090_53344 n1_110282_53344 3.96286
R11-107-104 n1_110282_53344 n1_132778_53344 4.0171399999999995
R11-107-105 n1_132778_53344 n1_154970_53344 3.96286
R11-107-106 n1_154970_53344 n1_177466_53344 4.0171399999999995
R11-107-107 n1_177466_53344 n1_199658_53344 3.96286
R11-107-108 n1_199658_53344 n1_221850_53344 3.96286
R11-107-109 n1_221850_53344 n1_244346_53344 4.0171399999999995
R11-107-110 n1_244346_53344 n1_266538_53344 3.96286
R11-107-111 n1_266538_53344 n1_289034_53344 4.0171399999999995
R11-107-112 n1_289034_53344 n1_311226_53344 3.96286
R11-107-113 n1_311226_53344 n1_333722_53344 4.0171399999999995
R11-107-114 n1_333722_53344 n1_355914_53344 3.96286
R11-107-115 n1_355914_53344 n1_378410_53344 4.0171399999999995
R11-107-116 n1_378410_53344 n1_400602_53344 3.96286
R11-107-117 n1_400602_53344 n1_422794_53344 3.96286
R11-107-118 n1_422794_53344 n1_445290_53344 4.0171399999999995
R11-107-119 n1_445290_53344 n1_467482_53344 3.96286
R11-107-120 n1_467482_53344 n1_489978_53344 4.0171399999999995
R11-107-121 n1_489978_53344 n1_512170_53344 3.96286
R11-107-122 n1_512170_53344 n1_534666_53344 4.0171399999999995
R11-107-123 n1_534666_53344 n1_556858_53344 3.96286
R11-107-124 n1_556858_53344 n1_579050_53344 3.96286
R11-107-125 n1_579050_53344 n1_601546_53344 4.0171399999999995
R11-107-126 n1_601546_53344 n1_623064_53344 3.8425
R11-107-127 n1_623064_53344 n1_625064_53344 0.333333
R11-108-100 n1_623064_53344 n1_625064_53344 0.357143
R11-108-101 n1_625064_53344 n1_627064_53344 0.333333
R11-109-100 n1_625064_53344 n1_627064_53344 0.357143
R11-110-100 n1_44000_56688 n1_46000_56688 0.357143
R11-111-100 n1_44000_56688 n1_46000_56688 0.333333
R11-111-101 n1_46000_56688 n1_48000_56688 0.357143
R11-112-100 n1_46000_56688 n1_48000_56688 0.333333
R11-112-101 n1_48000_56688 n1_65594_56688 3.14179
R11-112-102 n1_65594_56688 n1_88090_56688 4.0171399999999995
R11-112-103 n1_88090_56688 n1_110282_56688 3.96286
R11-112-104 n1_110282_56688 n1_132778_56688 4.0171399999999995
R11-112-105 n1_132778_56688 n1_154970_56688 3.96286
R11-112-106 n1_154970_56688 n1_177466_56688 4.0171399999999995
R11-112-107 n1_177466_56688 n1_199658_56688 3.96286
R11-112-108 n1_199658_56688 n1_221850_56688 3.96286
R11-112-109 n1_221850_56688 n1_244346_56688 4.0171399999999995
R11-112-110 n1_244346_56688 n1_266538_56688 3.96286
R11-112-111 n1_266538_56688 n1_289034_56688 4.0171399999999995
R11-112-112 n1_289034_56688 n1_311226_56688 3.96286
R11-112-113 n1_311226_56688 n1_333722_56688 4.0171399999999995
R11-112-114 n1_333722_56688 n1_355914_56688 3.96286
R11-112-115 n1_355914_56688 n1_378410_56688 4.0171399999999995
R11-112-116 n1_378410_56688 n1_400602_56688 3.96286
R11-112-117 n1_400602_56688 n1_422794_56688 3.96286
R11-112-118 n1_422794_56688 n1_445290_56688 4.0171399999999995
R11-112-119 n1_445290_56688 n1_467482_56688 3.96286
R11-112-120 n1_467482_56688 n1_489978_56688 4.0171399999999995
R11-112-121 n1_489978_56688 n1_512170_56688 3.96286
R11-112-122 n1_512170_56688 n1_534666_56688 4.0171399999999995
R11-112-123 n1_534666_56688 n1_556858_56688 3.96286
R11-112-124 n1_556858_56688 n1_579050_56688 3.96286
R11-112-125 n1_579050_56688 n1_601546_56688 4.0171399999999995
R11-112-126 n1_601546_56688 n1_623064_56688 3.8425
R11-112-127 n1_623064_56688 n1_625064_56688 0.333333
R11-113-100 n1_623064_56688 n1_625064_56688 0.357143
R11-113-101 n1_625064_56688 n1_627064_56688 0.357143
R11-114-100 n1_625064_56688 n1_627064_56688 0.333333
R11-115-100 n1_44000_60032 n1_46000_60032 0.357143
R11-116-100 n1_44000_60032 n1_46000_60032 0.333333
R11-116-101 n1_46000_60032 n1_48000_60032 0.357143
R11-117-100 n1_46000_60032 n1_48000_60032 0.333333
R11-117-101 n1_48000_60032 n1_65594_60032 3.14179
R11-117-102 n1_65594_60032 n1_88090_60032 4.0171399999999995
R11-117-103 n1_88090_60032 n1_110282_60032 3.96286
R11-117-104 n1_110282_60032 n1_132778_60032 4.0171399999999995
R11-117-105 n1_132778_60032 n1_154970_60032 3.96286
R11-117-106 n1_154970_60032 n1_177466_60032 4.0171399999999995
R11-117-107 n1_177466_60032 n1_199658_60032 3.96286
R11-117-108 n1_199658_60032 n1_221850_60032 3.96286
R11-117-109 n1_221850_60032 n1_244346_60032 4.0171399999999995
R11-117-110 n1_244346_60032 n1_266538_60032 3.96286
R11-117-111 n1_266538_60032 n1_289034_60032 4.0171399999999995
R11-117-112 n1_289034_60032 n1_311226_60032 3.96286
R11-117-113 n1_311226_60032 n1_333722_60032 4.0171399999999995
R11-117-114 n1_333722_60032 n1_355914_60032 3.96286
R11-117-115 n1_355914_60032 n1_378410_60032 4.0171399999999995
R11-117-116 n1_378410_60032 n1_400602_60032 3.96286
R11-117-117 n1_400602_60032 n1_422794_60032 3.96286
R11-117-118 n1_422794_60032 n1_445290_60032 4.0171399999999995
R11-117-119 n1_445290_60032 n1_467482_60032 3.96286
R11-117-120 n1_467482_60032 n1_489978_60032 4.0171399999999995
R11-117-121 n1_489978_60032 n1_512170_60032 3.96286
R11-117-122 n1_512170_60032 n1_534666_60032 4.0171399999999995
R11-117-123 n1_534666_60032 n1_556858_60032 3.96286
R11-117-124 n1_556858_60032 n1_579050_60032 3.96286
R11-117-125 n1_579050_60032 n1_601546_60032 4.0171399999999995
R11-117-126 n1_601546_60032 n1_623064_60032 3.8425
R11-117-127 n1_623064_60032 n1_625064_60032 0.333333
R11-118-100 n1_623064_60032 n1_625064_60032 0.357143
R11-118-101 n1_625064_60032 n1_627064_60032 0.333333
R11-119-100 n1_625064_60032 n1_627064_60032 0.357143
R11-120-100 n1_44000_63376 n1_46000_63376 0.357143
R11-121-100 n1_44000_63376 n1_46000_63376 0.333333
R11-121-101 n1_46000_63376 n1_48000_63376 0.357143
R11-122-100 n1_46000_63376 n1_48000_63376 0.333333
R11-122-101 n1_48000_63376 n1_65594_63376 3.14179
R11-122-102 n1_65594_63376 n1_88090_63376 4.0171399999999995
R11-122-103 n1_88090_63376 n1_110282_63376 3.96286
R11-122-104 n1_110282_63376 n1_132778_63376 4.0171399999999995
R11-122-105 n1_132778_63376 n1_154970_63376 3.96286
R11-122-106 n1_154970_63376 n1_177466_63376 4.0171399999999995
R11-122-107 n1_177466_63376 n1_199658_63376 3.96286
R11-122-108 n1_199658_63376 n1_221850_63376 3.96286
R11-122-109 n1_221850_63376 n1_244346_63376 4.0171399999999995
R11-122-110 n1_244346_63376 n1_266538_63376 3.96286
R11-122-111 n1_266538_63376 n1_289034_63376 4.0171399999999995
R11-122-112 n1_289034_63376 n1_311226_63376 3.96286
R11-122-113 n1_311226_63376 n1_333722_63376 4.0171399999999995
R11-122-114 n1_333722_63376 n1_355914_63376 3.96286
R11-122-115 n1_355914_63376 n1_378410_63376 4.0171399999999995
R11-122-116 n1_378410_63376 n1_400602_63376 3.96286
R11-122-117 n1_400602_63376 n1_422794_63376 3.96286
R11-122-118 n1_422794_63376 n1_445290_63376 4.0171399999999995
R11-122-119 n1_445290_63376 n1_467482_63376 3.96286
R11-122-120 n1_467482_63376 n1_489978_63376 4.0171399999999995
R11-122-121 n1_489978_63376 n1_512170_63376 3.96286
R11-122-122 n1_512170_63376 n1_534666_63376 4.0171399999999995
R11-122-123 n1_534666_63376 n1_556858_63376 3.96286
R11-122-124 n1_556858_63376 n1_579050_63376 3.96286
R11-122-125 n1_579050_63376 n1_601546_63376 4.0171399999999995
R11-122-126 n1_601546_63376 n1_623064_63376 3.8425
R11-122-127 n1_623064_63376 n1_625064_63376 0.357143
R11-123-100 n1_623064_63376 n1_625064_63376 0.333333
R11-123-101 n1_625064_63376 n1_627064_63376 0.333333
R11-124-100 n1_625064_63376 n1_627064_63376 0.357143
R11-125-100 n1_44000_66720 n1_46000_66720 0.333333
R11-126-100 n1_44000_66720 n1_46000_66720 0.357143
R11-126-101 n1_46000_66720 n1_48000_66720 0.357143
R11-127-100 n1_46000_66720 n1_48000_66720 0.333333
R11-127-101 n1_48000_66720 n1_65594_66720 3.14179
R11-127-102 n1_65594_66720 n1_88090_66720 4.0171399999999995
R11-127-103 n1_88090_66720 n1_110282_66720 3.96286
R11-127-104 n1_110282_66720 n1_132778_66720 4.0171399999999995
R11-127-105 n1_132778_66720 n1_154970_66720 3.96286
R11-127-106 n1_154970_66720 n1_177466_66720 4.0171399999999995
R11-127-107 n1_177466_66720 n1_199658_66720 3.96286
R11-127-108 n1_199658_66720 n1_221850_66720 3.96286
R11-127-109 n1_221850_66720 n1_244346_66720 4.0171399999999995
R11-127-110 n1_244346_66720 n1_266538_66720 3.96286
R11-127-111 n1_266538_66720 n1_289034_66720 4.0171399999999995
R11-127-112 n1_289034_66720 n1_311226_66720 3.96286
R11-127-113 n1_311226_66720 n1_333722_66720 4.0171399999999995
R11-127-114 n1_333722_66720 n1_355914_66720 3.96286
R11-127-115 n1_355914_66720 n1_378410_66720 4.0171399999999995
R11-127-116 n1_378410_66720 n1_400602_66720 3.96286
R11-127-117 n1_400602_66720 n1_422794_66720 3.96286
R11-127-118 n1_422794_66720 n1_445290_66720 4.0171399999999995
R11-127-119 n1_445290_66720 n1_467482_66720 3.96286
R11-127-120 n1_467482_66720 n1_489978_66720 4.0171399999999995
R11-127-121 n1_489978_66720 n1_512170_66720 3.96286
R11-127-122 n1_512170_66720 n1_534666_66720 4.0171399999999995
R11-127-123 n1_534666_66720 n1_556858_66720 3.96286
R11-127-124 n1_556858_66720 n1_579050_66720 3.96286
R11-127-125 n1_579050_66720 n1_601546_66720 4.0171399999999995
R11-127-126 n1_601546_66720 n1_623064_66720 3.8425
R11-127-127 n1_623064_66720 n1_625064_66720 0.333333
R11-128-100 n1_623064_66720 n1_625064_66720 0.357143
R11-128-101 n1_625064_66720 n1_627064_66720 0.333333
R11-129-100 n1_625064_66720 n1_627064_66720 0.357143
R11-130-100 n1_44000_70064 n1_46000_70064 0.357143
R11-131-100 n1_44000_70064 n1_46000_70064 0.333333
R11-131-101 n1_46000_70064 n1_48000_70064 0.333333
R11-132-100 n1_46000_70064 n1_48000_70064 0.357143
R11-132-101 n1_48000_70064 n1_65594_70064 3.14179
R11-132-102 n1_65594_70064 n1_88090_70064 4.0171399999999995
R11-132-103 n1_88090_70064 n1_110282_70064 3.96286
R11-132-104 n1_110282_70064 n1_132778_70064 4.0171399999999995
R11-132-105 n1_132778_70064 n1_154970_70064 3.96286
R11-132-106 n1_154970_70064 n1_177466_70064 4.0171399999999995
R11-132-107 n1_177466_70064 n1_199658_70064 3.96286
R11-132-108 n1_199658_70064 n1_221850_70064 3.96286
R11-132-109 n1_221850_70064 n1_244346_70064 4.0171399999999995
R11-132-110 n1_244346_70064 n1_266538_70064 3.96286
R11-132-111 n1_266538_70064 n1_289034_70064 4.0171399999999995
R11-132-112 n1_289034_70064 n1_311226_70064 3.96286
R11-132-113 n1_311226_70064 n1_333722_70064 4.0171399999999995
R11-132-114 n1_333722_70064 n1_355914_70064 3.96286
R11-132-115 n1_355914_70064 n1_378410_70064 4.0171399999999995
R11-132-116 n1_378410_70064 n1_400602_70064 3.96286
R11-132-117 n1_400602_70064 n1_422794_70064 3.96286
R11-132-118 n1_422794_70064 n1_445290_70064 4.0171399999999995
R11-132-119 n1_445290_70064 n1_467482_70064 3.96286
R11-132-120 n1_467482_70064 n1_489978_70064 4.0171399999999995
R11-132-121 n1_489978_70064 n1_512170_70064 3.96286
R11-132-122 n1_512170_70064 n1_534666_70064 4.0171399999999995
R11-132-123 n1_534666_70064 n1_556858_70064 3.96286
R11-132-124 n1_556858_70064 n1_579050_70064 3.96286
R11-132-125 n1_579050_70064 n1_601546_70064 4.0171399999999995
R11-132-126 n1_601546_70064 n1_623064_70064 3.8425
R11-132-127 n1_623064_70064 n1_625064_70064 0.333333
R11-133-100 n1_623064_70064 n1_625064_70064 0.357143
R11-133-101 n1_625064_70064 n1_627064_70064 0.333333
R11-134-100 n1_625064_70064 n1_627064_70064 0.357143
R11-135-100 n1_44000_73408 n1_46000_73408 0.333333
R11-136-100 n1_44000_73408 n1_46000_73408 0.357143
R11-136-101 n1_46000_73408 n1_48000_73408 0.333333
R11-137-100 n1_46000_73408 n1_48000_73408 0.357143
R11-137-101 n1_48000_73408 n1_65594_73408 3.14179
R11-137-102 n1_65594_73408 n1_88090_73408 4.0171399999999995
R11-137-103 n1_88090_73408 n1_110282_73408 3.96286
R11-137-104 n1_110282_73408 n1_132778_73408 4.0171399999999995
R11-137-105 n1_132778_73408 n1_154970_73408 3.96286
R11-137-106 n1_154970_73408 n1_177466_73408 4.0171399999999995
R11-137-107 n1_177466_73408 n1_199658_73408 3.96286
R11-137-108 n1_199658_73408 n1_221850_73408 3.96286
R11-137-109 n1_221850_73408 n1_244346_73408 4.0171399999999995
R11-137-110 n1_244346_73408 n1_266538_73408 3.96286
R11-137-111 n1_266538_73408 n1_289034_73408 4.0171399999999995
R11-137-112 n1_289034_73408 n1_311226_73408 3.96286
R11-137-113 n1_311226_73408 n1_333722_73408 4.0171399999999995
R11-137-114 n1_333722_73408 n1_355914_73408 3.96286
R11-137-115 n1_355914_73408 n1_378410_73408 4.0171399999999995
R11-137-116 n1_378410_73408 n1_400602_73408 3.96286
R11-137-117 n1_400602_73408 n1_422794_73408 3.96286
R11-137-118 n1_422794_73408 n1_445290_73408 4.0171399999999995
R11-137-119 n1_445290_73408 n1_467482_73408 3.96286
R11-137-120 n1_467482_73408 n1_489978_73408 4.0171399999999995
R11-137-121 n1_489978_73408 n1_512170_73408 3.96286
R11-137-122 n1_512170_73408 n1_534666_73408 4.0171399999999995
R11-137-123 n1_534666_73408 n1_556858_73408 3.96286
R11-137-124 n1_556858_73408 n1_579050_73408 3.96286
R11-137-125 n1_579050_73408 n1_601546_73408 4.0171399999999995
R11-137-126 n1_601546_73408 n1_623064_73408 3.8425
R11-137-127 n1_623064_73408 n1_625064_73408 0.333333
R11-138-100 n1_623064_73408 n1_625064_73408 0.357143
R11-138-101 n1_625064_73408 n1_627064_73408 0.333333
R11-139-100 n1_625064_73408 n1_627064_73408 0.357143
R11-140-100 n1_44000_76752 n1_46000_76752 0.357143
R11-141-100 n1_44000_76752 n1_46000_76752 0.333333
R11-141-101 n1_46000_76752 n1_48000_76752 0.357143
R11-142-100 n1_46000_76752 n1_48000_76752 0.333333
R11-142-101 n1_48000_76752 n1_65594_76752 3.14179
R11-142-102 n1_65594_76752 n1_88090_76752 4.0171399999999995
R11-142-103 n1_88090_76752 n1_110282_76752 3.96286
R11-142-104 n1_110282_76752 n1_132778_76752 4.0171399999999995
R11-142-105 n1_132778_76752 n1_154970_76752 3.96286
R11-142-106 n1_154970_76752 n1_177466_76752 4.0171399999999995
R11-142-107 n1_177466_76752 n1_199658_76752 3.96286
R11-142-108 n1_199658_76752 n1_221850_76752 3.96286
R11-142-109 n1_221850_76752 n1_244346_76752 4.0171399999999995
R11-142-110 n1_244346_76752 n1_266538_76752 3.96286
R11-142-111 n1_266538_76752 n1_289034_76752 4.0171399999999995
R11-142-112 n1_289034_76752 n1_311226_76752 3.96286
R11-142-113 n1_311226_76752 n1_333722_76752 4.0171399999999995
R11-142-114 n1_333722_76752 n1_355914_76752 3.96286
R11-142-115 n1_355914_76752 n1_378410_76752 4.0171399999999995
R11-142-116 n1_378410_76752 n1_400602_76752 3.96286
R11-142-117 n1_400602_76752 n1_422794_76752 3.96286
R11-142-118 n1_422794_76752 n1_445290_76752 4.0171399999999995
R11-142-119 n1_445290_76752 n1_467482_76752 3.96286
R11-142-120 n1_467482_76752 n1_489978_76752 4.0171399999999995
R11-142-121 n1_489978_76752 n1_512170_76752 3.96286
R11-142-122 n1_512170_76752 n1_534666_76752 4.0171399999999995
R11-142-123 n1_534666_76752 n1_556858_76752 3.96286
R11-142-124 n1_556858_76752 n1_579050_76752 3.96286
R11-142-125 n1_579050_76752 n1_601546_76752 4.0171399999999995
R11-142-126 n1_601546_76752 n1_623064_76752 3.8425
R11-142-127 n1_623064_76752 n1_625064_76752 0.357143
R11-143-100 n1_623064_76752 n1_625064_76752 0.333333
R11-143-101 n1_625064_76752 n1_627064_76752 0.357143
R11-144-100 n1_625064_76752 n1_627064_76752 0.333333
R11-145-100 n1_44000_80096 n1_46000_80096 0.333333
R11-146-100 n1_44000_80096 n1_46000_80096 0.357143
R11-146-101 n1_46000_80096 n1_48000_80096 0.357143
R11-147-100 n1_46000_80096 n1_48000_80096 0.333333
R11-147-101 n1_48000_80096 n1_65594_80096 3.14179
R11-147-102 n1_65594_80096 n1_88090_80096 4.0171399999999995
R11-147-103 n1_88090_80096 n1_110282_80096 3.96286
R11-147-104 n1_110282_80096 n1_132778_80096 4.0171399999999995
R11-147-105 n1_132778_80096 n1_154970_80096 3.96286
R11-147-106 n1_154970_80096 n1_177466_80096 4.0171399999999995
R11-147-107 n1_177466_80096 n1_199658_80096 3.96286
R11-147-108 n1_199658_80096 n1_221850_80096 3.96286
R11-147-109 n1_221850_80096 n1_244346_80096 4.0171399999999995
R11-147-110 n1_244346_80096 n1_266538_80096 3.96286
R11-147-111 n1_266538_80096 n1_289034_80096 4.0171399999999995
R11-147-112 n1_289034_80096 n1_311226_80096 3.96286
R11-147-113 n1_311226_80096 n1_333722_80096 4.0171399999999995
R11-147-114 n1_333722_80096 n1_355914_80096 3.96286
R11-147-115 n1_355914_80096 n1_378410_80096 4.0171399999999995
R11-147-116 n1_378410_80096 n1_400602_80096 3.96286
R11-147-117 n1_400602_80096 n1_422794_80096 3.96286
R11-147-118 n1_422794_80096 n1_445290_80096 4.0171399999999995
R11-147-119 n1_445290_80096 n1_467482_80096 3.96286
R11-147-120 n1_467482_80096 n1_489978_80096 4.0171399999999995
R11-147-121 n1_489978_80096 n1_512170_80096 3.96286
R11-147-122 n1_512170_80096 n1_534666_80096 4.0171399999999995
R11-147-123 n1_534666_80096 n1_556858_80096 3.96286
R11-147-124 n1_556858_80096 n1_579050_80096 3.96286
R11-147-125 n1_579050_80096 n1_601546_80096 4.0171399999999995
R11-147-126 n1_601546_80096 n1_623064_80096 3.8425
R11-147-127 n1_623064_80096 n1_625064_80096 0.333333
R11-148-100 n1_623064_80096 n1_625064_80096 0.357143
R11-148-101 n1_625064_80096 n1_627064_80096 0.357143
R11-149-100 n1_625064_80096 n1_627064_80096 0.333333
R11-150-100 n1_44000_83440 n1_46000_83440 0.333333
R11-151-100 n1_44000_83440 n1_46000_83440 0.357143
R11-151-101 n1_46000_83440 n1_48000_83440 0.333333
R11-152-100 n1_46000_83440 n1_48000_83440 0.357143
R11-152-101 n1_48000_83440 n1_65594_83440 3.14179
R11-152-102 n1_65594_83440 n1_88090_83440 4.0171399999999995
R11-152-103 n1_88090_83440 n1_110282_83440 3.96286
R11-152-104 n1_110282_83440 n1_132778_83440 4.0171399999999995
R11-152-105 n1_132778_83440 n1_154970_83440 3.96286
R11-152-106 n1_154970_83440 n1_177466_83440 4.0171399999999995
R11-152-107 n1_177466_83440 n1_199658_83440 3.96286
R11-152-108 n1_199658_83440 n1_221850_83440 3.96286
R11-152-109 n1_221850_83440 n1_244346_83440 4.0171399999999995
R11-152-110 n1_244346_83440 n1_266538_83440 3.96286
R11-152-111 n1_266538_83440 n1_289034_83440 4.0171399999999995
R11-152-112 n1_289034_83440 n1_311226_83440 3.96286
R11-152-113 n1_311226_83440 n1_333722_83440 4.0171399999999995
R11-152-114 n1_333722_83440 n1_355914_83440 3.96286
R11-152-115 n1_355914_83440 n1_378410_83440 4.0171399999999995
R11-152-116 n1_378410_83440 n1_400602_83440 3.96286
R11-152-117 n1_400602_83440 n1_422794_83440 3.96286
R11-152-118 n1_422794_83440 n1_445290_83440 4.0171399999999995
R11-152-119 n1_445290_83440 n1_467482_83440 3.96286
R11-152-120 n1_467482_83440 n1_489978_83440 4.0171399999999995
R11-152-121 n1_489978_83440 n1_512170_83440 3.96286
R11-152-122 n1_512170_83440 n1_534666_83440 4.0171399999999995
R11-152-123 n1_534666_83440 n1_556858_83440 3.96286
R11-152-124 n1_556858_83440 n1_579050_83440 3.96286
R11-152-125 n1_579050_83440 n1_601546_83440 4.0171399999999995
R11-152-126 n1_601546_83440 n1_623064_83440 3.8425
R11-152-127 n1_623064_83440 n1_625064_83440 0.357143
R11-153-100 n1_623064_83440 n1_625064_83440 0.333333
R11-153-101 n1_625064_83440 n1_627064_83440 0.333333
R11-154-100 n1_625064_83440 n1_627064_83440 0.357143
R11-155-100 n1_44000_86784 n1_46000_86784 0.333333
R11-156-100 n1_44000_86784 n1_46000_86784 0.357143
R11-156-101 n1_46000_86784 n1_48000_86784 0.357143
R11-157-100 n1_46000_86784 n1_48000_86784 0.333333
R11-157-101 n1_48000_86784 n1_65594_86784 3.14179
R11-157-102 n1_65594_86784 n1_88090_86784 4.0171399999999995
R11-157-103 n1_88090_86784 n1_110282_86784 3.96286
R11-157-104 n1_110282_86784 n1_132778_86784 4.0171399999999995
R11-157-105 n1_132778_86784 n1_154970_86784 3.96286
R11-157-106 n1_154970_86784 n1_177466_86784 4.0171399999999995
R11-157-107 n1_177466_86784 n1_199658_86784 3.96286
R11-157-108 n1_199658_86784 n1_221850_86784 3.96286
R11-157-109 n1_221850_86784 n1_244346_86784 4.0171399999999995
R11-157-110 n1_244346_86784 n1_266538_86784 3.96286
R11-157-111 n1_266538_86784 n1_289034_86784 4.0171399999999995
R11-157-112 n1_289034_86784 n1_311226_86784 3.96286
R11-157-113 n1_311226_86784 n1_333722_86784 4.0171399999999995
R11-157-114 n1_333722_86784 n1_355914_86784 3.96286
R11-157-115 n1_355914_86784 n1_378410_86784 4.0171399999999995
R11-157-116 n1_378410_86784 n1_400602_86784 3.96286
R11-157-117 n1_400602_86784 n1_422794_86784 3.96286
R11-157-118 n1_422794_86784 n1_445290_86784 4.0171399999999995
R11-157-119 n1_445290_86784 n1_467482_86784 3.96286
R11-157-120 n1_467482_86784 n1_489978_86784 4.0171399999999995
R11-157-121 n1_489978_86784 n1_512170_86784 3.96286
R11-157-122 n1_512170_86784 n1_534666_86784 4.0171399999999995
R11-157-123 n1_534666_86784 n1_556858_86784 3.96286
R11-157-124 n1_556858_86784 n1_579050_86784 3.96286
R11-157-125 n1_579050_86784 n1_601546_86784 4.0171399999999995
R11-157-126 n1_601546_86784 n1_623064_86784 3.8425
R11-157-127 n1_623064_86784 n1_625064_86784 0.333333
R11-158-100 n1_623064_86784 n1_625064_86784 0.357143
R11-158-101 n1_625064_86784 n1_627064_86784 0.357143
R11-159-100 n1_625064_86784 n1_627064_86784 0.333333
R11-160-100 n1_44000_90128 n1_46000_90128 0.357143
R11-161-100 n1_44000_90128 n1_46000_90128 0.333333
R11-161-101 n1_46000_90128 n1_48000_90128 0.357143
R11-162-100 n1_46000_90128 n1_48000_90128 0.333333
R11-162-101 n1_48000_90128 n1_65594_90128 3.14179
R11-162-102 n1_65594_90128 n1_88090_90128 4.0171399999999995
R11-162-103 n1_88090_90128 n1_110282_90128 3.96286
R11-162-104 n1_110282_90128 n1_132778_90128 4.0171399999999995
R11-162-105 n1_132778_90128 n1_154970_90128 3.96286
R11-162-106 n1_154970_90128 n1_177466_90128 4.0171399999999995
R11-162-107 n1_177466_90128 n1_199658_90128 3.96286
R11-162-108 n1_199658_90128 n1_221850_90128 3.96286
R11-162-109 n1_221850_90128 n1_244346_90128 4.0171399999999995
R11-162-110 n1_244346_90128 n1_266538_90128 3.96286
R11-162-111 n1_266538_90128 n1_289034_90128 4.0171399999999995
R11-162-112 n1_289034_90128 n1_311226_90128 3.96286
R11-162-113 n1_311226_90128 n1_333722_90128 4.0171399999999995
R11-162-114 n1_333722_90128 n1_355914_90128 3.96286
R11-162-115 n1_355914_90128 n1_378410_90128 4.0171399999999995
R11-162-116 n1_378410_90128 n1_400602_90128 3.96286
R11-162-117 n1_400602_90128 n1_422794_90128 3.96286
R11-162-118 n1_422794_90128 n1_445290_90128 4.0171399999999995
R11-162-119 n1_445290_90128 n1_467482_90128 3.96286
R11-162-120 n1_467482_90128 n1_489978_90128 4.0171399999999995
R11-162-121 n1_489978_90128 n1_512170_90128 3.96286
R11-162-122 n1_512170_90128 n1_534666_90128 4.0171399999999995
R11-162-123 n1_534666_90128 n1_556858_90128 3.96286
R11-162-124 n1_556858_90128 n1_579050_90128 3.96286
R11-162-125 n1_579050_90128 n1_601546_90128 4.0171399999999995
R11-162-126 n1_601546_90128 n1_623064_90128 3.8425
R11-162-127 n1_623064_90128 n1_625064_90128 0.357143
R11-163-100 n1_623064_90128 n1_625064_90128 0.333333
R11-163-101 n1_625064_90128 n1_627064_90128 0.333333
R11-164-100 n1_625064_90128 n1_627064_90128 0.357143
R11-165-100 n1_44000_93472 n1_46000_93472 0.333333
R11-166-100 n1_44000_93472 n1_46000_93472 0.357143
R11-166-101 n1_46000_93472 n1_48000_93472 0.333333
R11-167-100 n1_46000_93472 n1_48000_93472 0.357143
R11-167-101 n1_48000_93472 n1_65594_93472 3.14179
R11-167-102 n1_65594_93472 n1_88090_93472 4.0171399999999995
R11-167-103 n1_88090_93472 n1_110282_93472 3.96286
R11-167-104 n1_110282_93472 n1_132778_93472 4.0171399999999995
R11-167-105 n1_132778_93472 n1_154970_93472 3.96286
R11-167-106 n1_154970_93472 n1_177466_93472 4.0171399999999995
R11-167-107 n1_177466_93472 n1_199658_93472 3.96286
R11-167-108 n1_199658_93472 n1_221850_93472 3.96286
R11-167-109 n1_221850_93472 n1_244346_93472 4.0171399999999995
R11-167-110 n1_244346_93472 n1_266538_93472 3.96286
R11-167-111 n1_266538_93472 n1_289034_93472 4.0171399999999995
R11-167-112 n1_289034_93472 n1_311226_93472 3.96286
R11-167-113 n1_311226_93472 n1_333722_93472 4.0171399999999995
R11-167-114 n1_333722_93472 n1_355914_93472 3.96286
R11-167-115 n1_355914_93472 n1_378410_93472 4.0171399999999995
R11-167-116 n1_378410_93472 n1_400602_93472 3.96286
R11-167-117 n1_400602_93472 n1_422794_93472 3.96286
R11-167-118 n1_422794_93472 n1_445290_93472 4.0171399999999995
R11-167-119 n1_445290_93472 n1_467482_93472 3.96286
R11-167-120 n1_467482_93472 n1_489978_93472 4.0171399999999995
R11-167-121 n1_489978_93472 n1_512170_93472 3.96286
R11-167-122 n1_512170_93472 n1_534666_93472 4.0171399999999995
R11-167-123 n1_534666_93472 n1_556858_93472 3.96286
R11-167-124 n1_556858_93472 n1_579050_93472 3.96286
R11-167-125 n1_579050_93472 n1_601546_93472 4.0171399999999995
R11-167-126 n1_601546_93472 n1_623064_93472 3.8425
R11-167-127 n1_623064_93472 n1_625064_93472 0.333333
R11-168-100 n1_623064_93472 n1_625064_93472 0.357143
R11-168-101 n1_625064_93472 n1_627064_93472 0.333333
R11-169-100 n1_625064_93472 n1_627064_93472 0.357143
R11-170-100 n1_44000_96816 n1_46000_96816 0.333333
R11-171-100 n1_44000_96816 n1_46000_96816 0.357143
R11-171-101 n1_46000_96816 n1_48000_96816 0.333333
R11-172-100 n1_46000_96816 n1_48000_96816 0.357143
R11-172-101 n1_48000_96816 n1_65594_96816 3.14179
R11-172-102 n1_65594_96816 n1_88090_96816 4.0171399999999995
R11-172-103 n1_88090_96816 n1_110282_96816 3.96286
R11-172-104 n1_110282_96816 n1_132778_96816 4.0171399999999995
R11-172-105 n1_132778_96816 n1_154970_96816 3.96286
R11-172-106 n1_154970_96816 n1_177466_96816 4.0171399999999995
R11-172-107 n1_177466_96816 n1_199658_96816 3.96286
R11-172-108 n1_199658_96816 n1_221850_96816 3.96286
R11-172-109 n1_221850_96816 n1_244346_96816 4.0171399999999995
R11-172-110 n1_244346_96816 n1_266538_96816 3.96286
R11-172-111 n1_266538_96816 n1_289034_96816 4.0171399999999995
R11-172-112 n1_289034_96816 n1_311226_96816 3.96286
R11-172-113 n1_311226_96816 n1_333722_96816 4.0171399999999995
R11-172-114 n1_333722_96816 n1_355914_96816 3.96286
R11-172-115 n1_355914_96816 n1_378410_96816 4.0171399999999995
R11-172-116 n1_378410_96816 n1_400602_96816 3.96286
R11-172-117 n1_400602_96816 n1_422794_96816 3.96286
R11-172-118 n1_422794_96816 n1_445290_96816 4.0171399999999995
R11-172-119 n1_445290_96816 n1_467482_96816 3.96286
R11-172-120 n1_467482_96816 n1_489978_96816 4.0171399999999995
R11-172-121 n1_489978_96816 n1_512170_96816 3.96286
R11-172-122 n1_512170_96816 n1_534666_96816 4.0171399999999995
R11-172-123 n1_534666_96816 n1_556858_96816 3.96286
R11-172-124 n1_556858_96816 n1_579050_96816 3.96286
R11-172-125 n1_579050_96816 n1_601546_96816 4.0171399999999995
R11-172-126 n1_601546_96816 n1_623064_96816 3.8425
R11-172-127 n1_623064_96816 n1_625064_96816 0.357143
R11-173-100 n1_623064_96816 n1_625064_96816 0.333333
R11-173-101 n1_625064_96816 n1_627064_96816 0.333333
R11-174-100 n1_625064_96816 n1_627064_96816 0.357143
R11-175-100 n1_44000_100160 n1_46000_100160 0.333333
R11-176-100 n1_44000_100160 n1_46000_100160 0.357143
R11-176-101 n1_46000_100160 n1_48000_100160 0.333333
R11-177-100 n1_46000_100160 n1_48000_100160 0.357143
R11-177-101 n1_48000_100160 n1_65594_100160 3.14179
R11-177-102 n1_65594_100160 n1_88090_100160 4.0171399999999995
R11-177-103 n1_88090_100160 n1_110282_100160 3.96286
R11-177-104 n1_110282_100160 n1_132778_100160 4.0171399999999995
R11-177-105 n1_132778_100160 n1_154970_100160 3.96286
R11-177-106 n1_154970_100160 n1_177466_100160 4.0171399999999995
R11-177-107 n1_177466_100160 n1_199658_100160 3.96286
R11-177-108 n1_199658_100160 n1_221850_100160 3.96286
R11-177-109 n1_221850_100160 n1_244346_100160 4.0171399999999995
R11-177-110 n1_244346_100160 n1_266538_100160 3.96286
R11-177-111 n1_266538_100160 n1_289034_100160 4.0171399999999995
R11-177-112 n1_289034_100160 n1_311226_100160 3.96286
R11-177-113 n1_311226_100160 n1_333722_100160 4.0171399999999995
R11-177-114 n1_333722_100160 n1_355914_100160 3.96286
R11-177-115 n1_355914_100160 n1_378410_100160 4.0171399999999995
R11-177-116 n1_378410_100160 n1_400602_100160 3.96286
R11-177-117 n1_400602_100160 n1_422794_100160 3.96286
R11-177-118 n1_422794_100160 n1_445290_100160 4.0171399999999995
R11-177-119 n1_445290_100160 n1_467482_100160 3.96286
R11-177-120 n1_467482_100160 n1_489978_100160 4.0171399999999995
R11-177-121 n1_489978_100160 n1_512170_100160 3.96286
R11-177-122 n1_512170_100160 n1_534666_100160 4.0171399999999995
R11-177-123 n1_534666_100160 n1_556858_100160 3.96286
R11-177-124 n1_556858_100160 n1_579050_100160 3.96286
R11-177-125 n1_579050_100160 n1_601546_100160 4.0171399999999995
R11-177-126 n1_601546_100160 n1_623064_100160 3.8425
R11-177-127 n1_623064_100160 n1_625064_100160 0.357143
R11-178-100 n1_623064_100160 n1_625064_100160 0.333333
R11-178-101 n1_625064_100160 n1_627064_100160 0.357143
R11-179-100 n1_625064_100160 n1_627064_100160 0.333333
R11-180-100 n1_44000_103504 n1_46000_103504 0.333333
R11-181-100 n1_44000_103504 n1_46000_103504 0.357143
R11-181-101 n1_46000_103504 n1_48000_103504 0.333333
R11-182-100 n1_46000_103504 n1_48000_103504 0.357143
R11-182-101 n1_48000_103504 n1_65594_103504 3.14179
R11-182-102 n1_65594_103504 n1_88090_103504 4.0171399999999995
R11-182-103 n1_88090_103504 n1_110282_103504 3.96286
R11-182-104 n1_110282_103504 n1_132778_103504 4.0171399999999995
R11-182-105 n1_132778_103504 n1_154970_103504 3.96286
R11-182-106 n1_154970_103504 n1_177466_103504 4.0171399999999995
R11-182-107 n1_177466_103504 n1_199658_103504 3.96286
R11-182-108 n1_199658_103504 n1_221850_103504 3.96286
R11-182-109 n1_221850_103504 n1_244346_103504 4.0171399999999995
R11-182-110 n1_244346_103504 n1_266538_103504 3.96286
R11-182-111 n1_266538_103504 n1_289034_103504 4.0171399999999995
R11-182-112 n1_289034_103504 n1_311226_103504 3.96286
R11-182-113 n1_311226_103504 n1_333722_103504 4.0171399999999995
R11-182-114 n1_333722_103504 n1_355914_103504 3.96286
R11-182-115 n1_355914_103504 n1_378410_103504 4.0171399999999995
R11-182-116 n1_378410_103504 n1_400602_103504 3.96286
R11-182-117 n1_400602_103504 n1_422794_103504 3.96286
R11-182-118 n1_422794_103504 n1_445290_103504 4.0171399999999995
R11-182-119 n1_445290_103504 n1_467482_103504 3.96286
R11-182-120 n1_467482_103504 n1_489978_103504 4.0171399999999995
R11-182-121 n1_489978_103504 n1_512170_103504 3.96286
R11-182-122 n1_512170_103504 n1_534666_103504 4.0171399999999995
R11-182-123 n1_534666_103504 n1_556858_103504 3.96286
R11-182-124 n1_556858_103504 n1_579050_103504 3.96286
R11-182-125 n1_579050_103504 n1_601546_103504 4.0171399999999995
R11-182-126 n1_601546_103504 n1_623064_103504 3.8425
R11-182-127 n1_623064_103504 n1_625064_103504 0.333333
R11-183-100 n1_623064_103504 n1_625064_103504 0.357143
R11-183-101 n1_625064_103504 n1_627064_103504 0.333333
R11-184-100 n1_625064_103504 n1_627064_103504 0.357143
R11-185-100 n1_44000_106848 n1_46000_106848 0.333333
R11-186-100 n1_44000_106848 n1_46000_106848 0.357143
R11-186-101 n1_46000_106848 n1_48000_106848 0.333333
R11-187-100 n1_46000_106848 n1_48000_106848 0.357143
R11-187-101 n1_48000_106848 n1_65594_106848 3.14179
R11-187-102 n1_65594_106848 n1_88090_106848 4.0171399999999995
R11-187-103 n1_88090_106848 n1_110282_106848 3.96286
R11-187-104 n1_110282_106848 n1_132778_106848 4.0171399999999995
R11-187-105 n1_132778_106848 n1_154970_106848 3.96286
R11-187-106 n1_154970_106848 n1_177466_106848 4.0171399999999995
R11-187-107 n1_177466_106848 n1_199658_106848 3.96286
R11-187-108 n1_199658_106848 n1_221850_106848 3.96286
R11-187-109 n1_221850_106848 n1_244346_106848 4.0171399999999995
R11-187-110 n1_244346_106848 n1_266538_106848 3.96286
R11-187-111 n1_266538_106848 n1_289034_106848 4.0171399999999995
R11-187-112 n1_289034_106848 n1_311226_106848 3.96286
R11-187-113 n1_311226_106848 n1_333722_106848 4.0171399999999995
R11-187-114 n1_333722_106848 n1_355914_106848 3.96286
R11-187-115 n1_355914_106848 n1_378410_106848 4.0171399999999995
R11-187-116 n1_378410_106848 n1_400602_106848 3.96286
R11-187-117 n1_400602_106848 n1_422794_106848 3.96286
R11-187-118 n1_422794_106848 n1_445290_106848 4.0171399999999995
R11-187-119 n1_445290_106848 n1_467482_106848 3.96286
R11-187-120 n1_467482_106848 n1_489978_106848 4.0171399999999995
R11-187-121 n1_489978_106848 n1_512170_106848 3.96286
R11-187-122 n1_512170_106848 n1_534666_106848 4.0171399999999995
R11-187-123 n1_534666_106848 n1_556858_106848 3.96286
R11-187-124 n1_556858_106848 n1_579050_106848 3.96286
R11-187-125 n1_579050_106848 n1_601546_106848 4.0171399999999995
R11-187-126 n1_601546_106848 n1_623064_106848 3.8425
R11-187-127 n1_623064_106848 n1_625064_106848 0.357143
R11-188-100 n1_623064_106848 n1_625064_106848 0.333333
R11-188-101 n1_625064_106848 n1_627064_106848 0.333333
R11-189-100 n1_625064_106848 n1_627064_106848 0.357143
R11-190-100 n1_44000_110192 n1_46000_110192 0.357143
R11-191-100 n1_44000_110192 n1_46000_110192 0.333333
R11-191-101 n1_46000_110192 n1_48000_110192 0.357143
R11-192-100 n1_46000_110192 n1_48000_110192 0.333333
R11-192-101 n1_48000_110192 n1_65594_110192 3.14179
R11-192-102 n1_65594_110192 n1_88090_110192 4.0171399999999995
R11-192-103 n1_88090_110192 n1_110282_110192 3.96286
R11-192-104 n1_110282_110192 n1_132778_110192 4.0171399999999995
R11-192-105 n1_132778_110192 n1_154970_110192 3.96286
R11-192-106 n1_154970_110192 n1_177466_110192 4.0171399999999995
R11-192-107 n1_177466_110192 n1_199658_110192 3.96286
R11-192-108 n1_199658_110192 n1_221850_110192 3.96286
R11-192-109 n1_221850_110192 n1_244346_110192 4.0171399999999995
R11-192-110 n1_244346_110192 n1_266538_110192 3.96286
R11-192-111 n1_266538_110192 n1_289034_110192 4.0171399999999995
R11-192-112 n1_289034_110192 n1_311226_110192 3.96286
R11-192-113 n1_311226_110192 n1_333722_110192 4.0171399999999995
R11-192-114 n1_333722_110192 n1_355914_110192 3.96286
R11-192-115 n1_355914_110192 n1_378410_110192 4.0171399999999995
R11-192-116 n1_378410_110192 n1_400602_110192 3.96286
R11-192-117 n1_400602_110192 n1_422794_110192 3.96286
R11-192-118 n1_422794_110192 n1_445290_110192 4.0171399999999995
R11-192-119 n1_445290_110192 n1_467482_110192 3.96286
R11-192-120 n1_467482_110192 n1_489978_110192 4.0171399999999995
R11-192-121 n1_489978_110192 n1_512170_110192 3.96286
R11-192-122 n1_512170_110192 n1_534666_110192 4.0171399999999995
R11-192-123 n1_534666_110192 n1_556858_110192 3.96286
R11-192-124 n1_556858_110192 n1_579050_110192 3.96286
R11-192-125 n1_579050_110192 n1_601546_110192 4.0171399999999995
R11-192-126 n1_601546_110192 n1_623064_110192 3.8425
R11-192-127 n1_623064_110192 n1_625064_110192 0.357143
R11-193-100 n1_623064_110192 n1_625064_110192 0.333333
R11-193-101 n1_625064_110192 n1_627064_110192 0.333333
R11-194-100 n1_625064_110192 n1_627064_110192 0.357143
R11-195-100 n1_44000_113536 n1_46000_113536 0.333333
R11-196-100 n1_44000_113536 n1_46000_113536 0.357143
R11-196-101 n1_46000_113536 n1_48000_113536 0.357143
R11-197-100 n1_46000_113536 n1_48000_113536 0.333333
R11-197-101 n1_48000_113536 n1_65594_113536 3.14179
R11-197-102 n1_65594_113536 n1_88090_113536 4.0171399999999995
R11-197-103 n1_88090_113536 n1_110282_113536 3.96286
R11-197-104 n1_110282_113536 n1_132778_113536 4.0171399999999995
R11-197-105 n1_132778_113536 n1_154970_113536 3.96286
R11-197-106 n1_154970_113536 n1_177466_113536 4.0171399999999995
R11-197-107 n1_177466_113536 n1_199658_113536 3.96286
R11-197-108 n1_199658_113536 n1_221850_113536 3.96286
R11-197-109 n1_221850_113536 n1_244346_113536 4.0171399999999995
R11-197-110 n1_244346_113536 n1_266538_113536 3.96286
R11-197-111 n1_266538_113536 n1_289034_113536 4.0171399999999995
R11-197-112 n1_289034_113536 n1_311226_113536 3.96286
R11-197-113 n1_311226_113536 n1_333722_113536 4.0171399999999995
R11-197-114 n1_333722_113536 n1_355914_113536 3.96286
R11-197-115 n1_355914_113536 n1_378410_113536 4.0171399999999995
R11-197-116 n1_378410_113536 n1_400602_113536 3.96286
R11-197-117 n1_400602_113536 n1_422794_113536 3.96286
R11-197-118 n1_422794_113536 n1_445290_113536 4.0171399999999995
R11-197-119 n1_445290_113536 n1_467482_113536 3.96286
R11-197-120 n1_467482_113536 n1_489978_113536 4.0171399999999995
R11-197-121 n1_489978_113536 n1_512170_113536 3.96286
R11-197-122 n1_512170_113536 n1_534666_113536 4.0171399999999995
R11-197-123 n1_534666_113536 n1_556858_113536 3.96286
R11-197-124 n1_556858_113536 n1_579050_113536 3.96286
R11-197-125 n1_579050_113536 n1_601546_113536 4.0171399999999995
R11-197-126 n1_601546_113536 n1_623064_113536 3.8425
R11-197-127 n1_623064_113536 n1_625064_113536 0.357143
R11-198-100 n1_623064_113536 n1_625064_113536 0.333333
R11-198-101 n1_625064_113536 n1_627064_113536 0.357143
R11-199-100 n1_625064_113536 n1_627064_113536 0.333333
R11-200-100 n1_44000_116880 n1_46000_116880 0.357143
R11-201-100 n1_44000_116880 n1_46000_116880 0.333333
R11-201-101 n1_46000_116880 n1_48000_116880 0.333333
R11-202-100 n1_46000_116880 n1_48000_116880 0.357143
R11-202-101 n1_48000_116880 n1_65594_116880 3.14179
R11-202-102 n1_65594_116880 n1_88090_116880 4.0171399999999995
R11-202-103 n1_88090_116880 n1_110282_116880 3.96286
R11-202-104 n1_110282_116880 n1_132778_116880 4.0171399999999995
R11-202-105 n1_132778_116880 n1_154970_116880 3.96286
R11-202-106 n1_154970_116880 n1_177466_116880 4.0171399999999995
R11-202-107 n1_177466_116880 n1_199658_116880 3.96286
R11-202-108 n1_199658_116880 n1_221850_116880 3.96286
R11-202-109 n1_221850_116880 n1_244346_116880 4.0171399999999995
R11-202-110 n1_244346_116880 n1_266538_116880 3.96286
R11-202-111 n1_266538_116880 n1_289034_116880 4.0171399999999995
R11-202-112 n1_289034_116880 n1_311226_116880 3.96286
R11-202-113 n1_311226_116880 n1_333722_116880 4.0171399999999995
R11-202-114 n1_333722_116880 n1_355914_116880 3.96286
R11-202-115 n1_355914_116880 n1_378410_116880 4.0171399999999995
R11-202-116 n1_378410_116880 n1_400602_116880 3.96286
R11-202-117 n1_400602_116880 n1_422794_116880 3.96286
R11-202-118 n1_422794_116880 n1_445290_116880 4.0171399999999995
R11-202-119 n1_445290_116880 n1_467482_116880 3.96286
R11-202-120 n1_467482_116880 n1_489978_116880 4.0171399999999995
R11-202-121 n1_489978_116880 n1_512170_116880 3.96286
R11-202-122 n1_512170_116880 n1_534666_116880 4.0171399999999995
R11-202-123 n1_534666_116880 n1_556858_116880 3.96286
R11-202-124 n1_556858_116880 n1_579050_116880 3.96286
R11-202-125 n1_579050_116880 n1_601546_116880 4.0171399999999995
R11-202-126 n1_601546_116880 n1_623064_116880 3.8425
R11-202-127 n1_623064_116880 n1_625064_116880 0.357143
R11-203-100 n1_623064_116880 n1_625064_116880 0.333333
R11-203-101 n1_625064_116880 n1_627064_116880 0.357143
R11-204-100 n1_625064_116880 n1_627064_116880 0.333333
R11-205-100 n1_44000_120224 n1_46000_120224 0.333333
R11-206-100 n1_44000_120224 n1_46000_120224 0.357143
R11-206-101 n1_46000_120224 n1_48000_120224 0.333333
R11-207-100 n1_46000_120224 n1_48000_120224 0.357143
R11-207-101 n1_48000_120224 n1_65594_120224 3.14179
R11-207-102 n1_65594_120224 n1_88090_120224 4.0171399999999995
R11-207-103 n1_88090_120224 n1_110282_120224 3.96286
R11-207-104 n1_110282_120224 n1_132778_120224 4.0171399999999995
R11-207-105 n1_132778_120224 n1_154970_120224 3.96286
R11-207-106 n1_154970_120224 n1_177466_120224 4.0171399999999995
R11-207-107 n1_177466_120224 n1_199658_120224 3.96286
R11-207-108 n1_199658_120224 n1_221850_120224 3.96286
R11-207-109 n1_221850_120224 n1_244346_120224 4.0171399999999995
R11-207-110 n1_244346_120224 n1_266538_120224 3.96286
R11-207-111 n1_266538_120224 n1_289034_120224 4.0171399999999995
R11-207-112 n1_289034_120224 n1_311226_120224 3.96286
R11-207-113 n1_311226_120224 n1_333722_120224 4.0171399999999995
R11-207-114 n1_333722_120224 n1_355914_120224 3.96286
R11-207-115 n1_355914_120224 n1_378410_120224 4.0171399999999995
R11-207-116 n1_378410_120224 n1_400602_120224 3.96286
R11-207-117 n1_400602_120224 n1_422794_120224 3.96286
R11-207-118 n1_422794_120224 n1_445290_120224 4.0171399999999995
R11-207-119 n1_445290_120224 n1_467482_120224 3.96286
R11-207-120 n1_467482_120224 n1_489978_120224 4.0171399999999995
R11-207-121 n1_489978_120224 n1_512170_120224 3.96286
R11-207-122 n1_512170_120224 n1_534666_120224 4.0171399999999995
R11-207-123 n1_534666_120224 n1_556858_120224 3.96286
R11-207-124 n1_556858_120224 n1_579050_120224 3.96286
R11-207-125 n1_579050_120224 n1_601546_120224 4.0171399999999995
R11-207-126 n1_601546_120224 n1_623064_120224 3.8425
R11-207-127 n1_623064_120224 n1_625064_120224 0.357143
R11-208-100 n1_623064_120224 n1_625064_120224 0.333333
R11-208-101 n1_625064_120224 n1_627064_120224 0.357143
R11-209-100 n1_625064_120224 n1_627064_120224 0.333333
R11-210-100 n1_44000_123568 n1_46000_123568 0.333333
R11-211-100 n1_44000_123568 n1_46000_123568 0.357143
R11-211-101 n1_46000_123568 n1_48000_123568 0.333333
R11-212-100 n1_46000_123568 n1_48000_123568 0.357143
R11-212-101 n1_48000_123568 n1_65594_123568 3.14179
R11-212-102 n1_65594_123568 n1_88090_123568 4.0171399999999995
R11-212-103 n1_88090_123568 n1_110282_123568 3.96286
R11-212-104 n1_110282_123568 n1_132778_123568 4.0171399999999995
R11-212-105 n1_132778_123568 n1_154970_123568 3.96286
R11-212-106 n1_154970_123568 n1_177466_123568 4.0171399999999995
R11-212-107 n1_177466_123568 n1_199658_123568 3.96286
R11-212-108 n1_199658_123568 n1_221850_123568 3.96286
R11-212-109 n1_221850_123568 n1_244346_123568 4.0171399999999995
R11-212-110 n1_244346_123568 n1_266538_123568 3.96286
R11-212-111 n1_266538_123568 n1_289034_123568 4.0171399999999995
R11-212-112 n1_289034_123568 n1_311226_123568 3.96286
R11-212-113 n1_311226_123568 n1_333722_123568 4.0171399999999995
R11-212-114 n1_333722_123568 n1_355914_123568 3.96286
R11-212-115 n1_355914_123568 n1_378410_123568 4.0171399999999995
R11-212-116 n1_378410_123568 n1_400602_123568 3.96286
R11-212-117 n1_400602_123568 n1_422794_123568 3.96286
R11-212-118 n1_422794_123568 n1_445290_123568 4.0171399999999995
R11-212-119 n1_445290_123568 n1_467482_123568 3.96286
R11-212-120 n1_467482_123568 n1_489978_123568 4.0171399999999995
R11-212-121 n1_489978_123568 n1_512170_123568 3.96286
R11-212-122 n1_512170_123568 n1_534666_123568 4.0171399999999995
R11-212-123 n1_534666_123568 n1_556858_123568 3.96286
R11-212-124 n1_556858_123568 n1_579050_123568 3.96286
R11-212-125 n1_579050_123568 n1_601546_123568 4.0171399999999995
R11-212-126 n1_601546_123568 n1_623064_123568 3.8425
R11-212-127 n1_623064_123568 n1_625064_123568 0.357143
R11-213-100 n1_623064_123568 n1_625064_123568 0.333333
R11-213-101 n1_625064_123568 n1_627064_123568 0.357143
R11-214-100 n1_625064_123568 n1_627064_123568 0.333333
R11-215-100 n1_44000_126912 n1_46000_126912 0.333333
R11-216-100 n1_44000_126912 n1_46000_126912 0.357143
R11-216-101 n1_46000_126912 n1_48000_126912 0.333333
R11-217-100 n1_46000_126912 n1_48000_126912 0.357143
R11-217-101 n1_48000_126912 n1_65594_126912 3.14179
R11-217-102 n1_65594_126912 n1_88090_126912 4.0171399999999995
R11-217-103 n1_88090_126912 n1_110282_126912 3.96286
R11-217-104 n1_110282_126912 n1_132778_126912 4.0171399999999995
R11-217-105 n1_132778_126912 n1_154970_126912 3.96286
R11-217-106 n1_154970_126912 n1_177466_126912 4.0171399999999995
R11-217-107 n1_177466_126912 n1_199658_126912 3.96286
R11-217-108 n1_199658_126912 n1_221850_126912 3.96286
R11-217-109 n1_221850_126912 n1_244346_126912 4.0171399999999995
R11-217-110 n1_244346_126912 n1_266538_126912 3.96286
R11-217-111 n1_266538_126912 n1_289034_126912 4.0171399999999995
R11-217-112 n1_289034_126912 n1_311226_126912 3.96286
R11-217-113 n1_311226_126912 n1_333722_126912 4.0171399999999995
R11-217-114 n1_333722_126912 n1_355914_126912 3.96286
R11-217-115 n1_355914_126912 n1_378410_126912 4.0171399999999995
R11-217-116 n1_378410_126912 n1_400602_126912 3.96286
R11-217-117 n1_400602_126912 n1_422794_126912 3.96286
R11-217-118 n1_422794_126912 n1_445290_126912 4.0171399999999995
R11-217-119 n1_445290_126912 n1_467482_126912 3.96286
R11-217-120 n1_467482_126912 n1_489978_126912 4.0171399999999995
R11-217-121 n1_489978_126912 n1_512170_126912 3.96286
R11-217-122 n1_512170_126912 n1_534666_126912 4.0171399999999995
R11-217-123 n1_534666_126912 n1_556858_126912 3.96286
R11-217-124 n1_556858_126912 n1_579050_126912 3.96286
R11-217-125 n1_579050_126912 n1_601546_126912 4.0171399999999995
R11-217-126 n1_601546_126912 n1_623064_126912 3.8425
R11-217-127 n1_623064_126912 n1_625064_126912 0.357143
R11-218-100 n1_623064_126912 n1_625064_126912 0.333333
R11-218-101 n1_625064_126912 n1_627064_126912 0.357143
R11-219-100 n1_625064_126912 n1_627064_126912 0.333333
R11-220-100 n1_44000_130256 n1_46000_130256 0.333333
R11-221-100 n1_44000_130256 n1_46000_130256 0.357143
R11-221-101 n1_46000_130256 n1_48000_130256 0.333333
R11-222-100 n1_46000_130256 n1_48000_130256 0.357143
R11-222-101 n1_48000_130256 n1_65594_130256 3.14179
R11-222-102 n1_65594_130256 n1_88090_130256 4.0171399999999995
R11-222-103 n1_88090_130256 n1_110282_130256 3.96286
R11-222-104 n1_110282_130256 n1_132778_130256 4.0171399999999995
R11-222-105 n1_132778_130256 n1_154970_130256 3.96286
R11-222-106 n1_154970_130256 n1_177466_130256 4.0171399999999995
R11-222-107 n1_177466_130256 n1_199658_130256 3.96286
R11-222-108 n1_199658_130256 n1_221850_130256 3.96286
R11-222-109 n1_221850_130256 n1_244346_130256 4.0171399999999995
R11-222-110 n1_244346_130256 n1_266538_130256 3.96286
R11-222-111 n1_266538_130256 n1_289034_130256 4.0171399999999995
R11-222-112 n1_289034_130256 n1_311226_130256 3.96286
R11-222-113 n1_311226_130256 n1_333722_130256 4.0171399999999995
R11-222-114 n1_333722_130256 n1_355914_130256 3.96286
R11-222-115 n1_355914_130256 n1_378410_130256 4.0171399999999995
R11-222-116 n1_378410_130256 n1_400602_130256 3.96286
R11-222-117 n1_400602_130256 n1_422794_130256 3.96286
R11-222-118 n1_422794_130256 n1_445290_130256 4.0171399999999995
R11-222-119 n1_445290_130256 n1_467482_130256 3.96286
R11-222-120 n1_467482_130256 n1_489978_130256 4.0171399999999995
R11-222-121 n1_489978_130256 n1_512170_130256 3.96286
R11-222-122 n1_512170_130256 n1_534666_130256 4.0171399999999995
R11-222-123 n1_534666_130256 n1_556858_130256 3.96286
R11-222-124 n1_556858_130256 n1_579050_130256 3.96286
R11-222-125 n1_579050_130256 n1_601546_130256 4.0171399999999995
R11-222-126 n1_601546_130256 n1_623064_130256 3.8425
R11-222-127 n1_623064_130256 n1_625064_130256 0.357143
R11-223-100 n1_623064_130256 n1_625064_130256 0.333333
R11-223-101 n1_625064_130256 n1_627064_130256 0.357143
R11-224-100 n1_625064_130256 n1_627064_130256 0.333333
R11-225-100 n1_44000_133600 n1_46000_133600 0.333333
R11-226-100 n1_44000_133600 n1_46000_133600 0.357143
R11-226-101 n1_46000_133600 n1_48000_133600 0.333333
R11-227-100 n1_46000_133600 n1_48000_133600 0.357143
R11-227-101 n1_48000_133600 n1_65594_133600 3.14179
R11-227-102 n1_65594_133600 n1_88090_133600 4.0171399999999995
R11-227-103 n1_88090_133600 n1_110282_133600 3.96286
R11-227-104 n1_110282_133600 n1_132778_133600 4.0171399999999995
R11-227-105 n1_132778_133600 n1_154970_133600 3.96286
R11-227-106 n1_154970_133600 n1_177466_133600 4.0171399999999995
R11-227-107 n1_177466_133600 n1_199658_133600 3.96286
R11-227-108 n1_199658_133600 n1_221850_133600 3.96286
R11-227-109 n1_221850_133600 n1_244346_133600 4.0171399999999995
R11-227-110 n1_244346_133600 n1_266538_133600 3.96286
R11-227-111 n1_266538_133600 n1_289034_133600 4.0171399999999995
R11-227-112 n1_289034_133600 n1_311226_133600 3.96286
R11-227-113 n1_311226_133600 n1_333722_133600 4.0171399999999995
R11-227-114 n1_333722_133600 n1_355914_133600 3.96286
R11-227-115 n1_355914_133600 n1_378410_133600 4.0171399999999995
R11-227-116 n1_378410_133600 n1_400602_133600 3.96286
R11-227-117 n1_400602_133600 n1_422794_133600 3.96286
R11-227-118 n1_422794_133600 n1_445290_133600 4.0171399999999995
R11-227-119 n1_445290_133600 n1_467482_133600 3.96286
R11-227-120 n1_467482_133600 n1_489978_133600 4.0171399999999995
R11-227-121 n1_489978_133600 n1_512170_133600 3.96286
R11-227-122 n1_512170_133600 n1_534666_133600 4.0171399999999995
R11-227-123 n1_534666_133600 n1_556858_133600 3.96286
R11-227-124 n1_556858_133600 n1_579050_133600 3.96286
R11-227-125 n1_579050_133600 n1_601546_133600 4.0171399999999995
R11-227-126 n1_601546_133600 n1_623064_133600 3.8425
R11-227-127 n1_623064_133600 n1_625064_133600 0.357143
R11-228-100 n1_623064_133600 n1_625064_133600 0.333333
R11-228-101 n1_625064_133600 n1_627064_133600 0.357143
R11-229-100 n1_625064_133600 n1_627064_133600 0.333333
R11-230-100 n1_44000_136944 n1_46000_136944 0.333333
R11-231-100 n1_44000_136944 n1_46000_136944 0.357143
R11-231-101 n1_46000_136944 n1_48000_136944 0.333333
R11-232-100 n1_46000_136944 n1_48000_136944 0.357143
R11-232-101 n1_48000_136944 n1_65594_136944 3.14179
R11-232-102 n1_65594_136944 n1_88090_136944 4.0171399999999995
R11-232-103 n1_88090_136944 n1_110282_136944 3.96286
R11-232-104 n1_110282_136944 n1_132778_136944 4.0171399999999995
R11-232-105 n1_132778_136944 n1_154970_136944 3.96286
R11-232-106 n1_154970_136944 n1_177466_136944 4.0171399999999995
R11-232-107 n1_177466_136944 n1_199658_136944 3.96286
R11-232-108 n1_199658_136944 n1_221850_136944 3.96286
R11-232-109 n1_221850_136944 n1_244346_136944 4.0171399999999995
R11-232-110 n1_244346_136944 n1_266538_136944 3.96286
R11-232-111 n1_266538_136944 n1_289034_136944 4.0171399999999995
R11-232-112 n1_289034_136944 n1_311226_136944 3.96286
R11-232-113 n1_311226_136944 n1_333722_136944 4.0171399999999995
R11-232-114 n1_333722_136944 n1_355914_136944 3.96286
R11-232-115 n1_355914_136944 n1_378410_136944 4.0171399999999995
R11-232-116 n1_378410_136944 n1_400602_136944 3.96286
R11-232-117 n1_400602_136944 n1_422794_136944 3.96286
R11-232-118 n1_422794_136944 n1_445290_136944 4.0171399999999995
R11-232-119 n1_445290_136944 n1_467482_136944 3.96286
R11-232-120 n1_467482_136944 n1_489978_136944 4.0171399999999995
R11-232-121 n1_489978_136944 n1_512170_136944 3.96286
R11-232-122 n1_512170_136944 n1_534666_136944 4.0171399999999995
R11-232-123 n1_534666_136944 n1_556858_136944 3.96286
R11-232-124 n1_556858_136944 n1_579050_136944 3.96286
R11-232-125 n1_579050_136944 n1_601546_136944 4.0171399999999995
R11-232-126 n1_601546_136944 n1_623064_136944 3.8425
R11-232-127 n1_623064_136944 n1_625064_136944 0.357143
R11-233-100 n1_623064_136944 n1_625064_136944 0.333333
R11-233-101 n1_625064_136944 n1_627064_136944 0.357143
R11-234-100 n1_625064_136944 n1_627064_136944 0.333333
R11-235-100 n1_44000_140288 n1_46000_140288 0.333333
R11-236-100 n1_44000_140288 n1_46000_140288 0.357143
R11-236-101 n1_46000_140288 n1_48000_140288 0.333333
R11-237-100 n1_46000_140288 n1_48000_140288 0.357143
R11-237-101 n1_48000_140288 n1_65594_140288 3.14179
R11-237-102 n1_65594_140288 n1_88090_140288 4.0171399999999995
R11-237-103 n1_88090_140288 n1_110282_140288 3.96286
R11-237-104 n1_110282_140288 n1_132778_140288 4.0171399999999995
R11-237-105 n1_132778_140288 n1_154970_140288 3.96286
R11-237-106 n1_154970_140288 n1_177466_140288 4.0171399999999995
R11-237-107 n1_177466_140288 n1_199658_140288 3.96286
R11-237-108 n1_199658_140288 n1_221850_140288 3.96286
R11-237-109 n1_221850_140288 n1_244346_140288 4.0171399999999995
R11-237-110 n1_244346_140288 n1_266538_140288 3.96286
R11-237-111 n1_266538_140288 n1_289034_140288 4.0171399999999995
R11-237-112 n1_289034_140288 n1_311226_140288 3.96286
R11-237-113 n1_311226_140288 n1_333722_140288 4.0171399999999995
R11-237-114 n1_333722_140288 n1_355914_140288 3.96286
R11-237-115 n1_355914_140288 n1_378410_140288 4.0171399999999995
R11-237-116 n1_378410_140288 n1_400602_140288 3.96286
R11-237-117 n1_400602_140288 n1_422794_140288 3.96286
R11-237-118 n1_422794_140288 n1_445290_140288 4.0171399999999995
R11-237-119 n1_445290_140288 n1_467482_140288 3.96286
R11-237-120 n1_467482_140288 n1_489978_140288 4.0171399999999995
R11-237-121 n1_489978_140288 n1_512170_140288 3.96286
R11-237-122 n1_512170_140288 n1_534666_140288 4.0171399999999995
R11-237-123 n1_534666_140288 n1_556858_140288 3.96286
R11-237-124 n1_556858_140288 n1_579050_140288 3.96286
R11-237-125 n1_579050_140288 n1_601546_140288 4.0171399999999995
R11-237-126 n1_601546_140288 n1_623064_140288 3.8425
R11-237-127 n1_623064_140288 n1_625064_140288 0.357143
R11-238-100 n1_623064_140288 n1_625064_140288 0.333333
R11-238-101 n1_625064_140288 n1_627064_140288 0.357143
R11-239-100 n1_625064_140288 n1_627064_140288 0.333333
R11-240-100 n1_44000_143632 n1_46000_143632 0.333333
R11-241-100 n1_44000_143632 n1_46000_143632 0.357143
R11-241-101 n1_46000_143632 n1_48000_143632 0.333333
R11-242-100 n1_46000_143632 n1_48000_143632 0.357143
R11-242-101 n1_48000_143632 n1_65594_143632 3.14179
R11-242-102 n1_65594_143632 n1_88090_143632 4.0171399999999995
R11-242-103 n1_88090_143632 n1_110282_143632 3.96286
R11-242-104 n1_110282_143632 n1_132778_143632 4.0171399999999995
R11-242-105 n1_132778_143632 n1_154970_143632 3.96286
R11-242-106 n1_154970_143632 n1_177466_143632 4.0171399999999995
R11-242-107 n1_177466_143632 n1_199658_143632 3.96286
R11-242-108 n1_199658_143632 n1_221850_143632 3.96286
R11-242-109 n1_221850_143632 n1_244346_143632 4.0171399999999995
R11-242-110 n1_244346_143632 n1_266538_143632 3.96286
R11-242-111 n1_266538_143632 n1_289034_143632 4.0171399999999995
R11-242-112 n1_289034_143632 n1_311226_143632 3.96286
R11-242-113 n1_311226_143632 n1_333722_143632 4.0171399999999995
R11-242-114 n1_333722_143632 n1_355914_143632 3.96286
R11-242-115 n1_355914_143632 n1_378410_143632 4.0171399999999995
R11-242-116 n1_378410_143632 n1_400602_143632 3.96286
R11-242-117 n1_400602_143632 n1_422794_143632 3.96286
R11-242-118 n1_422794_143632 n1_445290_143632 4.0171399999999995
R11-242-119 n1_445290_143632 n1_467482_143632 3.96286
R11-242-120 n1_467482_143632 n1_489978_143632 4.0171399999999995
R11-242-121 n1_489978_143632 n1_512170_143632 3.96286
R11-242-122 n1_512170_143632 n1_534666_143632 4.0171399999999995
R11-242-123 n1_534666_143632 n1_556858_143632 3.96286
R11-242-124 n1_556858_143632 n1_579050_143632 3.96286
R11-242-125 n1_579050_143632 n1_601546_143632 4.0171399999999995
R11-242-126 n1_601546_143632 n1_623064_143632 3.8425
R11-242-127 n1_623064_143632 n1_625064_143632 0.357143
R11-243-100 n1_623064_143632 n1_625064_143632 0.333333
R11-243-101 n1_625064_143632 n1_627064_143632 0.357143
R11-244-100 n1_625064_143632 n1_627064_143632 0.333333
R11-245-100 n1_44000_146976 n1_46000_146976 0.333333
R11-246-100 n1_44000_146976 n1_46000_146976 0.357143
R11-246-101 n1_46000_146976 n1_48000_146976 0.333333
R11-247-100 n1_46000_146976 n1_48000_146976 0.357143
R11-247-101 n1_48000_146976 n1_65594_146976 3.14179
R11-247-102 n1_65594_146976 n1_88090_146976 4.0171399999999995
R11-247-103 n1_88090_146976 n1_110282_146976 3.96286
R11-247-104 n1_110282_146976 n1_132778_146976 4.0171399999999995
R11-247-105 n1_132778_146976 n1_154970_146976 3.96286
R11-247-106 n1_154970_146976 n1_177466_146976 4.0171399999999995
R11-247-107 n1_177466_146976 n1_199658_146976 3.96286
R11-247-108 n1_199658_146976 n1_221850_146976 3.96286
R11-247-109 n1_221850_146976 n1_244346_146976 4.0171399999999995
R11-247-110 n1_244346_146976 n1_266538_146976 3.96286
R11-247-111 n1_266538_146976 n1_289034_146976 4.0171399999999995
R11-247-112 n1_289034_146976 n1_311226_146976 3.96286
R11-247-113 n1_311226_146976 n1_333722_146976 4.0171399999999995
R11-247-114 n1_333722_146976 n1_355914_146976 3.96286
R11-247-115 n1_355914_146976 n1_378410_146976 4.0171399999999995
R11-247-116 n1_378410_146976 n1_400602_146976 3.96286
R11-247-117 n1_400602_146976 n1_422794_146976 3.96286
R11-247-118 n1_422794_146976 n1_445290_146976 4.0171399999999995
R11-247-119 n1_445290_146976 n1_467482_146976 3.96286
R11-247-120 n1_467482_146976 n1_489978_146976 4.0171399999999995
R11-247-121 n1_489978_146976 n1_512170_146976 3.96286
R11-247-122 n1_512170_146976 n1_534666_146976 4.0171399999999995
R11-247-123 n1_534666_146976 n1_556858_146976 3.96286
R11-247-124 n1_556858_146976 n1_579050_146976 3.96286
R11-247-125 n1_579050_146976 n1_601546_146976 4.0171399999999995
R11-247-126 n1_601546_146976 n1_623064_146976 3.8425
R11-247-127 n1_623064_146976 n1_625064_146976 0.357143
R11-248-100 n1_623064_146976 n1_625064_146976 0.333333
R11-248-101 n1_625064_146976 n1_627064_146976 0.357143
R11-249-100 n1_625064_146976 n1_627064_146976 0.333333
R11-250-100 n1_44000_150320 n1_46000_150320 0.333333
R11-251-100 n1_44000_150320 n1_46000_150320 0.357143
R11-251-101 n1_46000_150320 n1_48000_150320 0.333333
R11-252-100 n1_46000_150320 n1_48000_150320 0.357143
R11-252-101 n1_48000_150320 n1_65594_150320 3.14179
R11-252-102 n1_65594_150320 n1_88090_150320 4.0171399999999995
R11-252-103 n1_88090_150320 n1_110282_150320 3.96286
R11-252-104 n1_110282_150320 n1_132778_150320 4.0171399999999995
R11-252-105 n1_132778_150320 n1_154970_150320 3.96286
R11-252-106 n1_154970_150320 n1_177466_150320 4.0171399999999995
R11-252-107 n1_177466_150320 n1_199658_150320 3.96286
R11-252-108 n1_199658_150320 n1_221850_150320 3.96286
R11-252-109 n1_221850_150320 n1_244346_150320 4.0171399999999995
R11-252-110 n1_244346_150320 n1_266538_150320 3.96286
R11-252-111 n1_266538_150320 n1_289034_150320 4.0171399999999995
R11-252-112 n1_289034_150320 n1_311226_150320 3.96286
R11-252-113 n1_311226_150320 n1_333722_150320 4.0171399999999995
R11-252-114 n1_333722_150320 n1_355914_150320 3.96286
R11-252-115 n1_355914_150320 n1_378410_150320 4.0171399999999995
R11-252-116 n1_378410_150320 n1_400602_150320 3.96286
R11-252-117 n1_400602_150320 n1_422794_150320 3.96286
R11-252-118 n1_422794_150320 n1_445290_150320 4.0171399999999995
R11-252-119 n1_445290_150320 n1_467482_150320 3.96286
R11-252-120 n1_467482_150320 n1_489978_150320 4.0171399999999995
R11-252-121 n1_489978_150320 n1_512170_150320 3.96286
R11-252-122 n1_512170_150320 n1_534666_150320 4.0171399999999995
R11-252-123 n1_534666_150320 n1_556858_150320 3.96286
R11-252-124 n1_556858_150320 n1_579050_150320 3.96286
R11-252-125 n1_579050_150320 n1_601546_150320 4.0171399999999995
R11-252-126 n1_601546_150320 n1_623064_150320 3.8425
R11-252-127 n1_623064_150320 n1_625064_150320 0.357143
R11-253-100 n1_623064_150320 n1_625064_150320 0.333333
R11-253-101 n1_625064_150320 n1_627064_150320 0.357143
R11-254-100 n1_625064_150320 n1_627064_150320 0.333333
R11-255-100 n1_44000_153664 n1_46000_153664 0.333333
R11-256-100 n1_44000_153664 n1_46000_153664 0.357143
R11-256-101 n1_46000_153664 n1_48000_153664 0.333333
R11-257-100 n1_46000_153664 n1_48000_153664 0.357143
R11-257-101 n1_48000_153664 n1_65594_153664 3.14179
R11-257-102 n1_65594_153664 n1_88090_153664 4.0171399999999995
R11-257-103 n1_88090_153664 n1_110282_153664 3.96286
R11-257-104 n1_110282_153664 n1_132778_153664 4.0171399999999995
R11-257-105 n1_132778_153664 n1_154970_153664 3.96286
R11-257-106 n1_154970_153664 n1_177466_153664 4.0171399999999995
R11-257-107 n1_177466_153664 n1_199658_153664 3.96286
R11-257-108 n1_199658_153664 n1_221850_153664 3.96286
R11-257-109 n1_221850_153664 n1_244346_153664 4.0171399999999995
R11-257-110 n1_244346_153664 n1_266538_153664 3.96286
R11-257-111 n1_266538_153664 n1_289034_153664 4.0171399999999995
R11-257-112 n1_289034_153664 n1_311226_153664 3.96286
R11-257-113 n1_311226_153664 n1_333722_153664 4.0171399999999995
R11-257-114 n1_333722_153664 n1_355914_153664 3.96286
R11-257-115 n1_355914_153664 n1_378410_153664 4.0171399999999995
R11-257-116 n1_378410_153664 n1_400602_153664 3.96286
R11-257-117 n1_400602_153664 n1_422794_153664 3.96286
R11-257-118 n1_422794_153664 n1_445290_153664 4.0171399999999995
R11-257-119 n1_445290_153664 n1_467482_153664 3.96286
R11-257-120 n1_467482_153664 n1_489978_153664 4.0171399999999995
R11-257-121 n1_489978_153664 n1_512170_153664 3.96286
R11-257-122 n1_512170_153664 n1_534666_153664 4.0171399999999995
R11-257-123 n1_534666_153664 n1_556858_153664 3.96286
R11-257-124 n1_556858_153664 n1_579050_153664 3.96286
R11-257-125 n1_579050_153664 n1_601546_153664 4.0171399999999995
R11-257-126 n1_601546_153664 n1_623064_153664 3.8425
R11-257-127 n1_623064_153664 n1_625064_153664 0.357143
R11-258-100 n1_623064_153664 n1_625064_153664 0.333333
R11-258-101 n1_625064_153664 n1_627064_153664 0.357143
R11-259-100 n1_625064_153664 n1_627064_153664 0.333333
R11-260-100 n1_44000_157008 n1_46000_157008 0.333333
R11-261-100 n1_44000_157008 n1_46000_157008 0.357143
R11-261-101 n1_46000_157008 n1_48000_157008 0.333333
R11-262-100 n1_46000_157008 n1_48000_157008 0.357143
R11-262-101 n1_48000_157008 n1_65594_157008 3.14179
R11-262-102 n1_65594_157008 n1_88090_157008 4.0171399999999995
R11-262-103 n1_88090_157008 n1_110282_157008 3.96286
R11-262-104 n1_110282_157008 n1_132778_157008 4.0171399999999995
R11-262-105 n1_132778_157008 n1_154970_157008 3.96286
R11-262-106 n1_154970_157008 n1_177466_157008 4.0171399999999995
R11-262-107 n1_177466_157008 n1_199658_157008 3.96286
R11-262-108 n1_199658_157008 n1_221850_157008 3.96286
R11-262-109 n1_221850_157008 n1_244346_157008 4.0171399999999995
R11-262-110 n1_244346_157008 n1_266538_157008 3.96286
R11-262-111 n1_266538_157008 n1_289034_157008 4.0171399999999995
R11-262-112 n1_289034_157008 n1_311226_157008 3.96286
R11-262-113 n1_311226_157008 n1_333722_157008 4.0171399999999995
R11-262-114 n1_333722_157008 n1_355914_157008 3.96286
R11-262-115 n1_355914_157008 n1_378410_157008 4.0171399999999995
R11-262-116 n1_378410_157008 n1_400602_157008 3.96286
R11-262-117 n1_400602_157008 n1_422794_157008 3.96286
R11-262-118 n1_422794_157008 n1_445290_157008 4.0171399999999995
R11-262-119 n1_445290_157008 n1_467482_157008 3.96286
R11-262-120 n1_467482_157008 n1_489978_157008 4.0171399999999995
R11-262-121 n1_489978_157008 n1_512170_157008 3.96286
R11-262-122 n1_512170_157008 n1_534666_157008 4.0171399999999995
R11-262-123 n1_534666_157008 n1_556858_157008 3.96286
R11-262-124 n1_556858_157008 n1_579050_157008 3.96286
R11-262-125 n1_579050_157008 n1_601546_157008 4.0171399999999995
R11-262-126 n1_601546_157008 n1_623064_157008 3.8425
R11-262-127 n1_623064_157008 n1_625064_157008 0.357143
R11-263-100 n1_623064_157008 n1_625064_157008 0.333333
R11-263-101 n1_625064_157008 n1_627064_157008 0.357143
R11-264-100 n1_625064_157008 n1_627064_157008 0.333333
R11-265-100 n1_44000_160352 n1_46000_160352 0.333333
R11-266-100 n1_44000_160352 n1_46000_160352 0.357143
R11-266-101 n1_46000_160352 n1_48000_160352 0.333333
R11-267-100 n1_46000_160352 n1_48000_160352 0.357143
R11-267-101 n1_48000_160352 n1_65594_160352 3.14179
R11-267-102 n1_65594_160352 n1_88090_160352 4.0171399999999995
R11-267-103 n1_88090_160352 n1_110282_160352 3.96286
R11-267-104 n1_110282_160352 n1_132778_160352 4.0171399999999995
R11-267-105 n1_132778_160352 n1_154970_160352 3.96286
R11-267-106 n1_154970_160352 n1_177466_160352 4.0171399999999995
R11-267-107 n1_177466_160352 n1_199658_160352 3.96286
R11-267-108 n1_199658_160352 n1_221850_160352 3.96286
R11-267-109 n1_221850_160352 n1_244346_160352 4.0171399999999995
R11-267-110 n1_244346_160352 n1_266538_160352 3.96286
R11-267-111 n1_266538_160352 n1_289034_160352 4.0171399999999995
R11-267-112 n1_289034_160352 n1_311226_160352 3.96286
R11-267-113 n1_311226_160352 n1_333722_160352 4.0171399999999995
R11-267-114 n1_333722_160352 n1_355914_160352 3.96286
R11-267-115 n1_355914_160352 n1_378410_160352 4.0171399999999995
R11-267-116 n1_378410_160352 n1_400602_160352 3.96286
R11-267-117 n1_400602_160352 n1_422794_160352 3.96286
R11-267-118 n1_422794_160352 n1_445290_160352 4.0171399999999995
R11-267-119 n1_445290_160352 n1_467482_160352 3.96286
R11-267-120 n1_467482_160352 n1_489978_160352 4.0171399999999995
R11-267-121 n1_489978_160352 n1_512170_160352 3.96286
R11-267-122 n1_512170_160352 n1_534666_160352 4.0171399999999995
R11-267-123 n1_534666_160352 n1_556858_160352 3.96286
R11-267-124 n1_556858_160352 n1_579050_160352 3.96286
R11-267-125 n1_579050_160352 n1_601546_160352 4.0171399999999995
R11-267-126 n1_601546_160352 n1_623064_160352 3.8425
R11-267-127 n1_623064_160352 n1_625064_160352 0.357143
R11-268-100 n1_623064_160352 n1_625064_160352 0.333333
R11-268-101 n1_625064_160352 n1_627064_160352 0.357143
R11-269-100 n1_625064_160352 n1_627064_160352 0.333333
R11-270-100 n1_44000_163696 n1_46000_163696 0.333333
R11-271-100 n1_44000_163696 n1_46000_163696 0.357143
R11-271-101 n1_46000_163696 n1_48000_163696 0.333333
R11-272-100 n1_46000_163696 n1_48000_163696 0.357143
R11-272-101 n1_48000_163696 n1_65594_163696 3.14179
R11-272-102 n1_65594_163696 n1_88090_163696 4.0171399999999995
R11-272-103 n1_88090_163696 n1_110282_163696 3.96286
R11-272-104 n1_110282_163696 n1_132778_163696 4.0171399999999995
R11-272-105 n1_132778_163696 n1_154970_163696 3.96286
R11-272-106 n1_154970_163696 n1_177466_163696 4.0171399999999995
R11-272-107 n1_177466_163696 n1_199658_163696 3.96286
R11-272-108 n1_199658_163696 n1_221850_163696 3.96286
R11-272-109 n1_221850_163696 n1_244346_163696 4.0171399999999995
R11-272-110 n1_244346_163696 n1_266538_163696 3.96286
R11-272-111 n1_266538_163696 n1_289034_163696 4.0171399999999995
R11-272-112 n1_289034_163696 n1_311226_163696 3.96286
R11-272-113 n1_311226_163696 n1_333722_163696 4.0171399999999995
R11-272-114 n1_333722_163696 n1_355914_163696 3.96286
R11-272-115 n1_355914_163696 n1_378410_163696 4.0171399999999995
R11-272-116 n1_378410_163696 n1_400602_163696 3.96286
R11-272-117 n1_400602_163696 n1_422794_163696 3.96286
R11-272-118 n1_422794_163696 n1_445290_163696 4.0171399999999995
R11-272-119 n1_445290_163696 n1_467482_163696 3.96286
R11-272-120 n1_467482_163696 n1_489978_163696 4.0171399999999995
R11-272-121 n1_489978_163696 n1_512170_163696 3.96286
R11-272-122 n1_512170_163696 n1_534666_163696 4.0171399999999995
R11-272-123 n1_534666_163696 n1_556858_163696 3.96286
R11-272-124 n1_556858_163696 n1_579050_163696 3.96286
R11-272-125 n1_579050_163696 n1_601546_163696 4.0171399999999995
R11-272-126 n1_601546_163696 n1_623064_163696 3.8425
R11-272-127 n1_623064_163696 n1_625064_163696 0.357143
R11-273-100 n1_623064_163696 n1_625064_163696 0.333333
R11-273-101 n1_625064_163696 n1_627064_163696 0.357143
R11-274-100 n1_625064_163696 n1_627064_163696 0.333333
R11-275-100 n1_44000_167040 n1_46000_167040 0.357143
R11-276-100 n1_44000_167040 n1_46000_167040 0.333333
R11-276-101 n1_46000_167040 n1_48000_167040 0.357143
R11-277-100 n1_46000_167040 n1_48000_167040 0.333333
R11-277-101 n1_48000_167040 n1_65594_167040 3.14179
R11-277-102 n1_65594_167040 n1_88090_167040 4.0171399999999995
R11-277-103 n1_88090_167040 n1_110282_167040 3.96286
R11-277-104 n1_110282_167040 n1_132778_167040 4.0171399999999995
R11-277-105 n1_132778_167040 n1_154970_167040 3.96286
R11-277-106 n1_154970_167040 n1_177466_167040 4.0171399999999995
R11-277-107 n1_177466_167040 n1_199658_167040 3.96286
R11-277-108 n1_199658_167040 n1_221850_167040 3.96286
R11-277-109 n1_221850_167040 n1_244346_167040 4.0171399999999995
R11-277-110 n1_244346_167040 n1_266538_167040 3.96286
R11-277-111 n1_266538_167040 n1_289034_167040 4.0171399999999995
R11-277-112 n1_289034_167040 n1_311226_167040 3.96286
R11-277-113 n1_311226_167040 n1_333722_167040 4.0171399999999995
R11-277-114 n1_333722_167040 n1_355914_167040 3.96286
R11-277-115 n1_355914_167040 n1_378410_167040 4.0171399999999995
R11-277-116 n1_378410_167040 n1_400602_167040 3.96286
R11-277-117 n1_400602_167040 n1_422794_167040 3.96286
R11-277-118 n1_422794_167040 n1_445290_167040 4.0171399999999995
R11-277-119 n1_445290_167040 n1_467482_167040 3.96286
R11-277-120 n1_467482_167040 n1_489978_167040 4.0171399999999995
R11-277-121 n1_489978_167040 n1_512170_167040 3.96286
R11-277-122 n1_512170_167040 n1_534666_167040 4.0171399999999995
R11-277-123 n1_534666_167040 n1_556858_167040 3.96286
R11-277-124 n1_556858_167040 n1_579050_167040 3.96286
R11-277-125 n1_579050_167040 n1_601546_167040 4.0171399999999995
R11-277-126 n1_601546_167040 n1_623064_167040 3.8425
R11-277-127 n1_623064_167040 n1_625064_167040 0.357143
R11-278-100 n1_623064_167040 n1_625064_167040 0.333333
R11-278-101 n1_625064_167040 n1_627064_167040 0.357143
R11-279-100 n1_625064_167040 n1_627064_167040 0.333333
R11-280-100 n1_44000_170384 n1_46000_170384 0.357143
R11-281-100 n1_44000_170384 n1_46000_170384 0.333333
R11-281-101 n1_46000_170384 n1_48000_170384 0.357143
R11-282-100 n1_46000_170384 n1_48000_170384 0.333333
R11-282-101 n1_48000_170384 n1_65594_170384 3.14179
R11-282-102 n1_65594_170384 n1_88090_170384 4.0171399999999995
R11-282-103 n1_88090_170384 n1_110282_170384 3.96286
R11-282-104 n1_110282_170384 n1_132778_170384 4.0171399999999995
R11-282-105 n1_132778_170384 n1_154970_170384 3.96286
R11-282-106 n1_154970_170384 n1_177466_170384 4.0171399999999995
R11-282-107 n1_177466_170384 n1_199658_170384 3.96286
R11-282-108 n1_199658_170384 n1_221850_170384 3.96286
R11-282-109 n1_221850_170384 n1_244346_170384 4.0171399999999995
R11-282-110 n1_244346_170384 n1_266538_170384 3.96286
R11-282-111 n1_266538_170384 n1_289034_170384 4.0171399999999995
R11-282-112 n1_289034_170384 n1_311226_170384 3.96286
R11-282-113 n1_311226_170384 n1_333722_170384 4.0171399999999995
R11-282-114 n1_333722_170384 n1_355914_170384 3.96286
R11-282-115 n1_355914_170384 n1_378410_170384 4.0171399999999995
R11-282-116 n1_378410_170384 n1_400602_170384 3.96286
R11-282-117 n1_400602_170384 n1_422794_170384 3.96286
R11-282-118 n1_422794_170384 n1_445290_170384 4.0171399999999995
R11-282-119 n1_445290_170384 n1_467482_170384 3.96286
R11-282-120 n1_467482_170384 n1_489978_170384 4.0171399999999995
R11-282-121 n1_489978_170384 n1_512170_170384 3.96286
R11-282-122 n1_512170_170384 n1_534666_170384 4.0171399999999995
R11-282-123 n1_534666_170384 n1_556858_170384 3.96286
R11-282-124 n1_556858_170384 n1_579050_170384 3.96286
R11-282-125 n1_579050_170384 n1_601546_170384 4.0171399999999995
R11-282-126 n1_601546_170384 n1_623064_170384 3.8425
R11-282-127 n1_623064_170384 n1_625064_170384 0.357143
R11-283-100 n1_623064_170384 n1_625064_170384 0.333333
R11-283-101 n1_625064_170384 n1_627064_170384 0.357143
R11-284-100 n1_625064_170384 n1_627064_170384 0.333333
R11-285-100 n1_44000_173728 n1_46000_173728 0.357143
R11-286-100 n1_44000_173728 n1_46000_173728 0.333333
R11-286-101 n1_46000_173728 n1_48000_173728 0.357143
R11-287-100 n1_46000_173728 n1_48000_173728 0.333333
R11-287-101 n1_48000_173728 n1_65594_173728 3.14179
R11-287-102 n1_65594_173728 n1_88090_173728 4.0171399999999995
R11-287-103 n1_88090_173728 n1_110282_173728 3.96286
R11-287-104 n1_110282_173728 n1_132778_173728 4.0171399999999995
R11-287-105 n1_132778_173728 n1_154970_173728 3.96286
R11-287-106 n1_154970_173728 n1_177466_173728 4.0171399999999995
R11-287-107 n1_177466_173728 n1_199658_173728 3.96286
R11-287-108 n1_199658_173728 n1_221850_173728 3.96286
R11-287-109 n1_221850_173728 n1_244346_173728 4.0171399999999995
R11-287-110 n1_244346_173728 n1_266538_173728 3.96286
R11-287-111 n1_266538_173728 n1_289034_173728 4.0171399999999995
R11-287-112 n1_289034_173728 n1_311226_173728 3.96286
R11-287-113 n1_311226_173728 n1_333722_173728 4.0171399999999995
R11-287-114 n1_333722_173728 n1_355914_173728 3.96286
R11-287-115 n1_355914_173728 n1_378410_173728 4.0171399999999995
R11-287-116 n1_378410_173728 n1_400602_173728 3.96286
R11-287-117 n1_400602_173728 n1_422794_173728 3.96286
R11-287-118 n1_422794_173728 n1_445290_173728 4.0171399999999995
R11-287-119 n1_445290_173728 n1_467482_173728 3.96286
R11-287-120 n1_467482_173728 n1_489978_173728 4.0171399999999995
R11-287-121 n1_489978_173728 n1_512170_173728 3.96286
R11-287-122 n1_512170_173728 n1_534666_173728 4.0171399999999995
R11-287-123 n1_534666_173728 n1_556858_173728 3.96286
R11-287-124 n1_556858_173728 n1_579050_173728 3.96286
R11-287-125 n1_579050_173728 n1_601546_173728 4.0171399999999995
R11-287-126 n1_601546_173728 n1_623064_173728 3.8425
R11-287-127 n1_623064_173728 n1_625064_173728 0.357143
R11-288-100 n1_623064_173728 n1_625064_173728 0.333333
R11-288-101 n1_625064_173728 n1_627064_173728 0.357143
R11-289-100 n1_625064_173728 n1_627064_173728 0.333333
R11-290-100 n1_44000_177072 n1_46000_177072 0.357143
R11-291-100 n1_44000_177072 n1_46000_177072 0.333333
R11-291-101 n1_46000_177072 n1_48000_177072 0.357143
R11-292-100 n1_46000_177072 n1_48000_177072 0.333333
R11-292-101 n1_48000_177072 n1_65594_177072 3.14179
R11-292-102 n1_65594_177072 n1_88090_177072 4.0171399999999995
R11-292-103 n1_88090_177072 n1_110282_177072 3.96286
R11-292-104 n1_110282_177072 n1_132778_177072 4.0171399999999995
R11-292-105 n1_132778_177072 n1_154970_177072 3.96286
R11-292-106 n1_154970_177072 n1_177466_177072 4.0171399999999995
R11-292-107 n1_177466_177072 n1_199658_177072 3.96286
R11-292-108 n1_199658_177072 n1_221850_177072 3.96286
R11-292-109 n1_221850_177072 n1_244346_177072 4.0171399999999995
R11-292-110 n1_244346_177072 n1_266538_177072 3.96286
R11-292-111 n1_266538_177072 n1_289034_177072 4.0171399999999995
R11-292-112 n1_289034_177072 n1_311226_177072 3.96286
R11-292-113 n1_311226_177072 n1_333722_177072 4.0171399999999995
R11-292-114 n1_333722_177072 n1_355914_177072 3.96286
R11-292-115 n1_355914_177072 n1_378410_177072 4.0171399999999995
R11-292-116 n1_378410_177072 n1_400602_177072 3.96286
R11-292-117 n1_400602_177072 n1_422794_177072 3.96286
R11-292-118 n1_422794_177072 n1_445290_177072 4.0171399999999995
R11-292-119 n1_445290_177072 n1_467482_177072 3.96286
R11-292-120 n1_467482_177072 n1_489978_177072 4.0171399999999995
R11-292-121 n1_489978_177072 n1_512170_177072 3.96286
R11-292-122 n1_512170_177072 n1_534666_177072 4.0171399999999995
R11-292-123 n1_534666_177072 n1_556858_177072 3.96286
R11-292-124 n1_556858_177072 n1_579050_177072 3.96286
R11-292-125 n1_579050_177072 n1_601546_177072 4.0171399999999995
R11-292-126 n1_601546_177072 n1_623064_177072 3.8425
R11-292-127 n1_623064_177072 n1_625064_177072 0.357143
R11-293-100 n1_623064_177072 n1_625064_177072 0.333333
R11-293-101 n1_625064_177072 n1_627064_177072 0.357143
R11-294-100 n1_625064_177072 n1_627064_177072 0.333333
R11-295-100 n1_44000_180416 n1_46000_180416 0.357143
R11-296-100 n1_44000_180416 n1_46000_180416 0.333333
R11-296-101 n1_46000_180416 n1_48000_180416 0.357143
R11-297-100 n1_46000_180416 n1_48000_180416 0.333333
R11-297-101 n1_48000_180416 n1_65594_180416 3.14179
R11-297-102 n1_65594_180416 n1_88090_180416 4.0171399999999995
R11-297-103 n1_88090_180416 n1_110282_180416 3.96286
R11-297-104 n1_110282_180416 n1_132778_180416 4.0171399999999995
R11-297-105 n1_132778_180416 n1_154970_180416 3.96286
R11-297-106 n1_154970_180416 n1_177466_180416 4.0171399999999995
R11-297-107 n1_177466_180416 n1_199658_180416 3.96286
R11-297-108 n1_199658_180416 n1_221850_180416 3.96286
R11-297-109 n1_221850_180416 n1_244346_180416 4.0171399999999995
R11-297-110 n1_244346_180416 n1_266538_180416 3.96286
R11-297-111 n1_266538_180416 n1_289034_180416 4.0171399999999995
R11-297-112 n1_289034_180416 n1_311226_180416 3.96286
R11-297-113 n1_311226_180416 n1_333722_180416 4.0171399999999995
R11-297-114 n1_333722_180416 n1_355914_180416 3.96286
R11-297-115 n1_355914_180416 n1_378410_180416 4.0171399999999995
R11-297-116 n1_378410_180416 n1_400602_180416 3.96286
R11-297-117 n1_400602_180416 n1_422794_180416 3.96286
R11-297-118 n1_422794_180416 n1_445290_180416 4.0171399999999995
R11-297-119 n1_445290_180416 n1_467482_180416 3.96286
R11-297-120 n1_467482_180416 n1_489978_180416 4.0171399999999995
R11-297-121 n1_489978_180416 n1_512170_180416 3.96286
R11-297-122 n1_512170_180416 n1_534666_180416 4.0171399999999995
R11-297-123 n1_534666_180416 n1_556858_180416 3.96286
R11-297-124 n1_556858_180416 n1_579050_180416 3.96286
R11-297-125 n1_579050_180416 n1_601546_180416 4.0171399999999995
R11-297-126 n1_601546_180416 n1_623064_180416 3.8425
R11-297-127 n1_623064_180416 n1_625064_180416 0.357143
R11-298-100 n1_623064_180416 n1_625064_180416 0.333333
R11-298-101 n1_625064_180416 n1_627064_180416 0.357143
R11-299-100 n1_625064_180416 n1_627064_180416 0.333333
R11-300-100 n1_44000_183760 n1_46000_183760 0.333333
R11-301-100 n1_44000_183760 n1_46000_183760 0.357143
R11-301-101 n1_46000_183760 n1_48000_183760 0.333333
R11-302-100 n1_46000_183760 n1_48000_183760 0.357143
R11-302-101 n1_48000_183760 n1_65594_183760 3.14179
R11-302-102 n1_65594_183760 n1_88090_183760 4.0171399999999995
R11-302-103 n1_88090_183760 n1_110282_183760 3.96286
R11-302-104 n1_110282_183760 n1_132778_183760 4.0171399999999995
R11-302-105 n1_132778_183760 n1_154970_183760 3.96286
R11-302-106 n1_154970_183760 n1_177466_183760 4.0171399999999995
R11-302-107 n1_177466_183760 n1_199658_183760 3.96286
R11-302-108 n1_199658_183760 n1_221850_183760 3.96286
R11-302-109 n1_221850_183760 n1_244346_183760 4.0171399999999995
R11-302-110 n1_244346_183760 n1_266538_183760 3.96286
R11-302-111 n1_266538_183760 n1_289034_183760 4.0171399999999995
R11-302-112 n1_289034_183760 n1_311226_183760 3.96286
R11-302-113 n1_311226_183760 n1_333722_183760 4.0171399999999995
R11-302-114 n1_333722_183760 n1_355914_183760 3.96286
R11-302-115 n1_355914_183760 n1_378410_183760 4.0171399999999995
R11-302-116 n1_378410_183760 n1_400602_183760 3.96286
R11-302-117 n1_400602_183760 n1_422794_183760 3.96286
R11-302-118 n1_422794_183760 n1_445290_183760 4.0171399999999995
R11-302-119 n1_445290_183760 n1_467482_183760 3.96286
R11-302-120 n1_467482_183760 n1_489978_183760 4.0171399999999995
R11-302-121 n1_489978_183760 n1_512170_183760 3.96286
R11-302-122 n1_512170_183760 n1_534666_183760 4.0171399999999995
R11-302-123 n1_534666_183760 n1_556858_183760 3.96286
R11-302-124 n1_556858_183760 n1_579050_183760 3.96286
R11-302-125 n1_579050_183760 n1_601546_183760 4.0171399999999995
R11-302-126 n1_601546_183760 n1_623064_183760 3.8425
R11-302-127 n1_623064_183760 n1_625064_183760 0.357143
R11-303-100 n1_623064_183760 n1_625064_183760 0.333333
R11-303-101 n1_625064_183760 n1_627064_183760 0.357143
R11-304-100 n1_625064_183760 n1_627064_183760 0.333333
R11-305-100 n1_44000_187104 n1_46000_187104 0.333333
R11-306-100 n1_44000_187104 n1_46000_187104 0.357143
R11-306-101 n1_46000_187104 n1_48000_187104 0.333333
R11-307-100 n1_46000_187104 n1_48000_187104 0.357143
R11-307-101 n1_48000_187104 n1_65594_187104 3.14179
R11-307-102 n1_65594_187104 n1_88090_187104 4.0171399999999995
R11-307-103 n1_88090_187104 n1_110282_187104 3.96286
R11-307-104 n1_110282_187104 n1_132778_187104 4.0171399999999995
R11-307-105 n1_132778_187104 n1_154970_187104 3.96286
R11-307-106 n1_154970_187104 n1_177466_187104 4.0171399999999995
R11-307-107 n1_177466_187104 n1_199658_187104 3.96286
R11-307-108 n1_199658_187104 n1_221850_187104 3.96286
R11-307-109 n1_221850_187104 n1_244346_187104 4.0171399999999995
R11-307-110 n1_244346_187104 n1_266538_187104 3.96286
R11-307-111 n1_266538_187104 n1_289034_187104 4.0171399999999995
R11-307-112 n1_289034_187104 n1_311226_187104 3.96286
R11-307-113 n1_311226_187104 n1_333722_187104 4.0171399999999995
R11-307-114 n1_333722_187104 n1_355914_187104 3.96286
R11-307-115 n1_355914_187104 n1_378410_187104 4.0171399999999995
R11-307-116 n1_378410_187104 n1_400602_187104 3.96286
R11-307-117 n1_400602_187104 n1_422794_187104 3.96286
R11-307-118 n1_422794_187104 n1_445290_187104 4.0171399999999995
R11-307-119 n1_445290_187104 n1_467482_187104 3.96286
R11-307-120 n1_467482_187104 n1_489978_187104 4.0171399999999995
R11-307-121 n1_489978_187104 n1_512170_187104 3.96286
R11-307-122 n1_512170_187104 n1_534666_187104 4.0171399999999995
R11-307-123 n1_534666_187104 n1_556858_187104 3.96286
R11-307-124 n1_556858_187104 n1_579050_187104 3.96286
R11-307-125 n1_579050_187104 n1_601546_187104 4.0171399999999995
R11-307-126 n1_601546_187104 n1_623064_187104 3.8425
R11-307-127 n1_623064_187104 n1_625064_187104 0.357143
R11-308-100 n1_623064_187104 n1_625064_187104 0.333333
R11-308-101 n1_625064_187104 n1_627064_187104 0.357143
R11-309-100 n1_625064_187104 n1_627064_187104 0.333333
R11-310-100 n1_44000_190448 n1_46000_190448 0.333333
R11-311-100 n1_44000_190448 n1_46000_190448 0.357143
R11-311-101 n1_46000_190448 n1_48000_190448 0.333333
R11-312-100 n1_46000_190448 n1_48000_190448 0.357143
R11-312-101 n1_48000_190448 n1_65594_190448 3.14179
R11-312-102 n1_65594_190448 n1_88090_190448 4.0171399999999995
R11-312-103 n1_88090_190448 n1_110282_190448 3.96286
R11-312-104 n1_110282_190448 n1_132778_190448 4.0171399999999995
R11-312-105 n1_132778_190448 n1_154970_190448 3.96286
R11-312-106 n1_154970_190448 n1_177466_190448 4.0171399999999995
R11-312-107 n1_177466_190448 n1_199658_190448 3.96286
R11-312-108 n1_199658_190448 n1_221850_190448 3.96286
R11-312-109 n1_221850_190448 n1_244346_190448 4.0171399999999995
R11-312-110 n1_244346_190448 n1_266538_190448 3.96286
R11-312-111 n1_266538_190448 n1_289034_190448 4.0171399999999995
R11-312-112 n1_289034_190448 n1_311226_190448 3.96286
R11-312-113 n1_311226_190448 n1_333722_190448 4.0171399999999995
R11-312-114 n1_333722_190448 n1_355914_190448 3.96286
R11-312-115 n1_355914_190448 n1_378410_190448 4.0171399999999995
R11-312-116 n1_378410_190448 n1_400602_190448 3.96286
R11-312-117 n1_400602_190448 n1_422794_190448 3.96286
R11-312-118 n1_422794_190448 n1_445290_190448 4.0171399999999995
R11-312-119 n1_445290_190448 n1_467482_190448 3.96286
R11-312-120 n1_467482_190448 n1_489978_190448 4.0171399999999995
R11-312-121 n1_489978_190448 n1_512170_190448 3.96286
R11-312-122 n1_512170_190448 n1_534666_190448 4.0171399999999995
R11-312-123 n1_534666_190448 n1_556858_190448 3.96286
R11-312-124 n1_556858_190448 n1_579050_190448 3.96286
R11-312-125 n1_579050_190448 n1_601546_190448 4.0171399999999995
R11-312-126 n1_601546_190448 n1_623064_190448 3.8425
R11-312-127 n1_623064_190448 n1_625064_190448 0.357143
R11-313-100 n1_623064_190448 n1_625064_190448 0.333333
R11-313-101 n1_625064_190448 n1_627064_190448 0.357143
R11-314-100 n1_625064_190448 n1_627064_190448 0.333333
R11-315-100 n1_44000_193792 n1_46000_193792 0.333333
R11-316-100 n1_44000_193792 n1_46000_193792 0.357143
R11-316-101 n1_46000_193792 n1_48000_193792 0.333333
R11-317-100 n1_46000_193792 n1_48000_193792 0.357143
R11-317-101 n1_48000_193792 n1_65594_193792 3.14179
R11-317-102 n1_65594_193792 n1_88090_193792 4.0171399999999995
R11-317-103 n1_88090_193792 n1_110282_193792 3.96286
R11-317-104 n1_110282_193792 n1_132778_193792 4.0171399999999995
R11-317-105 n1_132778_193792 n1_154970_193792 3.96286
R11-317-106 n1_154970_193792 n1_177466_193792 4.0171399999999995
R11-317-107 n1_177466_193792 n1_199658_193792 3.96286
R11-317-108 n1_199658_193792 n1_221850_193792 3.96286
R11-317-109 n1_221850_193792 n1_244346_193792 4.0171399999999995
R11-317-110 n1_244346_193792 n1_266538_193792 3.96286
R11-317-111 n1_266538_193792 n1_289034_193792 4.0171399999999995
R11-317-112 n1_289034_193792 n1_311226_193792 3.96286
R11-317-113 n1_311226_193792 n1_333722_193792 4.0171399999999995
R11-317-114 n1_333722_193792 n1_355914_193792 3.96286
R11-317-115 n1_355914_193792 n1_378410_193792 4.0171399999999995
R11-317-116 n1_378410_193792 n1_400602_193792 3.96286
R11-317-117 n1_400602_193792 n1_422794_193792 3.96286
R11-317-118 n1_422794_193792 n1_445290_193792 4.0171399999999995
R11-317-119 n1_445290_193792 n1_467482_193792 3.96286
R11-317-120 n1_467482_193792 n1_489978_193792 4.0171399999999995
R11-317-121 n1_489978_193792 n1_512170_193792 3.96286
R11-317-122 n1_512170_193792 n1_534666_193792 4.0171399999999995
R11-317-123 n1_534666_193792 n1_556858_193792 3.96286
R11-317-124 n1_556858_193792 n1_579050_193792 3.96286
R11-317-125 n1_579050_193792 n1_601546_193792 4.0171399999999995
R11-317-126 n1_601546_193792 n1_623064_193792 3.8425
R11-317-127 n1_623064_193792 n1_625064_193792 0.357143
R11-318-100 n1_623064_193792 n1_625064_193792 0.333333
R11-318-101 n1_625064_193792 n1_627064_193792 0.357143
R11-319-100 n1_625064_193792 n1_627064_193792 0.333333
R11-320-100 n1_44000_197136 n1_46000_197136 0.333333
R11-321-100 n1_44000_197136 n1_46000_197136 0.357143
R11-321-101 n1_46000_197136 n1_48000_197136 0.333333
R11-322-100 n1_46000_197136 n1_48000_197136 0.357143
R11-322-101 n1_48000_197136 n1_65594_197136 3.14179
R11-322-102 n1_65594_197136 n1_88090_197136 4.0171399999999995
R11-322-103 n1_88090_197136 n1_110282_197136 3.96286
R11-322-104 n1_110282_197136 n1_132778_197136 4.0171399999999995
R11-322-105 n1_132778_197136 n1_154970_197136 3.96286
R11-322-106 n1_154970_197136 n1_177466_197136 4.0171399999999995
R11-322-107 n1_177466_197136 n1_199658_197136 3.96286
R11-322-108 n1_199658_197136 n1_221850_197136 3.96286
R11-322-109 n1_221850_197136 n1_244346_197136 4.0171399999999995
R11-322-110 n1_244346_197136 n1_266538_197136 3.96286
R11-322-111 n1_266538_197136 n1_289034_197136 4.0171399999999995
R11-322-112 n1_289034_197136 n1_311226_197136 3.96286
R11-322-113 n1_311226_197136 n1_333722_197136 4.0171399999999995
R11-322-114 n1_333722_197136 n1_355914_197136 3.96286
R11-322-115 n1_355914_197136 n1_378410_197136 4.0171399999999995
R11-322-116 n1_378410_197136 n1_400602_197136 3.96286
R11-322-117 n1_400602_197136 n1_422794_197136 3.96286
R11-322-118 n1_422794_197136 n1_445290_197136 4.0171399999999995
R11-322-119 n1_445290_197136 n1_467482_197136 3.96286
R11-322-120 n1_467482_197136 n1_489978_197136 4.0171399999999995
R11-322-121 n1_489978_197136 n1_512170_197136 3.96286
R11-322-122 n1_512170_197136 n1_534666_197136 4.0171399999999995
R11-322-123 n1_534666_197136 n1_556858_197136 3.96286
R11-322-124 n1_556858_197136 n1_579050_197136 3.96286
R11-322-125 n1_579050_197136 n1_601546_197136 4.0171399999999995
R11-322-126 n1_601546_197136 n1_623064_197136 3.8425
R11-322-127 n1_623064_197136 n1_625064_197136 0.357143
R11-323-100 n1_623064_197136 n1_625064_197136 0.333333
R11-323-101 n1_625064_197136 n1_627064_197136 0.357143
R11-324-100 n1_625064_197136 n1_627064_197136 0.333333
R11-325-100 n1_44000_200480 n1_46000_200480 0.333333
R11-326-100 n1_44000_200480 n1_46000_200480 0.357143
R11-326-101 n1_46000_200480 n1_48000_200480 0.333333
R11-327-100 n1_46000_200480 n1_48000_200480 0.357143
R11-327-101 n1_48000_200480 n1_65594_200480 3.14179
R11-327-102 n1_65594_200480 n1_88090_200480 4.0171399999999995
R11-327-103 n1_88090_200480 n1_110282_200480 3.96286
R11-327-104 n1_110282_200480 n1_132778_200480 4.0171399999999995
R11-327-105 n1_132778_200480 n1_154970_200480 3.96286
R11-327-106 n1_154970_200480 n1_177466_200480 4.0171399999999995
R11-327-107 n1_177466_200480 n1_199658_200480 3.96286
R11-327-108 n1_199658_200480 n1_221850_200480 3.96286
R11-327-109 n1_221850_200480 n1_244346_200480 4.0171399999999995
R11-327-110 n1_244346_200480 n1_266538_200480 3.96286
R11-327-111 n1_266538_200480 n1_289034_200480 4.0171399999999995
R11-327-112 n1_289034_200480 n1_311226_200480 3.96286
R11-327-113 n1_311226_200480 n1_333722_200480 4.0171399999999995
R11-327-114 n1_333722_200480 n1_355914_200480 3.96286
R11-327-115 n1_355914_200480 n1_378410_200480 4.0171399999999995
R11-327-116 n1_378410_200480 n1_400602_200480 3.96286
R11-327-117 n1_400602_200480 n1_422794_200480 3.96286
R11-327-118 n1_422794_200480 n1_445290_200480 4.0171399999999995
R11-327-119 n1_445290_200480 n1_467482_200480 3.96286
R11-327-120 n1_467482_200480 n1_489978_200480 4.0171399999999995
R11-327-121 n1_489978_200480 n1_512170_200480 3.96286
R11-327-122 n1_512170_200480 n1_534666_200480 4.0171399999999995
R11-327-123 n1_534666_200480 n1_556858_200480 3.96286
R11-327-124 n1_556858_200480 n1_579050_200480 3.96286
R11-327-125 n1_579050_200480 n1_601546_200480 4.0171399999999995
R11-327-126 n1_601546_200480 n1_623064_200480 3.8425
R11-327-127 n1_623064_200480 n1_625064_200480 0.357143
R11-328-100 n1_623064_200480 n1_625064_200480 0.333333
R11-328-101 n1_625064_200480 n1_627064_200480 0.357143
R11-329-100 n1_625064_200480 n1_627064_200480 0.333333
R11-330-100 n1_44000_203824 n1_46000_203824 0.333333
R11-331-100 n1_44000_203824 n1_46000_203824 0.357143
R11-331-101 n1_46000_203824 n1_48000_203824 0.333333
R11-332-100 n1_46000_203824 n1_48000_203824 0.357143
R11-332-101 n1_48000_203824 n1_65594_203824 3.14179
R11-332-102 n1_65594_203824 n1_88090_203824 4.0171399999999995
R11-332-103 n1_88090_203824 n1_110282_203824 3.96286
R11-332-104 n1_110282_203824 n1_132778_203824 4.0171399999999995
R11-332-105 n1_132778_203824 n1_154970_203824 3.96286
R11-332-106 n1_154970_203824 n1_177466_203824 4.0171399999999995
R11-332-107 n1_177466_203824 n1_199658_203824 3.96286
R11-332-108 n1_199658_203824 n1_221850_203824 3.96286
R11-332-109 n1_221850_203824 n1_244346_203824 4.0171399999999995
R11-332-110 n1_244346_203824 n1_266538_203824 3.96286
R11-332-111 n1_266538_203824 n1_289034_203824 4.0171399999999995
R11-332-112 n1_289034_203824 n1_311226_203824 3.96286
R11-332-113 n1_311226_203824 n1_333722_203824 4.0171399999999995
R11-332-114 n1_333722_203824 n1_355914_203824 3.96286
R11-332-115 n1_355914_203824 n1_378410_203824 4.0171399999999995
R11-332-116 n1_378410_203824 n1_400602_203824 3.96286
R11-332-117 n1_400602_203824 n1_422794_203824 3.96286
R11-332-118 n1_422794_203824 n1_445290_203824 4.0171399999999995
R11-332-119 n1_445290_203824 n1_467482_203824 3.96286
R11-332-120 n1_467482_203824 n1_489978_203824 4.0171399999999995
R11-332-121 n1_489978_203824 n1_512170_203824 3.96286
R11-332-122 n1_512170_203824 n1_534666_203824 4.0171399999999995
R11-332-123 n1_534666_203824 n1_556858_203824 3.96286
R11-332-124 n1_556858_203824 n1_579050_203824 3.96286
R11-332-125 n1_579050_203824 n1_601546_203824 4.0171399999999995
R11-332-126 n1_601546_203824 n1_623064_203824 3.8425
R11-332-127 n1_623064_203824 n1_625064_203824 0.357143
R11-333-100 n1_623064_203824 n1_625064_203824 0.333333
R11-333-101 n1_625064_203824 n1_627064_203824 0.357143
R11-334-100 n1_625064_203824 n1_627064_203824 0.333333
R11-335-100 n1_44000_207168 n1_46000_207168 0.357143
R11-336-100 n1_44000_207168 n1_46000_207168 0.333333
R11-336-101 n1_46000_207168 n1_48000_207168 0.357143
R11-337-100 n1_46000_207168 n1_48000_207168 0.333333
R11-337-101 n1_48000_207168 n1_65594_207168 3.14179
R11-337-102 n1_65594_207168 n1_88090_207168 4.0171399999999995
R11-337-103 n1_88090_207168 n1_110282_207168 3.96286
R11-337-104 n1_110282_207168 n1_132778_207168 4.0171399999999995
R11-337-105 n1_132778_207168 n1_154970_207168 3.96286
R11-337-106 n1_154970_207168 n1_177466_207168 4.0171399999999995
R11-337-107 n1_177466_207168 n1_199658_207168 3.96286
R11-337-108 n1_199658_207168 n1_221850_207168 3.96286
R11-337-109 n1_221850_207168 n1_244346_207168 4.0171399999999995
R11-337-110 n1_244346_207168 n1_266538_207168 3.96286
R11-337-111 n1_266538_207168 n1_289034_207168 4.0171399999999995
R11-337-112 n1_289034_207168 n1_311226_207168 3.96286
R11-337-113 n1_311226_207168 n1_333722_207168 4.0171399999999995
R11-337-114 n1_333722_207168 n1_355914_207168 3.96286
R11-337-115 n1_355914_207168 n1_378410_207168 4.0171399999999995
R11-337-116 n1_378410_207168 n1_400602_207168 3.96286
R11-337-117 n1_400602_207168 n1_422794_207168 3.96286
R11-337-118 n1_422794_207168 n1_445290_207168 4.0171399999999995
R11-337-119 n1_445290_207168 n1_467482_207168 3.96286
R11-337-120 n1_467482_207168 n1_489978_207168 4.0171399999999995
R11-337-121 n1_489978_207168 n1_512170_207168 3.96286
R11-337-122 n1_512170_207168 n1_534666_207168 4.0171399999999995
R11-337-123 n1_534666_207168 n1_556858_207168 3.96286
R11-337-124 n1_556858_207168 n1_579050_207168 3.96286
R11-337-125 n1_579050_207168 n1_601546_207168 4.0171399999999995
R11-337-126 n1_601546_207168 n1_623064_207168 3.8425
R11-337-127 n1_623064_207168 n1_625064_207168 0.357143
R11-338-100 n1_623064_207168 n1_625064_207168 0.333333
R11-338-101 n1_625064_207168 n1_627064_207168 0.357143
R11-339-100 n1_625064_207168 n1_627064_207168 0.333333
R11-340-100 n1_44000_210512 n1_46000_210512 0.357143
R11-341-100 n1_44000_210512 n1_46000_210512 0.333333
R11-341-101 n1_46000_210512 n1_48000_210512 0.357143
R11-342-100 n1_46000_210512 n1_48000_210512 0.333333
R11-342-101 n1_48000_210512 n1_65594_210512 3.14179
R11-342-102 n1_65594_210512 n1_88090_210512 4.0171399999999995
R11-342-103 n1_88090_210512 n1_110282_210512 3.96286
R11-342-104 n1_110282_210512 n1_132778_210512 4.0171399999999995
R11-342-105 n1_132778_210512 n1_154970_210512 3.96286
R11-342-106 n1_154970_210512 n1_177466_210512 4.0171399999999995
R11-342-107 n1_177466_210512 n1_199658_210512 3.96286
R11-342-108 n1_199658_210512 n1_221850_210512 3.96286
R11-342-109 n1_221850_210512 n1_244346_210512 4.0171399999999995
R11-342-110 n1_244346_210512 n1_266538_210512 3.96286
R11-342-111 n1_266538_210512 n1_289034_210512 4.0171399999999995
R11-342-112 n1_289034_210512 n1_311226_210512 3.96286
R11-342-113 n1_311226_210512 n1_333722_210512 4.0171399999999995
R11-342-114 n1_333722_210512 n1_355914_210512 3.96286
R11-342-115 n1_355914_210512 n1_378410_210512 4.0171399999999995
R11-342-116 n1_378410_210512 n1_400602_210512 3.96286
R11-342-117 n1_400602_210512 n1_422794_210512 3.96286
R11-342-118 n1_422794_210512 n1_445290_210512 4.0171399999999995
R11-342-119 n1_445290_210512 n1_467482_210512 3.96286
R11-342-120 n1_467482_210512 n1_489978_210512 4.0171399999999995
R11-342-121 n1_489978_210512 n1_512170_210512 3.96286
R11-342-122 n1_512170_210512 n1_534666_210512 4.0171399999999995
R11-342-123 n1_534666_210512 n1_556858_210512 3.96286
R11-342-124 n1_556858_210512 n1_579050_210512 3.96286
R11-342-125 n1_579050_210512 n1_601546_210512 4.0171399999999995
R11-342-126 n1_601546_210512 n1_623064_210512 3.8425
R11-342-127 n1_623064_210512 n1_625064_210512 0.357143
R11-343-100 n1_623064_210512 n1_625064_210512 0.333333
R11-343-101 n1_625064_210512 n1_627064_210512 0.357143
R11-344-100 n1_625064_210512 n1_627064_210512 0.333333
R11-345-100 n1_44000_213856 n1_46000_213856 0.357143
R11-346-100 n1_44000_213856 n1_46000_213856 0.333333
R11-346-101 n1_46000_213856 n1_48000_213856 0.357143
R11-347-100 n1_46000_213856 n1_48000_213856 0.333333
R11-347-101 n1_48000_213856 n1_65594_213856 3.14179
R11-347-102 n1_65594_213856 n1_88090_213856 4.0171399999999995
R11-347-103 n1_88090_213856 n1_110282_213856 3.96286
R11-347-104 n1_110282_213856 n1_132778_213856 4.0171399999999995
R11-347-105 n1_132778_213856 n1_154970_213856 3.96286
R11-347-106 n1_154970_213856 n1_177466_213856 4.0171399999999995
R11-347-107 n1_177466_213856 n1_199658_213856 3.96286
R11-347-108 n1_199658_213856 n1_221850_213856 3.96286
R11-347-109 n1_221850_213856 n1_244346_213856 4.0171399999999995
R11-347-110 n1_244346_213856 n1_266538_213856 3.96286
R11-347-111 n1_266538_213856 n1_289034_213856 4.0171399999999995
R11-347-112 n1_289034_213856 n1_311226_213856 3.96286
R11-347-113 n1_311226_213856 n1_333722_213856 4.0171399999999995
R11-347-114 n1_333722_213856 n1_355914_213856 3.96286
R11-347-115 n1_355914_213856 n1_378410_213856 4.0171399999999995
R11-347-116 n1_378410_213856 n1_400602_213856 3.96286
R11-347-117 n1_400602_213856 n1_422794_213856 3.96286
R11-347-118 n1_422794_213856 n1_445290_213856 4.0171399999999995
R11-347-119 n1_445290_213856 n1_467482_213856 3.96286
R11-347-120 n1_467482_213856 n1_489978_213856 4.0171399999999995
R11-347-121 n1_489978_213856 n1_512170_213856 3.96286
R11-347-122 n1_512170_213856 n1_534666_213856 4.0171399999999995
R11-347-123 n1_534666_213856 n1_556858_213856 3.96286
R11-347-124 n1_556858_213856 n1_579050_213856 3.96286
R11-347-125 n1_579050_213856 n1_601546_213856 4.0171399999999995
R11-347-126 n1_601546_213856 n1_623064_213856 3.8425
R11-347-127 n1_623064_213856 n1_625064_213856 0.357143
R11-348-100 n1_623064_213856 n1_625064_213856 0.333333
R11-348-101 n1_625064_213856 n1_627064_213856 0.357143
R11-349-100 n1_625064_213856 n1_627064_213856 0.333333
R11-350-100 n1_44000_217200 n1_46000_217200 0.357143
R11-351-100 n1_44000_217200 n1_46000_217200 0.333333
R11-351-101 n1_46000_217200 n1_48000_217200 0.357143
R11-352-100 n1_46000_217200 n1_48000_217200 0.333333
R11-352-101 n1_48000_217200 n1_65594_217200 3.14179
R11-352-102 n1_65594_217200 n1_88090_217200 4.0171399999999995
R11-352-103 n1_88090_217200 n1_110282_217200 3.96286
R11-352-104 n1_110282_217200 n1_132778_217200 4.0171399999999995
R11-352-105 n1_132778_217200 n1_154970_217200 3.96286
R11-352-106 n1_154970_217200 n1_177466_217200 4.0171399999999995
R11-352-107 n1_177466_217200 n1_199658_217200 3.96286
R11-352-108 n1_199658_217200 n1_221850_217200 3.96286
R11-352-109 n1_221850_217200 n1_244346_217200 4.0171399999999995
R11-352-110 n1_244346_217200 n1_266538_217200 3.96286
R11-352-111 n1_266538_217200 n1_289034_217200 4.0171399999999995
R11-352-112 n1_289034_217200 n1_311226_217200 3.96286
R11-352-113 n1_311226_217200 n1_333722_217200 4.0171399999999995
R11-352-114 n1_333722_217200 n1_355914_217200 3.96286
R11-352-115 n1_355914_217200 n1_378410_217200 4.0171399999999995
R11-352-116 n1_378410_217200 n1_400602_217200 3.96286
R11-352-117 n1_400602_217200 n1_422794_217200 3.96286
R11-352-118 n1_422794_217200 n1_445290_217200 4.0171399999999995
R11-352-119 n1_445290_217200 n1_467482_217200 3.96286
R11-352-120 n1_467482_217200 n1_489978_217200 4.0171399999999995
R11-352-121 n1_489978_217200 n1_512170_217200 3.96286
R11-352-122 n1_512170_217200 n1_534666_217200 4.0171399999999995
R11-352-123 n1_534666_217200 n1_556858_217200 3.96286
R11-352-124 n1_556858_217200 n1_579050_217200 3.96286
R11-352-125 n1_579050_217200 n1_601546_217200 4.0171399999999995
R11-352-126 n1_601546_217200 n1_623064_217200 3.8425
R11-352-127 n1_623064_217200 n1_625064_217200 0.357143
R11-353-100 n1_623064_217200 n1_625064_217200 0.333333
R11-353-101 n1_625064_217200 n1_627064_217200 0.357143
R11-354-100 n1_625064_217200 n1_627064_217200 0.333333
R11-355-100 n1_44000_220544 n1_46000_220544 0.357143
R11-356-100 n1_44000_220544 n1_46000_220544 0.333333
R11-356-101 n1_46000_220544 n1_48000_220544 0.357143
R11-357-100 n1_46000_220544 n1_48000_220544 0.333333
R11-357-101 n1_48000_220544 n1_65594_220544 3.14179
R11-357-102 n1_65594_220544 n1_88090_220544 4.0171399999999995
R11-357-103 n1_88090_220544 n1_110282_220544 3.96286
R11-357-104 n1_110282_220544 n1_132778_220544 4.0171399999999995
R11-357-105 n1_132778_220544 n1_154970_220544 3.96286
R11-357-106 n1_154970_220544 n1_177466_220544 4.0171399999999995
R11-357-107 n1_177466_220544 n1_199658_220544 3.96286
R11-357-108 n1_199658_220544 n1_221850_220544 3.96286
R11-357-109 n1_221850_220544 n1_244346_220544 4.0171399999999995
R11-357-110 n1_244346_220544 n1_266538_220544 3.96286
R11-357-111 n1_266538_220544 n1_289034_220544 4.0171399999999995
R11-357-112 n1_289034_220544 n1_311226_220544 3.96286
R11-357-113 n1_311226_220544 n1_333722_220544 4.0171399999999995
R11-357-114 n1_333722_220544 n1_355914_220544 3.96286
R11-357-115 n1_355914_220544 n1_378410_220544 4.0171399999999995
R11-357-116 n1_378410_220544 n1_400602_220544 3.96286
R11-357-117 n1_400602_220544 n1_422794_220544 3.96286
R11-357-118 n1_422794_220544 n1_445290_220544 4.0171399999999995
R11-357-119 n1_445290_220544 n1_467482_220544 3.96286
R11-357-120 n1_467482_220544 n1_489978_220544 4.0171399999999995
R11-357-121 n1_489978_220544 n1_512170_220544 3.96286
R11-357-122 n1_512170_220544 n1_534666_220544 4.0171399999999995
R11-357-123 n1_534666_220544 n1_556858_220544 3.96286
R11-357-124 n1_556858_220544 n1_579050_220544 3.96286
R11-357-125 n1_579050_220544 n1_601546_220544 4.0171399999999995
R11-357-126 n1_601546_220544 n1_623064_220544 3.8425
R11-357-127 n1_623064_220544 n1_625064_220544 0.357143
R11-358-100 n1_623064_220544 n1_625064_220544 0.333333
R11-358-101 n1_625064_220544 n1_627064_220544 0.357143
R11-359-100 n1_625064_220544 n1_627064_220544 0.333333
R11-360-100 n1_44000_223888 n1_46000_223888 0.333333
R11-361-100 n1_44000_223888 n1_46000_223888 0.357143
R11-361-101 n1_46000_223888 n1_48000_223888 0.333333
R11-362-100 n1_46000_223888 n1_48000_223888 0.357143
R11-362-101 n1_48000_223888 n1_65594_223888 3.14179
R11-362-102 n1_65594_223888 n1_88090_223888 4.0171399999999995
R11-362-103 n1_88090_223888 n1_110282_223888 3.96286
R11-362-104 n1_110282_223888 n1_132778_223888 4.0171399999999995
R11-362-105 n1_132778_223888 n1_154970_223888 3.96286
R11-362-106 n1_154970_223888 n1_177466_223888 4.0171399999999995
R11-362-107 n1_177466_223888 n1_199658_223888 3.96286
R11-362-108 n1_199658_223888 n1_221850_223888 3.96286
R11-362-109 n1_221850_223888 n1_244346_223888 4.0171399999999995
R11-362-110 n1_244346_223888 n1_266538_223888 3.96286
R11-362-111 n1_266538_223888 n1_289034_223888 4.0171399999999995
R11-362-112 n1_289034_223888 n1_311226_223888 3.96286
R11-362-113 n1_311226_223888 n1_333722_223888 4.0171399999999995
R11-362-114 n1_333722_223888 n1_355914_223888 3.96286
R11-362-115 n1_355914_223888 n1_378410_223888 4.0171399999999995
R11-362-116 n1_378410_223888 n1_400602_223888 3.96286
R11-362-117 n1_400602_223888 n1_422794_223888 3.96286
R11-362-118 n1_422794_223888 n1_445290_223888 4.0171399999999995
R11-362-119 n1_445290_223888 n1_467482_223888 3.96286
R11-362-120 n1_467482_223888 n1_489978_223888 4.0171399999999995
R11-362-121 n1_489978_223888 n1_512170_223888 3.96286
R11-362-122 n1_512170_223888 n1_534666_223888 4.0171399999999995
R11-362-123 n1_534666_223888 n1_556858_223888 3.96286
R11-362-124 n1_556858_223888 n1_579050_223888 3.96286
R11-362-125 n1_579050_223888 n1_601546_223888 4.0171399999999995
R11-362-126 n1_601546_223888 n1_623064_223888 3.8425
R11-362-127 n1_623064_223888 n1_625064_223888 0.357143
R11-363-100 n1_623064_223888 n1_625064_223888 0.333333
R11-363-101 n1_625064_223888 n1_627064_223888 0.357143
R11-364-100 n1_625064_223888 n1_627064_223888 0.333333
R11-365-100 n1_44000_227232 n1_46000_227232 0.333333
R11-366-100 n1_44000_227232 n1_46000_227232 0.357143
R11-366-101 n1_46000_227232 n1_48000_227232 0.333333
R11-367-100 n1_46000_227232 n1_48000_227232 0.357143
R11-367-101 n1_48000_227232 n1_65594_227232 3.14179
R11-367-102 n1_65594_227232 n1_88090_227232 4.0171399999999995
R11-367-103 n1_88090_227232 n1_110282_227232 3.96286
R11-367-104 n1_110282_227232 n1_132778_227232 4.0171399999999995
R11-367-105 n1_132778_227232 n1_154970_227232 3.96286
R11-367-106 n1_154970_227232 n1_177466_227232 4.0171399999999995
R11-367-107 n1_177466_227232 n1_199658_227232 3.96286
R11-367-108 n1_199658_227232 n1_221850_227232 3.96286
R11-367-109 n1_221850_227232 n1_244346_227232 4.0171399999999995
R11-367-110 n1_244346_227232 n1_266538_227232 3.96286
R11-367-111 n1_266538_227232 n1_289034_227232 4.0171399999999995
R11-367-112 n1_289034_227232 n1_311226_227232 3.96286
R11-367-113 n1_311226_227232 n1_333722_227232 4.0171399999999995
R11-367-114 n1_333722_227232 n1_355914_227232 3.96286
R11-367-115 n1_355914_227232 n1_378410_227232 4.0171399999999995
R11-367-116 n1_378410_227232 n1_400602_227232 3.96286
R11-367-117 n1_400602_227232 n1_422794_227232 3.96286
R11-367-118 n1_422794_227232 n1_445290_227232 4.0171399999999995
R11-367-119 n1_445290_227232 n1_467482_227232 3.96286
R11-367-120 n1_467482_227232 n1_489978_227232 4.0171399999999995
R11-367-121 n1_489978_227232 n1_512170_227232 3.96286
R11-367-122 n1_512170_227232 n1_534666_227232 4.0171399999999995
R11-367-123 n1_534666_227232 n1_556858_227232 3.96286
R11-367-124 n1_556858_227232 n1_579050_227232 3.96286
R11-367-125 n1_579050_227232 n1_601546_227232 4.0171399999999995
R11-367-126 n1_601546_227232 n1_623064_227232 3.8425
R11-367-127 n1_623064_227232 n1_625064_227232 0.357143
R11-368-100 n1_623064_227232 n1_625064_227232 0.333333
R11-368-101 n1_625064_227232 n1_627064_227232 0.357143
R11-369-100 n1_625064_227232 n1_627064_227232 0.333333
R11-370-100 n1_44000_230576 n1_46000_230576 0.333333
R11-371-100 n1_44000_230576 n1_46000_230576 0.357143
R11-371-101 n1_46000_230576 n1_48000_230576 0.333333
R11-372-100 n1_46000_230576 n1_48000_230576 0.357143
R11-372-101 n1_48000_230576 n1_65594_230576 3.14179
R11-372-102 n1_65594_230576 n1_88090_230576 4.0171399999999995
R11-372-103 n1_88090_230576 n1_110282_230576 3.96286
R11-372-104 n1_110282_230576 n1_132778_230576 4.0171399999999995
R11-372-105 n1_132778_230576 n1_154970_230576 3.96286
R11-372-106 n1_154970_230576 n1_177466_230576 4.0171399999999995
R11-372-107 n1_177466_230576 n1_199658_230576 3.96286
R11-372-108 n1_199658_230576 n1_221850_230576 3.96286
R11-372-109 n1_221850_230576 n1_244346_230576 4.0171399999999995
R11-372-110 n1_244346_230576 n1_266538_230576 3.96286
R11-372-111 n1_266538_230576 n1_289034_230576 4.0171399999999995
R11-372-112 n1_289034_230576 n1_311226_230576 3.96286
R11-372-113 n1_311226_230576 n1_333722_230576 4.0171399999999995
R11-372-114 n1_333722_230576 n1_355914_230576 3.96286
R11-372-115 n1_355914_230576 n1_378410_230576 4.0171399999999995
R11-372-116 n1_378410_230576 n1_400602_230576 3.96286
R11-372-117 n1_400602_230576 n1_422794_230576 3.96286
R11-372-118 n1_422794_230576 n1_445290_230576 4.0171399999999995
R11-372-119 n1_445290_230576 n1_467482_230576 3.96286
R11-372-120 n1_467482_230576 n1_489978_230576 4.0171399999999995
R11-372-121 n1_489978_230576 n1_512170_230576 3.96286
R11-372-122 n1_512170_230576 n1_534666_230576 4.0171399999999995
R11-372-123 n1_534666_230576 n1_556858_230576 3.96286
R11-372-124 n1_556858_230576 n1_579050_230576 3.96286
R11-372-125 n1_579050_230576 n1_601546_230576 4.0171399999999995
R11-372-126 n1_601546_230576 n1_623064_230576 3.8425
R11-372-127 n1_623064_230576 n1_625064_230576 0.357143
R11-373-100 n1_623064_230576 n1_625064_230576 0.333333
R11-373-101 n1_625064_230576 n1_627064_230576 0.357143
R11-374-100 n1_625064_230576 n1_627064_230576 0.333333
R11-375-100 n1_44000_233920 n1_46000_233920 0.333333
R11-376-100 n1_44000_233920 n1_46000_233920 0.357143
R11-376-101 n1_46000_233920 n1_48000_233920 0.333333
R11-377-100 n1_46000_233920 n1_48000_233920 0.357143
R11-377-101 n1_48000_233920 n1_65594_233920 3.14179
R11-377-102 n1_65594_233920 n1_88090_233920 4.0171399999999995
R11-377-103 n1_88090_233920 n1_110282_233920 3.96286
R11-377-104 n1_110282_233920 n1_132778_233920 4.0171399999999995
R11-377-105 n1_132778_233920 n1_154970_233920 3.96286
R11-377-106 n1_154970_233920 n1_177466_233920 4.0171399999999995
R11-377-107 n1_177466_233920 n1_199658_233920 3.96286
R11-377-108 n1_199658_233920 n1_221850_233920 3.96286
R11-377-109 n1_221850_233920 n1_244346_233920 4.0171399999999995
R11-377-110 n1_244346_233920 n1_266538_233920 3.96286
R11-377-111 n1_266538_233920 n1_289034_233920 4.0171399999999995
R11-377-112 n1_289034_233920 n1_311226_233920 3.96286
R11-377-113 n1_311226_233920 n1_333722_233920 4.0171399999999995
R11-377-114 n1_333722_233920 n1_355914_233920 3.96286
R11-377-115 n1_355914_233920 n1_378410_233920 4.0171399999999995
R11-377-116 n1_378410_233920 n1_400602_233920 3.96286
R11-377-117 n1_400602_233920 n1_422794_233920 3.96286
R11-377-118 n1_422794_233920 n1_445290_233920 4.0171399999999995
R11-377-119 n1_445290_233920 n1_467482_233920 3.96286
R11-377-120 n1_467482_233920 n1_489978_233920 4.0171399999999995
R11-377-121 n1_489978_233920 n1_512170_233920 3.96286
R11-377-122 n1_512170_233920 n1_534666_233920 4.0171399999999995
R11-377-123 n1_534666_233920 n1_556858_233920 3.96286
R11-377-124 n1_556858_233920 n1_579050_233920 3.96286
R11-377-125 n1_579050_233920 n1_601546_233920 4.0171399999999995
R11-377-126 n1_601546_233920 n1_623064_233920 3.8425
R11-377-127 n1_623064_233920 n1_625064_233920 0.357143
R11-378-100 n1_623064_233920 n1_625064_233920 0.333333
R11-378-101 n1_625064_233920 n1_627064_233920 0.357143
R11-379-100 n1_625064_233920 n1_627064_233920 0.333333
R11-380-100 n1_44000_237264 n1_46000_237264 0.333333
R11-381-100 n1_44000_237264 n1_46000_237264 0.357143
R11-381-101 n1_46000_237264 n1_48000_237264 0.333333
R11-382-100 n1_46000_237264 n1_48000_237264 0.357143
R11-382-101 n1_48000_237264 n1_65594_237264 3.14179
R11-382-102 n1_65594_237264 n1_88090_237264 4.0171399999999995
R11-382-103 n1_88090_237264 n1_110282_237264 3.96286
R11-382-104 n1_110282_237264 n1_132778_237264 4.0171399999999995
R11-382-105 n1_132778_237264 n1_154970_237264 3.96286
R11-382-106 n1_154970_237264 n1_177466_237264 4.0171399999999995
R11-382-107 n1_177466_237264 n1_199658_237264 3.96286
R11-382-108 n1_199658_237264 n1_221850_237264 3.96286
R11-382-109 n1_221850_237264 n1_244346_237264 4.0171399999999995
R11-382-110 n1_244346_237264 n1_266538_237264 3.96286
R11-382-111 n1_266538_237264 n1_289034_237264 4.0171399999999995
R11-382-112 n1_289034_237264 n1_311226_237264 3.96286
R11-382-113 n1_311226_237264 n1_333722_237264 4.0171399999999995
R11-382-114 n1_333722_237264 n1_355914_237264 3.96286
R11-382-115 n1_355914_237264 n1_378410_237264 4.0171399999999995
R11-382-116 n1_378410_237264 n1_400602_237264 3.96286
R11-382-117 n1_400602_237264 n1_422794_237264 3.96286
R11-382-118 n1_422794_237264 n1_445290_237264 4.0171399999999995
R11-382-119 n1_445290_237264 n1_467482_237264 3.96286
R11-382-120 n1_467482_237264 n1_489978_237264 4.0171399999999995
R11-382-121 n1_489978_237264 n1_512170_237264 3.96286
R11-382-122 n1_512170_237264 n1_534666_237264 4.0171399999999995
R11-382-123 n1_534666_237264 n1_556858_237264 3.96286
R11-382-124 n1_556858_237264 n1_579050_237264 3.96286
R11-382-125 n1_579050_237264 n1_601546_237264 4.0171399999999995
R11-382-126 n1_601546_237264 n1_623064_237264 3.8425
R11-382-127 n1_623064_237264 n1_625064_237264 0.357143
R11-383-100 n1_623064_237264 n1_625064_237264 0.333333
R11-383-101 n1_625064_237264 n1_627064_237264 0.357143
R11-384-100 n1_625064_237264 n1_627064_237264 0.333333
R11-385-100 n1_44000_240608 n1_46000_240608 0.333333
R11-386-100 n1_44000_240608 n1_46000_240608 0.357143
R11-386-101 n1_46000_240608 n1_48000_240608 0.333333
R11-387-100 n1_46000_240608 n1_48000_240608 0.357143
R11-387-101 n1_48000_240608 n1_65594_240608 3.14179
R11-387-102 n1_65594_240608 n1_88090_240608 4.0171399999999995
R11-387-103 n1_88090_240608 n1_110282_240608 3.96286
R11-387-104 n1_110282_240608 n1_132778_240608 4.0171399999999995
R11-387-105 n1_132778_240608 n1_154970_240608 3.96286
R11-387-106 n1_154970_240608 n1_177466_240608 4.0171399999999995
R11-387-107 n1_177466_240608 n1_199658_240608 3.96286
R11-387-108 n1_199658_240608 n1_221850_240608 3.96286
R11-387-109 n1_221850_240608 n1_244346_240608 4.0171399999999995
R11-387-110 n1_244346_240608 n1_266538_240608 3.96286
R11-387-111 n1_266538_240608 n1_289034_240608 4.0171399999999995
R11-387-112 n1_289034_240608 n1_311226_240608 3.96286
R11-387-113 n1_311226_240608 n1_333722_240608 4.0171399999999995
R11-387-114 n1_333722_240608 n1_355914_240608 3.96286
R11-387-115 n1_355914_240608 n1_378410_240608 4.0171399999999995
R11-387-116 n1_378410_240608 n1_400602_240608 3.96286
R11-387-117 n1_400602_240608 n1_422794_240608 3.96286
R11-387-118 n1_422794_240608 n1_445290_240608 4.0171399999999995
R11-387-119 n1_445290_240608 n1_467482_240608 3.96286
R11-387-120 n1_467482_240608 n1_489978_240608 4.0171399999999995
R11-387-121 n1_489978_240608 n1_512170_240608 3.96286
R11-387-122 n1_512170_240608 n1_534666_240608 4.0171399999999995
R11-387-123 n1_534666_240608 n1_556858_240608 3.96286
R11-387-124 n1_556858_240608 n1_579050_240608 3.96286
R11-387-125 n1_579050_240608 n1_601546_240608 4.0171399999999995
R11-387-126 n1_601546_240608 n1_623064_240608 3.8425
R11-387-127 n1_623064_240608 n1_625064_240608 0.357143
R11-388-100 n1_623064_240608 n1_625064_240608 0.333333
R11-388-101 n1_625064_240608 n1_627064_240608 0.357143
R11-389-100 n1_625064_240608 n1_627064_240608 0.333333
R11-390-100 n1_44000_243952 n1_46000_243952 0.357143
R11-391-100 n1_44000_243952 n1_46000_243952 0.333333
R11-391-101 n1_46000_243952 n1_48000_243952 0.357143
R11-392-100 n1_46000_243952 n1_48000_243952 0.333333
R11-392-101 n1_48000_243952 n1_65594_243952 3.14179
R11-392-102 n1_65594_243952 n1_88090_243952 4.0171399999999995
R11-392-103 n1_88090_243952 n1_110282_243952 3.96286
R11-392-104 n1_110282_243952 n1_132778_243952 4.0171399999999995
R11-392-105 n1_132778_243952 n1_154970_243952 3.96286
R11-392-106 n1_154970_243952 n1_177466_243952 4.0171399999999995
R11-392-107 n1_177466_243952 n1_199658_243952 3.96286
R11-392-108 n1_199658_243952 n1_221850_243952 3.96286
R11-392-109 n1_221850_243952 n1_244346_243952 4.0171399999999995
R11-392-110 n1_244346_243952 n1_266538_243952 3.96286
R11-392-111 n1_266538_243952 n1_289034_243952 4.0171399999999995
R11-392-112 n1_289034_243952 n1_311226_243952 3.96286
R11-392-113 n1_311226_243952 n1_333722_243952 4.0171399999999995
R11-392-114 n1_333722_243952 n1_355914_243952 3.96286
R11-392-115 n1_355914_243952 n1_378410_243952 4.0171399999999995
R11-392-116 n1_378410_243952 n1_400602_243952 3.96286
R11-392-117 n1_400602_243952 n1_422794_243952 3.96286
R11-392-118 n1_422794_243952 n1_445290_243952 4.0171399999999995
R11-392-119 n1_445290_243952 n1_467482_243952 3.96286
R11-392-120 n1_467482_243952 n1_489978_243952 4.0171399999999995
R11-392-121 n1_489978_243952 n1_512170_243952 3.96286
R11-392-122 n1_512170_243952 n1_534666_243952 4.0171399999999995
R11-392-123 n1_534666_243952 n1_556858_243952 3.96286
R11-392-124 n1_556858_243952 n1_579050_243952 3.96286
R11-392-125 n1_579050_243952 n1_601546_243952 4.0171399999999995
R11-392-126 n1_601546_243952 n1_623064_243952 3.8425
R11-392-127 n1_623064_243952 n1_625064_243952 0.357143
R11-393-100 n1_623064_243952 n1_625064_243952 0.333333
R11-393-101 n1_625064_243952 n1_627064_243952 0.357143
R11-394-100 n1_625064_243952 n1_627064_243952 0.333333
R11-395-100 n1_44000_247296 n1_46000_247296 0.357143
R11-396-100 n1_44000_247296 n1_46000_247296 0.333333
R11-396-101 n1_46000_247296 n1_48000_247296 0.357143
R11-397-100 n1_46000_247296 n1_48000_247296 0.333333
R11-397-101 n1_48000_247296 n1_65594_247296 3.14179
R11-397-102 n1_65594_247296 n1_88090_247296 4.0171399999999995
R11-397-103 n1_88090_247296 n1_110282_247296 3.96286
R11-397-104 n1_110282_247296 n1_132778_247296 4.0171399999999995
R11-397-105 n1_132778_247296 n1_154970_247296 3.96286
R11-397-106 n1_154970_247296 n1_177466_247296 4.0171399999999995
R11-397-107 n1_177466_247296 n1_199658_247296 3.96286
R11-397-108 n1_199658_247296 n1_221850_247296 3.96286
R11-397-109 n1_221850_247296 n1_244346_247296 4.0171399999999995
R11-397-110 n1_244346_247296 n1_266538_247296 3.96286
R11-397-111 n1_266538_247296 n1_289034_247296 4.0171399999999995
R11-397-112 n1_289034_247296 n1_311226_247296 3.96286
R11-397-113 n1_311226_247296 n1_333722_247296 4.0171399999999995
R11-397-114 n1_333722_247296 n1_355914_247296 3.96286
R11-397-115 n1_355914_247296 n1_378410_247296 4.0171399999999995
R11-397-116 n1_378410_247296 n1_400602_247296 3.96286
R11-397-117 n1_400602_247296 n1_422794_247296 3.96286
R11-397-118 n1_422794_247296 n1_445290_247296 4.0171399999999995
R11-397-119 n1_445290_247296 n1_467482_247296 3.96286
R11-397-120 n1_467482_247296 n1_489978_247296 4.0171399999999995
R11-397-121 n1_489978_247296 n1_512170_247296 3.96286
R11-397-122 n1_512170_247296 n1_534666_247296 4.0171399999999995
R11-397-123 n1_534666_247296 n1_556858_247296 3.96286
R11-397-124 n1_556858_247296 n1_579050_247296 3.96286
R11-397-125 n1_579050_247296 n1_601546_247296 4.0171399999999995
R11-397-126 n1_601546_247296 n1_623064_247296 3.8425
R11-397-127 n1_623064_247296 n1_625064_247296 0.357143
R11-398-100 n1_623064_247296 n1_625064_247296 0.333333
R11-398-101 n1_625064_247296 n1_627064_247296 0.357143
R11-399-100 n1_625064_247296 n1_627064_247296 0.333333
R11-400-100 n1_44000_250640 n1_46000_250640 0.357143
R11-401-100 n1_44000_250640 n1_46000_250640 0.333333
R11-401-101 n1_46000_250640 n1_48000_250640 0.357143
R11-402-100 n1_46000_250640 n1_48000_250640 0.333333
R11-402-101 n1_48000_250640 n1_65594_250640 3.14179
R11-402-102 n1_65594_250640 n1_88090_250640 4.0171399999999995
R11-402-103 n1_88090_250640 n1_110282_250640 3.96286
R11-402-104 n1_110282_250640 n1_132778_250640 4.0171399999999995
R11-402-105 n1_132778_250640 n1_154970_250640 3.96286
R11-402-106 n1_154970_250640 n1_177466_250640 4.0171399999999995
R11-402-107 n1_177466_250640 n1_199658_250640 3.96286
R11-402-108 n1_199658_250640 n1_221850_250640 3.96286
R11-402-109 n1_221850_250640 n1_244346_250640 4.0171399999999995
R11-402-110 n1_244346_250640 n1_266538_250640 3.96286
R11-402-111 n1_266538_250640 n1_289034_250640 4.0171399999999995
R11-402-112 n1_289034_250640 n1_311226_250640 3.96286
R11-402-113 n1_311226_250640 n1_333722_250640 4.0171399999999995
R11-402-114 n1_333722_250640 n1_355914_250640 3.96286
R11-402-115 n1_355914_250640 n1_378410_250640 4.0171399999999995
R11-402-116 n1_378410_250640 n1_400602_250640 3.96286
R11-402-117 n1_400602_250640 n1_422794_250640 3.96286
R11-402-118 n1_422794_250640 n1_445290_250640 4.0171399999999995
R11-402-119 n1_445290_250640 n1_467482_250640 3.96286
R11-402-120 n1_467482_250640 n1_489978_250640 4.0171399999999995
R11-402-121 n1_489978_250640 n1_512170_250640 3.96286
R11-402-122 n1_512170_250640 n1_534666_250640 4.0171399999999995
R11-402-123 n1_534666_250640 n1_556858_250640 3.96286
R11-402-124 n1_556858_250640 n1_579050_250640 3.96286
R11-402-125 n1_579050_250640 n1_601546_250640 4.0171399999999995
R11-402-126 n1_601546_250640 n1_623064_250640 3.8425
R11-402-127 n1_623064_250640 n1_625064_250640 0.357143
R11-403-100 n1_623064_250640 n1_625064_250640 0.333333
R11-403-101 n1_625064_250640 n1_627064_250640 0.357143
R11-404-100 n1_625064_250640 n1_627064_250640 0.333333
R11-405-100 n1_44000_253984 n1_46000_253984 0.357143
R11-406-100 n1_44000_253984 n1_46000_253984 0.333333
R11-406-101 n1_46000_253984 n1_48000_253984 0.357143
R11-407-100 n1_46000_253984 n1_48000_253984 0.333333
R11-407-101 n1_48000_253984 n1_65594_253984 3.14179
R11-407-102 n1_65594_253984 n1_88090_253984 4.0171399999999995
R11-407-103 n1_88090_253984 n1_110282_253984 3.96286
R11-407-104 n1_110282_253984 n1_132778_253984 4.0171399999999995
R11-407-105 n1_132778_253984 n1_154970_253984 3.96286
R11-407-106 n1_154970_253984 n1_177466_253984 4.0171399999999995
R11-407-107 n1_177466_253984 n1_199658_253984 3.96286
R11-407-108 n1_199658_253984 n1_221850_253984 3.96286
R11-407-109 n1_221850_253984 n1_244346_253984 4.0171399999999995
R11-407-110 n1_244346_253984 n1_266538_253984 3.96286
R11-407-111 n1_266538_253984 n1_289034_253984 4.0171399999999995
R11-407-112 n1_289034_253984 n1_311226_253984 3.96286
R11-407-113 n1_311226_253984 n1_333722_253984 4.0171399999999995
R11-407-114 n1_333722_253984 n1_355914_253984 3.96286
R11-407-115 n1_355914_253984 n1_378410_253984 4.0171399999999995
R11-407-116 n1_378410_253984 n1_400602_253984 3.96286
R11-407-117 n1_400602_253984 n1_422794_253984 3.96286
R11-407-118 n1_422794_253984 n1_445290_253984 4.0171399999999995
R11-407-119 n1_445290_253984 n1_467482_253984 3.96286
R11-407-120 n1_467482_253984 n1_489978_253984 4.0171399999999995
R11-407-121 n1_489978_253984 n1_512170_253984 3.96286
R11-407-122 n1_512170_253984 n1_534666_253984 4.0171399999999995
R11-407-123 n1_534666_253984 n1_556858_253984 3.96286
R11-407-124 n1_556858_253984 n1_579050_253984 3.96286
R11-407-125 n1_579050_253984 n1_601546_253984 4.0171399999999995
R11-407-126 n1_601546_253984 n1_623064_253984 3.8425
R11-407-127 n1_623064_253984 n1_625064_253984 0.357143
R11-408-100 n1_623064_253984 n1_625064_253984 0.333333
R11-408-101 n1_625064_253984 n1_627064_253984 0.357143
R11-409-100 n1_625064_253984 n1_627064_253984 0.333333
R11-410-100 n1_44000_257328 n1_46000_257328 0.357143
R11-411-100 n1_44000_257328 n1_46000_257328 0.333333
R11-411-101 n1_46000_257328 n1_48000_257328 0.357143
R11-412-100 n1_46000_257328 n1_48000_257328 0.333333
R11-412-101 n1_48000_257328 n1_65594_257328 3.14179
R11-412-102 n1_65594_257328 n1_88090_257328 4.0171399999999995
R11-412-103 n1_88090_257328 n1_110282_257328 3.96286
R11-412-104 n1_110282_257328 n1_132778_257328 4.0171399999999995
R11-412-105 n1_132778_257328 n1_154970_257328 3.96286
R11-412-106 n1_154970_257328 n1_177466_257328 4.0171399999999995
R11-412-107 n1_177466_257328 n1_199658_257328 3.96286
R11-412-108 n1_199658_257328 n1_221850_257328 3.96286
R11-412-109 n1_221850_257328 n1_244346_257328 4.0171399999999995
R11-412-110 n1_244346_257328 n1_266538_257328 3.96286
R11-412-111 n1_266538_257328 n1_289034_257328 4.0171399999999995
R11-412-112 n1_289034_257328 n1_311226_257328 3.96286
R11-412-113 n1_311226_257328 n1_333722_257328 4.0171399999999995
R11-412-114 n1_333722_257328 n1_355914_257328 3.96286
R11-412-115 n1_355914_257328 n1_378410_257328 4.0171399999999995
R11-412-116 n1_378410_257328 n1_400602_257328 3.96286
R11-412-117 n1_400602_257328 n1_422794_257328 3.96286
R11-412-118 n1_422794_257328 n1_445290_257328 4.0171399999999995
R11-412-119 n1_445290_257328 n1_467482_257328 3.96286
R11-412-120 n1_467482_257328 n1_489978_257328 4.0171399999999995
R11-412-121 n1_489978_257328 n1_512170_257328 3.96286
R11-412-122 n1_512170_257328 n1_534666_257328 4.0171399999999995
R11-412-123 n1_534666_257328 n1_556858_257328 3.96286
R11-412-124 n1_556858_257328 n1_579050_257328 3.96286
R11-412-125 n1_579050_257328 n1_601546_257328 4.0171399999999995
R11-412-126 n1_601546_257328 n1_623064_257328 3.8425
R11-412-127 n1_623064_257328 n1_625064_257328 0.357143
R11-413-100 n1_623064_257328 n1_625064_257328 0.333333
R11-413-101 n1_625064_257328 n1_627064_257328 0.357143
R11-414-100 n1_625064_257328 n1_627064_257328 0.333333
R11-415-100 n1_44000_260672 n1_46000_260672 0.333333
R11-416-100 n1_44000_260672 n1_46000_260672 0.357143
R11-416-101 n1_46000_260672 n1_48000_260672 0.333333
R11-417-100 n1_46000_260672 n1_48000_260672 0.357143
R11-417-101 n1_48000_260672 n1_65594_260672 3.14179
R11-417-102 n1_65594_260672 n1_88090_260672 4.0171399999999995
R11-417-103 n1_88090_260672 n1_110282_260672 3.96286
R11-417-104 n1_110282_260672 n1_132778_260672 4.0171399999999995
R11-417-105 n1_132778_260672 n1_154970_260672 3.96286
R11-417-106 n1_154970_260672 n1_177466_260672 4.0171399999999995
R11-417-107 n1_177466_260672 n1_199658_260672 3.96286
R11-417-108 n1_199658_260672 n1_221850_260672 3.96286
R11-417-109 n1_221850_260672 n1_244346_260672 4.0171399999999995
R11-417-110 n1_244346_260672 n1_266538_260672 3.96286
R11-417-111 n1_266538_260672 n1_289034_260672 4.0171399999999995
R11-417-112 n1_289034_260672 n1_311226_260672 3.96286
R11-417-113 n1_311226_260672 n1_333722_260672 4.0171399999999995
R11-417-114 n1_333722_260672 n1_355914_260672 3.96286
R11-417-115 n1_355914_260672 n1_378410_260672 4.0171399999999995
R11-417-116 n1_378410_260672 n1_400602_260672 3.96286
R11-417-117 n1_400602_260672 n1_422794_260672 3.96286
R11-417-118 n1_422794_260672 n1_445290_260672 4.0171399999999995
R11-417-119 n1_445290_260672 n1_467482_260672 3.96286
R11-417-120 n1_467482_260672 n1_489978_260672 4.0171399999999995
R11-417-121 n1_489978_260672 n1_512170_260672 3.96286
R11-417-122 n1_512170_260672 n1_534666_260672 4.0171399999999995
R11-417-123 n1_534666_260672 n1_556858_260672 3.96286
R11-417-124 n1_556858_260672 n1_579050_260672 3.96286
R11-417-125 n1_579050_260672 n1_601546_260672 4.0171399999999995
R11-417-126 n1_601546_260672 n1_623064_260672 3.8425
R11-417-127 n1_623064_260672 n1_625064_260672 0.357143
R11-418-100 n1_623064_260672 n1_625064_260672 0.333333
R11-418-101 n1_625064_260672 n1_627064_260672 0.357143
R11-419-100 n1_625064_260672 n1_627064_260672 0.333333
R11-420-100 n1_44000_264016 n1_46000_264016 0.333333
R11-421-100 n1_44000_264016 n1_46000_264016 0.357143
R11-421-101 n1_46000_264016 n1_48000_264016 0.333333
R11-422-100 n1_46000_264016 n1_48000_264016 0.357143
R11-422-101 n1_48000_264016 n1_65594_264016 3.14179
R11-422-102 n1_65594_264016 n1_88090_264016 4.0171399999999995
R11-422-103 n1_88090_264016 n1_110282_264016 3.96286
R11-422-104 n1_110282_264016 n1_132778_264016 4.0171399999999995
R11-422-105 n1_132778_264016 n1_154970_264016 3.96286
R11-422-106 n1_154970_264016 n1_177466_264016 4.0171399999999995
R11-422-107 n1_177466_264016 n1_199658_264016 3.96286
R11-422-108 n1_199658_264016 n1_221850_264016 3.96286
R11-422-109 n1_221850_264016 n1_244346_264016 4.0171399999999995
R11-422-110 n1_244346_264016 n1_266538_264016 3.96286
R11-422-111 n1_266538_264016 n1_289034_264016 4.0171399999999995
R11-422-112 n1_289034_264016 n1_311226_264016 3.96286
R11-422-113 n1_311226_264016 n1_333722_264016 4.0171399999999995
R11-422-114 n1_333722_264016 n1_355914_264016 3.96286
R11-422-115 n1_355914_264016 n1_378410_264016 4.0171399999999995
R11-422-116 n1_378410_264016 n1_400602_264016 3.96286
R11-422-117 n1_400602_264016 n1_422794_264016 3.96286
R11-422-118 n1_422794_264016 n1_445290_264016 4.0171399999999995
R11-422-119 n1_445290_264016 n1_467482_264016 3.96286
R11-422-120 n1_467482_264016 n1_489978_264016 4.0171399999999995
R11-422-121 n1_489978_264016 n1_512170_264016 3.96286
R11-422-122 n1_512170_264016 n1_534666_264016 4.0171399999999995
R11-422-123 n1_534666_264016 n1_556858_264016 3.96286
R11-422-124 n1_556858_264016 n1_579050_264016 3.96286
R11-422-125 n1_579050_264016 n1_601546_264016 4.0171399999999995
R11-422-126 n1_601546_264016 n1_623064_264016 3.8425
R11-422-127 n1_623064_264016 n1_625064_264016 0.357143
R11-423-100 n1_623064_264016 n1_625064_264016 0.333333
R11-423-101 n1_625064_264016 n1_627064_264016 0.357143
R11-424-100 n1_625064_264016 n1_627064_264016 0.333333
R11-425-100 n1_44000_267360 n1_46000_267360 0.333333
R11-426-100 n1_44000_267360 n1_46000_267360 0.357143
R11-426-101 n1_46000_267360 n1_48000_267360 0.333333
R11-427-100 n1_46000_267360 n1_48000_267360 0.357143
R11-427-101 n1_48000_267360 n1_65594_267360 3.14179
R11-427-102 n1_65594_267360 n1_88090_267360 4.0171399999999995
R11-427-103 n1_88090_267360 n1_110282_267360 3.96286
R11-427-104 n1_110282_267360 n1_132778_267360 4.0171399999999995
R11-427-105 n1_132778_267360 n1_154970_267360 3.96286
R11-427-106 n1_154970_267360 n1_177466_267360 4.0171399999999995
R11-427-107 n1_177466_267360 n1_199658_267360 3.96286
R11-427-108 n1_199658_267360 n1_221850_267360 3.96286
R11-427-109 n1_221850_267360 n1_244346_267360 4.0171399999999995
R11-427-110 n1_244346_267360 n1_266538_267360 3.96286
R11-427-111 n1_266538_267360 n1_289034_267360 4.0171399999999995
R11-427-112 n1_289034_267360 n1_311226_267360 3.96286
R11-427-113 n1_311226_267360 n1_333722_267360 4.0171399999999995
R11-427-114 n1_333722_267360 n1_355914_267360 3.96286
R11-427-115 n1_355914_267360 n1_378410_267360 4.0171399999999995
R11-427-116 n1_378410_267360 n1_400602_267360 3.96286
R11-427-117 n1_400602_267360 n1_422794_267360 3.96286
R11-427-118 n1_422794_267360 n1_445290_267360 4.0171399999999995
R11-427-119 n1_445290_267360 n1_467482_267360 3.96286
R11-427-120 n1_467482_267360 n1_489978_267360 4.0171399999999995
R11-427-121 n1_489978_267360 n1_512170_267360 3.96286
R11-427-122 n1_512170_267360 n1_534666_267360 4.0171399999999995
R11-427-123 n1_534666_267360 n1_556858_267360 3.96286
R11-427-124 n1_556858_267360 n1_579050_267360 3.96286
R11-427-125 n1_579050_267360 n1_601546_267360 4.0171399999999995
R11-427-126 n1_601546_267360 n1_623064_267360 3.8425
R11-427-127 n1_623064_267360 n1_625064_267360 0.357143
R11-428-100 n1_623064_267360 n1_625064_267360 0.333333
R11-428-101 n1_625064_267360 n1_627064_267360 0.357143
R11-429-100 n1_625064_267360 n1_627064_267360 0.333333
R11-430-100 n1_44000_270704 n1_46000_270704 0.333333
R11-431-100 n1_44000_270704 n1_46000_270704 0.357143
R11-431-101 n1_46000_270704 n1_48000_270704 0.333333
R11-432-100 n1_46000_270704 n1_48000_270704 0.357143
R11-432-101 n1_48000_270704 n1_65594_270704 3.14179
R11-432-102 n1_65594_270704 n1_88090_270704 4.0171399999999995
R11-432-103 n1_88090_270704 n1_110282_270704 3.96286
R11-432-104 n1_110282_270704 n1_132778_270704 4.0171399999999995
R11-432-105 n1_132778_270704 n1_154970_270704 3.96286
R11-432-106 n1_154970_270704 n1_177466_270704 4.0171399999999995
R11-432-107 n1_177466_270704 n1_199658_270704 3.96286
R11-432-108 n1_199658_270704 n1_221850_270704 3.96286
R11-432-109 n1_221850_270704 n1_244346_270704 4.0171399999999995
R11-432-110 n1_244346_270704 n1_266538_270704 3.96286
R11-432-111 n1_266538_270704 n1_289034_270704 4.0171399999999995
R11-432-112 n1_289034_270704 n1_311226_270704 3.96286
R11-432-113 n1_311226_270704 n1_333722_270704 4.0171399999999995
R11-432-114 n1_333722_270704 n1_355914_270704 3.96286
R11-432-115 n1_355914_270704 n1_378410_270704 4.0171399999999995
R11-432-116 n1_378410_270704 n1_400602_270704 3.96286
R11-432-117 n1_400602_270704 n1_422794_270704 3.96286
R11-432-118 n1_422794_270704 n1_445290_270704 4.0171399999999995
R11-432-119 n1_445290_270704 n1_467482_270704 3.96286
R11-432-120 n1_467482_270704 n1_489978_270704 4.0171399999999995
R11-432-121 n1_489978_270704 n1_512170_270704 3.96286
R11-432-122 n1_512170_270704 n1_534666_270704 4.0171399999999995
R11-432-123 n1_534666_270704 n1_556858_270704 3.96286
R11-432-124 n1_556858_270704 n1_579050_270704 3.96286
R11-432-125 n1_579050_270704 n1_601546_270704 4.0171399999999995
R11-432-126 n1_601546_270704 n1_623064_270704 3.8425
R11-432-127 n1_623064_270704 n1_625064_270704 0.357143
R11-433-100 n1_623064_270704 n1_625064_270704 0.333333
R11-433-101 n1_625064_270704 n1_627064_270704 0.357143
R11-434-100 n1_625064_270704 n1_627064_270704 0.333333
R11-435-100 n1_44000_274048 n1_46000_274048 0.333333
R11-436-100 n1_44000_274048 n1_46000_274048 0.357143
R11-436-101 n1_46000_274048 n1_48000_274048 0.333333
R11-437-100 n1_46000_274048 n1_48000_274048 0.357143
R11-437-101 n1_48000_274048 n1_65594_274048 3.14179
R11-437-102 n1_65594_274048 n1_88090_274048 4.0171399999999995
R11-437-103 n1_88090_274048 n1_110282_274048 3.96286
R11-437-104 n1_110282_274048 n1_132778_274048 4.0171399999999995
R11-437-105 n1_132778_274048 n1_154970_274048 3.96286
R11-437-106 n1_154970_274048 n1_177466_274048 4.0171399999999995
R11-437-107 n1_177466_274048 n1_199658_274048 3.96286
R11-437-108 n1_199658_274048 n1_221850_274048 3.96286
R11-437-109 n1_221850_274048 n1_244346_274048 4.0171399999999995
R11-437-110 n1_244346_274048 n1_266538_274048 3.96286
R11-437-111 n1_266538_274048 n1_289034_274048 4.0171399999999995
R11-437-112 n1_289034_274048 n1_311226_274048 3.96286
R11-437-113 n1_311226_274048 n1_333722_274048 4.0171399999999995
R11-437-114 n1_333722_274048 n1_355914_274048 3.96286
R11-437-115 n1_355914_274048 n1_378410_274048 4.0171399999999995
R11-437-116 n1_378410_274048 n1_400602_274048 3.96286
R11-437-117 n1_400602_274048 n1_422794_274048 3.96286
R11-437-118 n1_422794_274048 n1_445290_274048 4.0171399999999995
R11-437-119 n1_445290_274048 n1_467482_274048 3.96286
R11-437-120 n1_467482_274048 n1_489978_274048 4.0171399999999995
R11-437-121 n1_489978_274048 n1_512170_274048 3.96286
R11-437-122 n1_512170_274048 n1_534666_274048 4.0171399999999995
R11-437-123 n1_534666_274048 n1_556858_274048 3.96286
R11-437-124 n1_556858_274048 n1_579050_274048 3.96286
R11-437-125 n1_579050_274048 n1_601546_274048 4.0171399999999995
R11-437-126 n1_601546_274048 n1_623064_274048 3.8425
R11-437-127 n1_623064_274048 n1_625064_274048 0.357143
R11-438-100 n1_623064_274048 n1_625064_274048 0.333333
R11-438-101 n1_625064_274048 n1_627064_274048 0.357143
R11-439-100 n1_625064_274048 n1_627064_274048 0.333333
R11-440-100 n1_44000_277392 n1_46000_277392 0.333333
R11-441-100 n1_44000_277392 n1_46000_277392 0.357143
R11-441-101 n1_46000_277392 n1_48000_277392 0.333333
R11-442-100 n1_46000_277392 n1_48000_277392 0.357143
R11-442-101 n1_48000_277392 n1_65594_277392 3.14179
R11-442-102 n1_65594_277392 n1_88090_277392 4.0171399999999995
R11-442-103 n1_88090_277392 n1_110282_277392 3.96286
R11-442-104 n1_110282_277392 n1_132778_277392 4.0171399999999995
R11-442-105 n1_132778_277392 n1_154970_277392 3.96286
R11-442-106 n1_154970_277392 n1_177466_277392 4.0171399999999995
R11-442-107 n1_177466_277392 n1_199658_277392 3.96286
R11-442-108 n1_199658_277392 n1_221850_277392 3.96286
R11-442-109 n1_221850_277392 n1_244346_277392 4.0171399999999995
R11-442-110 n1_244346_277392 n1_266538_277392 3.96286
R11-442-111 n1_266538_277392 n1_289034_277392 4.0171399999999995
R11-442-112 n1_289034_277392 n1_311226_277392 3.96286
R11-442-113 n1_311226_277392 n1_333722_277392 4.0171399999999995
R11-442-114 n1_333722_277392 n1_355914_277392 3.96286
R11-442-115 n1_355914_277392 n1_378410_277392 4.0171399999999995
R11-442-116 n1_378410_277392 n1_400602_277392 3.96286
R11-442-117 n1_400602_277392 n1_422794_277392 3.96286
R11-442-118 n1_422794_277392 n1_445290_277392 4.0171399999999995
R11-442-119 n1_445290_277392 n1_467482_277392 3.96286
R11-442-120 n1_467482_277392 n1_489978_277392 4.0171399999999995
R11-442-121 n1_489978_277392 n1_512170_277392 3.96286
R11-442-122 n1_512170_277392 n1_534666_277392 4.0171399999999995
R11-442-123 n1_534666_277392 n1_556858_277392 3.96286
R11-442-124 n1_556858_277392 n1_579050_277392 3.96286
R11-442-125 n1_579050_277392 n1_601546_277392 4.0171399999999995
R11-442-126 n1_601546_277392 n1_623064_277392 3.8425
R11-442-127 n1_623064_277392 n1_625064_277392 0.357143
R11-443-100 n1_623064_277392 n1_625064_277392 0.333333
R11-443-101 n1_625064_277392 n1_627064_277392 0.357143
R11-444-100 n1_625064_277392 n1_627064_277392 0.333333
R11-445-100 n1_44000_280736 n1_46000_280736 0.333333
R11-446-100 n1_44000_280736 n1_46000_280736 0.357143
R11-446-101 n1_46000_280736 n1_48000_280736 0.333333
R11-447-100 n1_46000_280736 n1_48000_280736 0.357143
R11-447-101 n1_48000_280736 n1_65594_280736 3.14179
R11-447-102 n1_65594_280736 n1_88090_280736 4.0171399999999995
R11-447-103 n1_88090_280736 n1_110282_280736 3.96286
R11-447-104 n1_110282_280736 n1_132778_280736 4.0171399999999995
R11-447-105 n1_132778_280736 n1_154970_280736 3.96286
R11-447-106 n1_154970_280736 n1_177466_280736 4.0171399999999995
R11-447-107 n1_177466_280736 n1_199658_280736 3.96286
R11-447-108 n1_199658_280736 n1_221850_280736 3.96286
R11-447-109 n1_221850_280736 n1_244346_280736 4.0171399999999995
R11-447-110 n1_244346_280736 n1_266538_280736 3.96286
R11-447-111 n1_266538_280736 n1_289034_280736 4.0171399999999995
R11-447-112 n1_289034_280736 n1_311226_280736 3.96286
R11-447-113 n1_311226_280736 n1_333722_280736 4.0171399999999995
R11-447-114 n1_333722_280736 n1_355914_280736 3.96286
R11-447-115 n1_355914_280736 n1_378410_280736 4.0171399999999995
R11-447-116 n1_378410_280736 n1_400602_280736 3.96286
R11-447-117 n1_400602_280736 n1_422794_280736 3.96286
R11-447-118 n1_422794_280736 n1_445290_280736 4.0171399999999995
R11-447-119 n1_445290_280736 n1_467482_280736 3.96286
R11-447-120 n1_467482_280736 n1_489978_280736 4.0171399999999995
R11-447-121 n1_489978_280736 n1_512170_280736 3.96286
R11-447-122 n1_512170_280736 n1_534666_280736 4.0171399999999995
R11-447-123 n1_534666_280736 n1_556858_280736 3.96286
R11-447-124 n1_556858_280736 n1_579050_280736 3.96286
R11-447-125 n1_579050_280736 n1_601546_280736 4.0171399999999995
R11-447-126 n1_601546_280736 n1_623064_280736 3.8425
R11-447-127 n1_623064_280736 n1_625064_280736 0.357143
R11-448-100 n1_623064_280736 n1_625064_280736 0.333333
R11-448-101 n1_625064_280736 n1_627064_280736 0.357143
R11-449-100 n1_625064_280736 n1_627064_280736 0.333333
R11-450-100 n1_44000_284080 n1_46000_284080 0.333333
R11-451-100 n1_44000_284080 n1_46000_284080 0.357143
R11-451-101 n1_46000_284080 n1_48000_284080 0.333333
R11-452-100 n1_46000_284080 n1_48000_284080 0.357143
R11-452-101 n1_48000_284080 n1_65594_284080 3.14179
R11-452-102 n1_65594_284080 n1_88090_284080 4.0171399999999995
R11-452-103 n1_88090_284080 n1_110282_284080 3.96286
R11-452-104 n1_110282_284080 n1_132778_284080 4.0171399999999995
R11-452-105 n1_132778_284080 n1_154970_284080 3.96286
R11-452-106 n1_154970_284080 n1_177466_284080 4.0171399999999995
R11-452-107 n1_177466_284080 n1_199658_284080 3.96286
R11-452-108 n1_199658_284080 n1_221850_284080 3.96286
R11-452-109 n1_221850_284080 n1_244346_284080 4.0171399999999995
R11-452-110 n1_244346_284080 n1_266538_284080 3.96286
R11-452-111 n1_266538_284080 n1_289034_284080 4.0171399999999995
R11-452-112 n1_289034_284080 n1_311226_284080 3.96286
R11-452-113 n1_311226_284080 n1_333722_284080 4.0171399999999995
R11-452-114 n1_333722_284080 n1_355914_284080 3.96286
R11-452-115 n1_355914_284080 n1_378410_284080 4.0171399999999995
R11-452-116 n1_378410_284080 n1_400602_284080 3.96286
R11-452-117 n1_400602_284080 n1_422794_284080 3.96286
R11-452-118 n1_422794_284080 n1_445290_284080 4.0171399999999995
R11-452-119 n1_445290_284080 n1_467482_284080 3.96286
R11-452-120 n1_467482_284080 n1_489978_284080 4.0171399999999995
R11-452-121 n1_489978_284080 n1_512170_284080 3.96286
R11-452-122 n1_512170_284080 n1_534666_284080 4.0171399999999995
R11-452-123 n1_534666_284080 n1_556858_284080 3.96286
R11-452-124 n1_556858_284080 n1_579050_284080 3.96286
R11-452-125 n1_579050_284080 n1_601546_284080 4.0171399999999995
R11-452-126 n1_601546_284080 n1_623064_284080 3.8425
R11-452-127 n1_623064_284080 n1_625064_284080 0.357143
R11-453-100 n1_623064_284080 n1_625064_284080 0.333333
R11-453-101 n1_625064_284080 n1_627064_284080 0.357143
R11-454-100 n1_625064_284080 n1_627064_284080 0.333333
R11-455-100 n1_44000_287424 n1_46000_287424 0.333333
R11-456-100 n1_44000_287424 n1_46000_287424 0.357143
R11-456-101 n1_46000_287424 n1_48000_287424 0.333333
R11-457-100 n1_46000_287424 n1_48000_287424 0.357143
R11-457-101 n1_48000_287424 n1_65594_287424 3.14179
R11-457-102 n1_65594_287424 n1_88090_287424 4.0171399999999995
R11-457-103 n1_88090_287424 n1_110282_287424 3.96286
R11-457-104 n1_110282_287424 n1_132778_287424 4.0171399999999995
R11-457-105 n1_132778_287424 n1_154970_287424 3.96286
R11-457-106 n1_154970_287424 n1_177466_287424 4.0171399999999995
R11-457-107 n1_177466_287424 n1_199658_287424 3.96286
R11-457-108 n1_199658_287424 n1_221850_287424 3.96286
R11-457-109 n1_221850_287424 n1_244346_287424 4.0171399999999995
R11-457-110 n1_244346_287424 n1_266538_287424 3.96286
R11-457-111 n1_266538_287424 n1_289034_287424 4.0171399999999995
R11-457-112 n1_289034_287424 n1_311226_287424 3.96286
R11-457-113 n1_311226_287424 n1_333722_287424 4.0171399999999995
R11-457-114 n1_333722_287424 n1_355914_287424 3.96286
R11-457-115 n1_355914_287424 n1_378410_287424 4.0171399999999995
R11-457-116 n1_378410_287424 n1_400602_287424 3.96286
R11-457-117 n1_400602_287424 n1_422794_287424 3.96286
R11-457-118 n1_422794_287424 n1_445290_287424 4.0171399999999995
R11-457-119 n1_445290_287424 n1_467482_287424 3.96286
R11-457-120 n1_467482_287424 n1_489978_287424 4.0171399999999995
R11-457-121 n1_489978_287424 n1_512170_287424 3.96286
R11-457-122 n1_512170_287424 n1_534666_287424 4.0171399999999995
R11-457-123 n1_534666_287424 n1_556858_287424 3.96286
R11-457-124 n1_556858_287424 n1_579050_287424 3.96286
R11-457-125 n1_579050_287424 n1_601546_287424 4.0171399999999995
R11-457-126 n1_601546_287424 n1_623064_287424 3.8425
R11-457-127 n1_623064_287424 n1_625064_287424 0.357143
R11-458-100 n1_623064_287424 n1_625064_287424 0.333333
R11-458-101 n1_625064_287424 n1_627064_287424 0.357143
R11-459-100 n1_625064_287424 n1_627064_287424 0.333333
R11-460-100 n1_44000_290768 n1_46000_290768 0.333333
R11-461-100 n1_44000_290768 n1_46000_290768 0.357143
R11-461-101 n1_46000_290768 n1_48000_290768 0.333333
R11-462-100 n1_46000_290768 n1_48000_290768 0.357143
R11-462-101 n1_48000_290768 n1_65594_290768 3.14179
R11-462-102 n1_65594_290768 n1_88090_290768 4.0171399999999995
R11-462-103 n1_88090_290768 n1_110282_290768 3.96286
R11-462-104 n1_110282_290768 n1_132778_290768 4.0171399999999995
R11-462-105 n1_132778_290768 n1_154970_290768 3.96286
R11-462-106 n1_154970_290768 n1_177466_290768 4.0171399999999995
R11-462-107 n1_177466_290768 n1_199658_290768 3.96286
R11-462-108 n1_199658_290768 n1_221850_290768 3.96286
R11-462-109 n1_221850_290768 n1_244346_290768 4.0171399999999995
R11-462-110 n1_244346_290768 n1_266538_290768 3.96286
R11-462-111 n1_266538_290768 n1_289034_290768 4.0171399999999995
R11-462-112 n1_289034_290768 n1_311226_290768 3.96286
R11-462-113 n1_311226_290768 n1_333722_290768 4.0171399999999995
R11-462-114 n1_333722_290768 n1_355914_290768 3.96286
R11-462-115 n1_355914_290768 n1_378410_290768 4.0171399999999995
R11-462-116 n1_378410_290768 n1_400602_290768 3.96286
R11-462-117 n1_400602_290768 n1_422794_290768 3.96286
R11-462-118 n1_422794_290768 n1_445290_290768 4.0171399999999995
R11-462-119 n1_445290_290768 n1_467482_290768 3.96286
R11-462-120 n1_467482_290768 n1_489978_290768 4.0171399999999995
R11-462-121 n1_489978_290768 n1_512170_290768 3.96286
R11-462-122 n1_512170_290768 n1_534666_290768 4.0171399999999995
R11-462-123 n1_534666_290768 n1_556858_290768 3.96286
R11-462-124 n1_556858_290768 n1_579050_290768 3.96286
R11-462-125 n1_579050_290768 n1_601546_290768 4.0171399999999995
R11-462-126 n1_601546_290768 n1_623064_290768 3.8425
R11-462-127 n1_623064_290768 n1_625064_290768 0.357143
R11-463-100 n1_623064_290768 n1_625064_290768 0.333333
R11-463-101 n1_625064_290768 n1_627064_290768 0.357143
R11-464-100 n1_625064_290768 n1_627064_290768 0.333333
R11-465-100 n1_44000_294112 n1_46000_294112 0.333333
R11-466-100 n1_44000_294112 n1_46000_294112 0.357143
R11-466-101 n1_46000_294112 n1_48000_294112 0.333333
R11-467-100 n1_46000_294112 n1_48000_294112 0.357143
R11-467-101 n1_48000_294112 n1_65594_294112 3.14179
R11-467-102 n1_65594_294112 n1_88090_294112 4.0171399999999995
R11-467-103 n1_88090_294112 n1_110282_294112 3.96286
R11-467-104 n1_110282_294112 n1_132778_294112 4.0171399999999995
R11-467-105 n1_132778_294112 n1_154970_294112 3.96286
R11-467-106 n1_154970_294112 n1_177466_294112 4.0171399999999995
R11-467-107 n1_177466_294112 n1_199658_294112 3.96286
R11-467-108 n1_199658_294112 n1_221850_294112 3.96286
R11-467-109 n1_221850_294112 n1_244346_294112 4.0171399999999995
R11-467-110 n1_244346_294112 n1_266538_294112 3.96286
R11-467-111 n1_266538_294112 n1_289034_294112 4.0171399999999995
R11-467-112 n1_289034_294112 n1_311226_294112 3.96286
R11-467-113 n1_311226_294112 n1_333722_294112 4.0171399999999995
R11-467-114 n1_333722_294112 n1_355914_294112 3.96286
R11-467-115 n1_355914_294112 n1_378410_294112 4.0171399999999995
R11-467-116 n1_378410_294112 n1_400602_294112 3.96286
R11-467-117 n1_400602_294112 n1_422794_294112 3.96286
R11-467-118 n1_422794_294112 n1_445290_294112 4.0171399999999995
R11-467-119 n1_445290_294112 n1_467482_294112 3.96286
R11-467-120 n1_467482_294112 n1_489978_294112 4.0171399999999995
R11-467-121 n1_489978_294112 n1_512170_294112 3.96286
R11-467-122 n1_512170_294112 n1_534666_294112 4.0171399999999995
R11-467-123 n1_534666_294112 n1_556858_294112 3.96286
R11-467-124 n1_556858_294112 n1_579050_294112 3.96286
R11-467-125 n1_579050_294112 n1_601546_294112 4.0171399999999995
R11-467-126 n1_601546_294112 n1_623064_294112 3.8425
R11-467-127 n1_623064_294112 n1_625064_294112 0.357143
R11-468-100 n1_623064_294112 n1_625064_294112 0.333333
R11-468-101 n1_625064_294112 n1_627064_294112 0.357143
R11-469-100 n1_625064_294112 n1_627064_294112 0.333333
R11-470-100 n1_44000_297456 n1_46000_297456 0.333333
R11-471-100 n1_44000_297456 n1_46000_297456 0.357143
R11-471-101 n1_46000_297456 n1_48000_297456 0.333333
R11-472-100 n1_46000_297456 n1_48000_297456 0.357143
R11-472-101 n1_48000_297456 n1_65594_297456 3.14179
R11-472-102 n1_65594_297456 n1_88090_297456 4.0171399999999995
R11-472-103 n1_88090_297456 n1_110282_297456 3.96286
R11-472-104 n1_110282_297456 n1_132778_297456 4.0171399999999995
R11-472-105 n1_132778_297456 n1_154970_297456 3.96286
R11-472-106 n1_154970_297456 n1_177466_297456 4.0171399999999995
R11-472-107 n1_177466_297456 n1_199658_297456 3.96286
R11-472-108 n1_199658_297456 n1_221850_297456 3.96286
R11-472-109 n1_221850_297456 n1_244346_297456 4.0171399999999995
R11-472-110 n1_244346_297456 n1_266538_297456 3.96286
R11-472-111 n1_266538_297456 n1_289034_297456 4.0171399999999995
R11-472-112 n1_289034_297456 n1_311226_297456 3.96286
R11-472-113 n1_311226_297456 n1_333722_297456 4.0171399999999995
R11-472-114 n1_333722_297456 n1_355914_297456 3.96286
R11-472-115 n1_355914_297456 n1_378410_297456 4.0171399999999995
R11-472-116 n1_378410_297456 n1_400602_297456 3.96286
R11-472-117 n1_400602_297456 n1_422794_297456 3.96286
R11-472-118 n1_422794_297456 n1_445290_297456 4.0171399999999995
R11-472-119 n1_445290_297456 n1_467482_297456 3.96286
R11-472-120 n1_467482_297456 n1_489978_297456 4.0171399999999995
R11-472-121 n1_489978_297456 n1_512170_297456 3.96286
R11-472-122 n1_512170_297456 n1_534666_297456 4.0171399999999995
R11-472-123 n1_534666_297456 n1_556858_297456 3.96286
R11-472-124 n1_556858_297456 n1_579050_297456 3.96286
R11-472-125 n1_579050_297456 n1_601546_297456 4.0171399999999995
R11-472-126 n1_601546_297456 n1_623064_297456 3.8425
R11-472-127 n1_623064_297456 n1_625064_297456 0.357143
R11-473-100 n1_623064_297456 n1_625064_297456 0.333333
R11-473-101 n1_625064_297456 n1_627064_297456 0.357143
R11-474-100 n1_625064_297456 n1_627064_297456 0.333333
R11-475-100 n1_44000_300800 n1_46000_300800 0.333333
R11-476-100 n1_44000_300800 n1_46000_300800 0.357143
R11-476-101 n1_46000_300800 n1_48000_300800 0.333333
R11-477-100 n1_46000_300800 n1_48000_300800 0.357143
R11-477-101 n1_48000_300800 n1_65594_300800 3.14179
R11-477-102 n1_65594_300800 n1_88090_300800 4.0171399999999995
R11-477-103 n1_88090_300800 n1_110282_300800 3.96286
R11-477-104 n1_110282_300800 n1_132778_300800 4.0171399999999995
R11-477-105 n1_132778_300800 n1_154970_300800 3.96286
R11-477-106 n1_154970_300800 n1_177466_300800 4.0171399999999995
R11-477-107 n1_177466_300800 n1_199658_300800 3.96286
R11-477-108 n1_199658_300800 n1_221850_300800 3.96286
R11-477-109 n1_221850_300800 n1_244346_300800 4.0171399999999995
R11-477-110 n1_244346_300800 n1_266538_300800 3.96286
R11-477-111 n1_266538_300800 n1_289034_300800 4.0171399999999995
R11-477-112 n1_289034_300800 n1_311226_300800 3.96286
R11-477-113 n1_311226_300800 n1_333722_300800 4.0171399999999995
R11-477-114 n1_333722_300800 n1_355914_300800 3.96286
R11-477-115 n1_355914_300800 n1_378410_300800 4.0171399999999995
R11-477-116 n1_378410_300800 n1_400602_300800 3.96286
R11-477-117 n1_400602_300800 n1_422794_300800 3.96286
R11-477-118 n1_422794_300800 n1_445290_300800 4.0171399999999995
R11-477-119 n1_445290_300800 n1_467482_300800 3.96286
R11-477-120 n1_467482_300800 n1_489978_300800 4.0171399999999995
R11-477-121 n1_489978_300800 n1_512170_300800 3.96286
R11-477-122 n1_512170_300800 n1_534666_300800 4.0171399999999995
R11-477-123 n1_534666_300800 n1_556858_300800 3.96286
R11-477-124 n1_556858_300800 n1_579050_300800 3.96286
R11-477-125 n1_579050_300800 n1_601546_300800 4.0171399999999995
R11-477-126 n1_601546_300800 n1_623064_300800 3.8425
R11-477-127 n1_623064_300800 n1_625064_300800 0.357143
R11-478-100 n1_623064_300800 n1_625064_300800 0.333333
R11-478-101 n1_625064_300800 n1_627064_300800 0.357143
R11-479-100 n1_625064_300800 n1_627064_300800 0.333333
R11-480-100 n1_44000_304144 n1_46000_304144 0.333333
R11-481-100 n1_44000_304144 n1_46000_304144 0.357143
R11-481-101 n1_46000_304144 n1_48000_304144 0.333333
R11-482-100 n1_46000_304144 n1_48000_304144 0.357143
R11-482-101 n1_48000_304144 n1_65594_304144 3.14179
R11-482-102 n1_65594_304144 n1_88090_304144 4.0171399999999995
R11-482-103 n1_88090_304144 n1_110282_304144 3.96286
R11-482-104 n1_110282_304144 n1_132778_304144 4.0171399999999995
R11-482-105 n1_132778_304144 n1_154970_304144 3.96286
R11-482-106 n1_154970_304144 n1_177466_304144 4.0171399999999995
R11-482-107 n1_177466_304144 n1_199658_304144 3.96286
R11-482-108 n1_199658_304144 n1_221850_304144 3.96286
R11-482-109 n1_221850_304144 n1_244346_304144 4.0171399999999995
R11-482-110 n1_244346_304144 n1_266538_304144 3.96286
R11-482-111 n1_266538_304144 n1_289034_304144 4.0171399999999995
R11-482-112 n1_289034_304144 n1_311226_304144 3.96286
R11-482-113 n1_311226_304144 n1_333722_304144 4.0171399999999995
R11-482-114 n1_333722_304144 n1_355914_304144 3.96286
R11-482-115 n1_355914_304144 n1_378410_304144 4.0171399999999995
R11-482-116 n1_378410_304144 n1_400602_304144 3.96286
R11-482-117 n1_400602_304144 n1_422794_304144 3.96286
R11-482-118 n1_422794_304144 n1_445290_304144 4.0171399999999995
R11-482-119 n1_445290_304144 n1_467482_304144 3.96286
R11-482-120 n1_467482_304144 n1_489978_304144 4.0171399999999995
R11-482-121 n1_489978_304144 n1_512170_304144 3.96286
R11-482-122 n1_512170_304144 n1_534666_304144 4.0171399999999995
R11-482-123 n1_534666_304144 n1_556858_304144 3.96286
R11-482-124 n1_556858_304144 n1_579050_304144 3.96286
R11-482-125 n1_579050_304144 n1_601546_304144 4.0171399999999995
R11-482-126 n1_601546_304144 n1_623064_304144 3.8425
R11-482-127 n1_623064_304144 n1_625064_304144 0.357143
R11-483-100 n1_623064_304144 n1_625064_304144 0.333333
R11-483-101 n1_625064_304144 n1_627064_304144 0.357143
R11-484-100 n1_625064_304144 n1_627064_304144 0.333333
R11-485-100 n1_44000_307488 n1_46000_307488 0.333333
R11-486-100 n1_44000_307488 n1_46000_307488 0.357143
R11-486-101 n1_46000_307488 n1_48000_307488 0.333333
R11-487-100 n1_46000_307488 n1_48000_307488 0.357143
R11-487-101 n1_48000_307488 n1_65594_307488 3.14179
R11-487-102 n1_65594_307488 n1_88090_307488 4.0171399999999995
R11-487-103 n1_88090_307488 n1_110282_307488 3.96286
R11-487-104 n1_110282_307488 n1_132778_307488 4.0171399999999995
R11-487-105 n1_132778_307488 n1_154970_307488 3.96286
R11-487-106 n1_154970_307488 n1_177466_307488 4.0171399999999995
R11-487-107 n1_177466_307488 n1_199658_307488 3.96286
R11-487-108 n1_199658_307488 n1_221850_307488 3.96286
R11-487-109 n1_221850_307488 n1_244346_307488 4.0171399999999995
R11-487-110 n1_244346_307488 n1_266538_307488 3.96286
R11-487-111 n1_266538_307488 n1_289034_307488 4.0171399999999995
R11-487-112 n1_289034_307488 n1_311226_307488 3.96286
R11-487-113 n1_311226_307488 n1_333722_307488 4.0171399999999995
R11-487-114 n1_333722_307488 n1_355914_307488 3.96286
R11-487-115 n1_355914_307488 n1_378410_307488 4.0171399999999995
R11-487-116 n1_378410_307488 n1_400602_307488 3.96286
R11-487-117 n1_400602_307488 n1_422794_307488 3.96286
R11-487-118 n1_422794_307488 n1_445290_307488 4.0171399999999995
R11-487-119 n1_445290_307488 n1_467482_307488 3.96286
R11-487-120 n1_467482_307488 n1_489978_307488 4.0171399999999995
R11-487-121 n1_489978_307488 n1_512170_307488 3.96286
R11-487-122 n1_512170_307488 n1_534666_307488 4.0171399999999995
R11-487-123 n1_534666_307488 n1_556858_307488 3.96286
R11-487-124 n1_556858_307488 n1_579050_307488 3.96286
R11-487-125 n1_579050_307488 n1_601546_307488 4.0171399999999995
R11-487-126 n1_601546_307488 n1_623064_307488 3.8425
R11-487-127 n1_623064_307488 n1_625064_307488 0.357143
R11-488-100 n1_623064_307488 n1_625064_307488 0.333333
R11-488-101 n1_625064_307488 n1_627064_307488 0.357143
R11-489-100 n1_625064_307488 n1_627064_307488 0.333333
R11-490-100 n1_44000_310832 n1_46000_310832 0.333333
R11-491-100 n1_44000_310832 n1_46000_310832 0.357143
R11-491-101 n1_46000_310832 n1_48000_310832 0.333333
R11-492-100 n1_46000_310832 n1_48000_310832 0.357143
R11-492-101 n1_48000_310832 n1_65594_310832 3.14179
R11-492-102 n1_65594_310832 n1_88090_310832 4.0171399999999995
R11-492-103 n1_88090_310832 n1_110282_310832 3.96286
R11-492-104 n1_110282_310832 n1_132778_310832 4.0171399999999995
R11-492-105 n1_132778_310832 n1_154970_310832 3.96286
R11-492-106 n1_154970_310832 n1_177466_310832 4.0171399999999995
R11-492-107 n1_177466_310832 n1_199658_310832 3.96286
R11-492-108 n1_199658_310832 n1_221850_310832 3.96286
R11-492-109 n1_221850_310832 n1_244346_310832 4.0171399999999995
R11-492-110 n1_244346_310832 n1_266538_310832 3.96286
R11-492-111 n1_266538_310832 n1_289034_310832 4.0171399999999995
R11-492-112 n1_289034_310832 n1_311226_310832 3.96286
R11-492-113 n1_311226_310832 n1_333722_310832 4.0171399999999995
R11-492-114 n1_333722_310832 n1_355914_310832 3.96286
R11-492-115 n1_355914_310832 n1_378410_310832 4.0171399999999995
R11-492-116 n1_378410_310832 n1_400602_310832 3.96286
R11-492-117 n1_400602_310832 n1_422794_310832 3.96286
R11-492-118 n1_422794_310832 n1_445290_310832 4.0171399999999995
R11-492-119 n1_445290_310832 n1_467482_310832 3.96286
R11-492-120 n1_467482_310832 n1_489978_310832 4.0171399999999995
R11-492-121 n1_489978_310832 n1_512170_310832 3.96286
R11-492-122 n1_512170_310832 n1_534666_310832 4.0171399999999995
R11-492-123 n1_534666_310832 n1_556858_310832 3.96286
R11-492-124 n1_556858_310832 n1_579050_310832 3.96286
R11-492-125 n1_579050_310832 n1_601546_310832 4.0171399999999995
R11-492-126 n1_601546_310832 n1_623064_310832 3.8425
R11-492-127 n1_623064_310832 n1_625064_310832 0.357143
R11-493-100 n1_623064_310832 n1_625064_310832 0.333333
R11-493-101 n1_625064_310832 n1_627064_310832 0.357143
R11-494-100 n1_625064_310832 n1_627064_310832 0.333333
R11-495-100 n1_44000_314176 n1_46000_314176 0.333333
R11-496-100 n1_44000_314176 n1_46000_314176 0.357143
R11-496-101 n1_46000_314176 n1_48000_314176 0.333333
R11-497-100 n1_46000_314176 n1_48000_314176 0.357143
R11-497-101 n1_48000_314176 n1_65594_314176 3.14179
R11-497-102 n1_65594_314176 n1_88090_314176 4.0171399999999995
R11-497-103 n1_88090_314176 n1_110282_314176 3.96286
R11-497-104 n1_110282_314176 n1_132778_314176 4.0171399999999995
R11-497-105 n1_132778_314176 n1_154970_314176 3.96286
R11-497-106 n1_154970_314176 n1_177466_314176 4.0171399999999995
R11-497-107 n1_177466_314176 n1_199658_314176 3.96286
R11-497-108 n1_199658_314176 n1_221850_314176 3.96286
R11-497-109 n1_221850_314176 n1_244346_314176 4.0171399999999995
R11-497-110 n1_244346_314176 n1_266538_314176 3.96286
R11-497-111 n1_266538_314176 n1_289034_314176 4.0171399999999995
R11-497-112 n1_289034_314176 n1_311226_314176 3.96286
R11-497-113 n1_311226_314176 n1_333722_314176 4.0171399999999995
R11-497-114 n1_333722_314176 n1_355914_314176 3.96286
R11-497-115 n1_355914_314176 n1_378410_314176 4.0171399999999995
R11-497-116 n1_378410_314176 n1_400602_314176 3.96286
R11-497-117 n1_400602_314176 n1_422794_314176 3.96286
R11-497-118 n1_422794_314176 n1_445290_314176 4.0171399999999995
R11-497-119 n1_445290_314176 n1_467482_314176 3.96286
R11-497-120 n1_467482_314176 n1_489978_314176 4.0171399999999995
R11-497-121 n1_489978_314176 n1_512170_314176 3.96286
R11-497-122 n1_512170_314176 n1_534666_314176 4.0171399999999995
R11-497-123 n1_534666_314176 n1_556858_314176 3.96286
R11-497-124 n1_556858_314176 n1_579050_314176 3.96286
R11-497-125 n1_579050_314176 n1_601546_314176 4.0171399999999995
R11-497-126 n1_601546_314176 n1_623064_314176 3.8425
R11-497-127 n1_623064_314176 n1_625064_314176 0.357143
R11-498-100 n1_623064_314176 n1_625064_314176 0.333333
R11-498-101 n1_625064_314176 n1_627064_314176 0.357143
R11-499-100 n1_625064_314176 n1_627064_314176 0.333333
R11-500-100 n1_44000_317520 n1_46000_317520 0.357143
R11-501-100 n1_44000_317520 n1_46000_317520 0.333333
R11-501-101 n1_46000_317520 n1_48000_317520 0.357143
R11-502-100 n1_46000_317520 n1_48000_317520 0.333333
R11-502-101 n1_48000_317520 n1_65594_317520 3.14179
R11-502-102 n1_65594_317520 n1_88090_317520 4.0171399999999995
R11-502-103 n1_88090_317520 n1_110282_317520 3.96286
R11-502-104 n1_110282_317520 n1_132778_317520 4.0171399999999995
R11-502-105 n1_132778_317520 n1_154970_317520 3.96286
R11-502-106 n1_154970_317520 n1_177466_317520 4.0171399999999995
R11-502-107 n1_177466_317520 n1_199658_317520 3.96286
R11-502-108 n1_199658_317520 n1_221850_317520 3.96286
R11-502-109 n1_221850_317520 n1_244346_317520 4.0171399999999995
R11-502-110 n1_244346_317520 n1_266538_317520 3.96286
R11-502-111 n1_266538_317520 n1_289034_317520 4.0171399999999995
R11-502-112 n1_289034_317520 n1_311226_317520 3.96286
R11-502-113 n1_311226_317520 n1_333722_317520 4.0171399999999995
R11-502-114 n1_333722_317520 n1_355914_317520 3.96286
R11-502-115 n1_355914_317520 n1_378410_317520 4.0171399999999995
R11-502-116 n1_378410_317520 n1_400602_317520 3.96286
R11-502-117 n1_400602_317520 n1_422794_317520 3.96286
R11-502-118 n1_422794_317520 n1_445290_317520 4.0171399999999995
R11-502-119 n1_445290_317520 n1_467482_317520 3.96286
R11-502-120 n1_467482_317520 n1_489978_317520 4.0171399999999995
R11-502-121 n1_489978_317520 n1_512170_317520 3.96286
R11-502-122 n1_512170_317520 n1_534666_317520 4.0171399999999995
R11-502-123 n1_534666_317520 n1_556858_317520 3.96286
R11-502-124 n1_556858_317520 n1_579050_317520 3.96286
R11-502-125 n1_579050_317520 n1_601546_317520 4.0171399999999995
R11-502-126 n1_601546_317520 n1_623064_317520 3.8425
R11-502-127 n1_623064_317520 n1_625064_317520 0.357143
R11-503-100 n1_623064_317520 n1_625064_317520 0.333333
R11-503-101 n1_625064_317520 n1_627064_317520 0.357143
R11-504-100 n1_625064_317520 n1_627064_317520 0.333333
R11-505-100 n1_44000_320864 n1_46000_320864 0.357143
R11-506-100 n1_44000_320864 n1_46000_320864 0.333333
R11-506-101 n1_46000_320864 n1_48000_320864 0.357143
R11-507-100 n1_46000_320864 n1_48000_320864 0.333333
R11-507-101 n1_48000_320864 n1_65594_320864 3.14179
R11-507-102 n1_65594_320864 n1_88090_320864 4.0171399999999995
R11-507-103 n1_88090_320864 n1_110282_320864 3.96286
R11-507-104 n1_110282_320864 n1_132778_320864 4.0171399999999995
R11-507-105 n1_132778_320864 n1_154970_320864 3.96286
R11-507-106 n1_154970_320864 n1_177466_320864 4.0171399999999995
R11-507-107 n1_177466_320864 n1_199658_320864 3.96286
R11-507-108 n1_199658_320864 n1_221850_320864 3.96286
R11-507-109 n1_221850_320864 n1_244346_320864 4.0171399999999995
R11-507-110 n1_244346_320864 n1_266538_320864 3.96286
R11-507-111 n1_266538_320864 n1_289034_320864 4.0171399999999995
R11-507-112 n1_289034_320864 n1_311226_320864 3.96286
R11-507-113 n1_311226_320864 n1_333722_320864 4.0171399999999995
R11-507-114 n1_333722_320864 n1_355914_320864 3.96286
R11-507-115 n1_355914_320864 n1_378410_320864 4.0171399999999995
R11-507-116 n1_378410_320864 n1_400602_320864 3.96286
R11-507-117 n1_400602_320864 n1_422794_320864 3.96286
R11-507-118 n1_422794_320864 n1_445290_320864 4.0171399999999995
R11-507-119 n1_445290_320864 n1_467482_320864 3.96286
R11-507-120 n1_467482_320864 n1_489978_320864 4.0171399999999995
R11-507-121 n1_489978_320864 n1_512170_320864 3.96286
R11-507-122 n1_512170_320864 n1_534666_320864 4.0171399999999995
R11-507-123 n1_534666_320864 n1_556858_320864 3.96286
R11-507-124 n1_556858_320864 n1_579050_320864 3.96286
R11-507-125 n1_579050_320864 n1_601546_320864 4.0171399999999995
R11-507-126 n1_601546_320864 n1_623064_320864 3.8425
R11-507-127 n1_623064_320864 n1_625064_320864 0.357143
R11-508-100 n1_623064_320864 n1_625064_320864 0.333333
R11-508-101 n1_625064_320864 n1_627064_320864 0.357143
R11-509-100 n1_625064_320864 n1_627064_320864 0.333333
R11-510-100 n1_44000_324208 n1_46000_324208 0.357143
R11-511-100 n1_44000_324208 n1_46000_324208 0.333333
R11-511-101 n1_46000_324208 n1_48000_324208 0.357143
R11-512-100 n1_46000_324208 n1_48000_324208 0.333333
R11-512-101 n1_48000_324208 n1_65594_324208 3.14179
R11-512-102 n1_65594_324208 n1_88090_324208 4.0171399999999995
R11-512-103 n1_88090_324208 n1_110282_324208 3.96286
R11-512-104 n1_110282_324208 n1_132778_324208 4.0171399999999995
R11-512-105 n1_132778_324208 n1_154970_324208 3.96286
R11-512-106 n1_154970_324208 n1_177466_324208 4.0171399999999995
R11-512-107 n1_177466_324208 n1_199658_324208 3.96286
R11-512-108 n1_199658_324208 n1_221850_324208 3.96286
R11-512-109 n1_221850_324208 n1_244346_324208 4.0171399999999995
R11-512-110 n1_244346_324208 n1_266538_324208 3.96286
R11-512-111 n1_266538_324208 n1_289034_324208 4.0171399999999995
R11-512-112 n1_289034_324208 n1_311226_324208 3.96286
R11-512-113 n1_311226_324208 n1_333722_324208 4.0171399999999995
R11-512-114 n1_333722_324208 n1_355914_324208 3.96286
R11-512-115 n1_355914_324208 n1_378410_324208 4.0171399999999995
R11-512-116 n1_378410_324208 n1_400602_324208 3.96286
R11-512-117 n1_400602_324208 n1_422794_324208 3.96286
R11-512-118 n1_422794_324208 n1_445290_324208 4.0171399999999995
R11-512-119 n1_445290_324208 n1_467482_324208 3.96286
R11-512-120 n1_467482_324208 n1_489978_324208 4.0171399999999995
R11-512-121 n1_489978_324208 n1_512170_324208 3.96286
R11-512-122 n1_512170_324208 n1_534666_324208 4.0171399999999995
R11-512-123 n1_534666_324208 n1_556858_324208 3.96286
R11-512-124 n1_556858_324208 n1_579050_324208 3.96286
R11-512-125 n1_579050_324208 n1_601546_324208 4.0171399999999995
R11-512-126 n1_601546_324208 n1_623064_324208 3.8425
R11-512-127 n1_623064_324208 n1_625064_324208 0.357143
R11-513-100 n1_623064_324208 n1_625064_324208 0.333333
R11-513-101 n1_625064_324208 n1_627064_324208 0.357143
R11-514-100 n1_625064_324208 n1_627064_324208 0.333333
R11-515-100 n1_44000_327552 n1_46000_327552 0.357143
R11-516-100 n1_44000_327552 n1_46000_327552 0.333333
R11-516-101 n1_46000_327552 n1_48000_327552 0.357143
R11-517-100 n1_46000_327552 n1_48000_327552 0.333333
R11-517-101 n1_48000_327552 n1_65594_327552 3.14179
R11-517-102 n1_65594_327552 n1_88090_327552 4.0171399999999995
R11-517-103 n1_88090_327552 n1_110282_327552 3.96286
R11-517-104 n1_110282_327552 n1_132778_327552 4.0171399999999995
R11-517-105 n1_132778_327552 n1_154970_327552 3.96286
R11-517-106 n1_154970_327552 n1_177466_327552 4.0171399999999995
R11-517-107 n1_177466_327552 n1_199658_327552 3.96286
R11-517-108 n1_199658_327552 n1_221850_327552 3.96286
R11-517-109 n1_221850_327552 n1_244346_327552 4.0171399999999995
R11-517-110 n1_244346_327552 n1_266538_327552 3.96286
R11-517-111 n1_266538_327552 n1_289034_327552 4.0171399999999995
R11-517-112 n1_289034_327552 n1_311226_327552 3.96286
R11-517-113 n1_311226_327552 n1_333722_327552 4.0171399999999995
R11-517-114 n1_333722_327552 n1_355914_327552 3.96286
R11-517-115 n1_355914_327552 n1_378410_327552 4.0171399999999995
R11-517-116 n1_378410_327552 n1_400602_327552 3.96286
R11-517-117 n1_400602_327552 n1_422794_327552 3.96286
R11-517-118 n1_422794_327552 n1_445290_327552 4.0171399999999995
R11-517-119 n1_445290_327552 n1_467482_327552 3.96286
R11-517-120 n1_467482_327552 n1_489978_327552 4.0171399999999995
R11-517-121 n1_489978_327552 n1_512170_327552 3.96286
R11-517-122 n1_512170_327552 n1_534666_327552 4.0171399999999995
R11-517-123 n1_534666_327552 n1_556858_327552 3.96286
R11-517-124 n1_556858_327552 n1_579050_327552 3.96286
R11-517-125 n1_579050_327552 n1_601546_327552 4.0171399999999995
R11-517-126 n1_601546_327552 n1_623064_327552 3.8425
R11-517-127 n1_623064_327552 n1_625064_327552 0.357143
R11-518-100 n1_623064_327552 n1_625064_327552 0.333333
R11-518-101 n1_625064_327552 n1_627064_327552 0.357143
R11-519-100 n1_625064_327552 n1_627064_327552 0.333333
R11-520-100 n1_44000_330896 n1_46000_330896 0.357143
R11-521-100 n1_44000_330896 n1_46000_330896 0.333333
R11-521-101 n1_46000_330896 n1_48000_330896 0.357143
R11-522-100 n1_46000_330896 n1_48000_330896 0.333333
R11-522-101 n1_48000_330896 n1_65594_330896 3.14179
R11-522-102 n1_65594_330896 n1_88090_330896 4.0171399999999995
R11-522-103 n1_88090_330896 n1_110282_330896 3.96286
R11-522-104 n1_110282_330896 n1_132778_330896 4.0171399999999995
R11-522-105 n1_132778_330896 n1_154970_330896 3.96286
R11-522-106 n1_154970_330896 n1_177466_330896 4.0171399999999995
R11-522-107 n1_177466_330896 n1_199658_330896 3.96286
R11-522-108 n1_199658_330896 n1_221850_330896 3.96286
R11-522-109 n1_221850_330896 n1_244346_330896 4.0171399999999995
R11-522-110 n1_244346_330896 n1_266538_330896 3.96286
R11-522-111 n1_266538_330896 n1_289034_330896 4.0171399999999995
R11-522-112 n1_289034_330896 n1_311226_330896 3.96286
R11-522-113 n1_311226_330896 n1_333722_330896 4.0171399999999995
R11-522-114 n1_333722_330896 n1_355914_330896 3.96286
R11-522-115 n1_355914_330896 n1_378410_330896 4.0171399999999995
R11-522-116 n1_378410_330896 n1_400602_330896 3.96286
R11-522-117 n1_400602_330896 n1_422794_330896 3.96286
R11-522-118 n1_422794_330896 n1_445290_330896 4.0171399999999995
R11-522-119 n1_445290_330896 n1_467482_330896 3.96286
R11-522-120 n1_467482_330896 n1_489978_330896 4.0171399999999995
R11-522-121 n1_489978_330896 n1_512170_330896 3.96286
R11-522-122 n1_512170_330896 n1_534666_330896 4.0171399999999995
R11-522-123 n1_534666_330896 n1_556858_330896 3.96286
R11-522-124 n1_556858_330896 n1_579050_330896 3.96286
R11-522-125 n1_579050_330896 n1_601546_330896 4.0171399999999995
R11-522-126 n1_601546_330896 n1_623064_330896 3.8425
R11-522-127 n1_623064_330896 n1_625064_330896 0.357143
R11-523-100 n1_623064_330896 n1_625064_330896 0.333333
R11-523-101 n1_625064_330896 n1_627064_330896 0.357143
R11-524-100 n1_625064_330896 n1_627064_330896 0.333333
R11-525-100 n1_44000_334240 n1_46000_334240 0.333333
R11-526-100 n1_44000_334240 n1_46000_334240 0.357143
R11-526-101 n1_46000_334240 n1_48000_334240 0.333333
R11-527-100 n1_46000_334240 n1_48000_334240 0.357143
R11-527-101 n1_48000_334240 n1_65594_334240 3.14179
R11-527-102 n1_65594_334240 n1_88090_334240 4.0171399999999995
R11-527-103 n1_88090_334240 n1_110282_334240 3.96286
R11-527-104 n1_110282_334240 n1_132778_334240 4.0171399999999995
R11-527-105 n1_132778_334240 n1_154970_334240 3.96286
R11-527-106 n1_154970_334240 n1_177466_334240 4.0171399999999995
R11-527-107 n1_177466_334240 n1_199658_334240 3.96286
R11-527-108 n1_199658_334240 n1_221850_334240 3.96286
R11-527-109 n1_221850_334240 n1_244346_334240 4.0171399999999995
R11-527-110 n1_244346_334240 n1_266538_334240 3.96286
R11-527-111 n1_266538_334240 n1_289034_334240 4.0171399999999995
R11-527-112 n1_289034_334240 n1_311226_334240 3.96286
R11-527-113 n1_311226_334240 n1_333722_334240 4.0171399999999995
R11-527-114 n1_333722_334240 n1_355914_334240 3.96286
R11-527-115 n1_355914_334240 n1_378410_334240 4.0171399999999995
R11-527-116 n1_378410_334240 n1_400602_334240 3.96286
R11-527-117 n1_400602_334240 n1_422794_334240 3.96286
R11-527-118 n1_422794_334240 n1_445290_334240 4.0171399999999995
R11-527-119 n1_445290_334240 n1_467482_334240 3.96286
R11-527-120 n1_467482_334240 n1_489978_334240 4.0171399999999995
R11-527-121 n1_489978_334240 n1_512170_334240 3.96286
R11-527-122 n1_512170_334240 n1_534666_334240 4.0171399999999995
R11-527-123 n1_534666_334240 n1_556858_334240 3.96286
R11-527-124 n1_556858_334240 n1_579050_334240 3.96286
R11-527-125 n1_579050_334240 n1_601546_334240 4.0171399999999995
R11-527-126 n1_601546_334240 n1_623064_334240 3.8425
R11-527-127 n1_623064_334240 n1_625064_334240 0.357143
R11-528-100 n1_623064_334240 n1_625064_334240 0.333333
R11-528-101 n1_625064_334240 n1_627064_334240 0.357143
R11-529-100 n1_625064_334240 n1_627064_334240 0.333333
R11-530-100 n1_44000_337584 n1_46000_337584 0.333333
R11-531-100 n1_44000_337584 n1_46000_337584 0.357143
R11-531-101 n1_46000_337584 n1_48000_337584 0.333333
R11-532-100 n1_46000_337584 n1_48000_337584 0.357143
R11-532-101 n1_48000_337584 n1_65594_337584 3.14179
R11-532-102 n1_65594_337584 n1_88090_337584 4.0171399999999995
R11-532-103 n1_88090_337584 n1_110282_337584 3.96286
R11-532-104 n1_110282_337584 n1_132778_337584 4.0171399999999995
R11-532-105 n1_132778_337584 n1_154970_337584 3.96286
R11-532-106 n1_154970_337584 n1_177466_337584 4.0171399999999995
R11-532-107 n1_177466_337584 n1_199658_337584 3.96286
R11-532-108 n1_199658_337584 n1_221850_337584 3.96286
R11-532-109 n1_221850_337584 n1_244346_337584 4.0171399999999995
R11-532-110 n1_244346_337584 n1_266538_337584 3.96286
R11-532-111 n1_266538_337584 n1_289034_337584 4.0171399999999995
R11-532-112 n1_289034_337584 n1_311226_337584 3.96286
R11-532-113 n1_311226_337584 n1_333722_337584 4.0171399999999995
R11-532-114 n1_333722_337584 n1_355914_337584 3.96286
R11-532-115 n1_355914_337584 n1_378410_337584 4.0171399999999995
R11-532-116 n1_378410_337584 n1_400602_337584 3.96286
R11-532-117 n1_400602_337584 n1_422794_337584 3.96286
R11-532-118 n1_422794_337584 n1_445290_337584 4.0171399999999995
R11-532-119 n1_445290_337584 n1_467482_337584 3.96286
R11-532-120 n1_467482_337584 n1_489978_337584 4.0171399999999995
R11-532-121 n1_489978_337584 n1_512170_337584 3.96286
R11-532-122 n1_512170_337584 n1_534666_337584 4.0171399999999995
R11-532-123 n1_534666_337584 n1_556858_337584 3.96286
R11-532-124 n1_556858_337584 n1_579050_337584 3.96286
R11-532-125 n1_579050_337584 n1_601546_337584 4.0171399999999995
R11-532-126 n1_601546_337584 n1_623064_337584 3.8425
R11-532-127 n1_623064_337584 n1_625064_337584 0.357143
R11-533-100 n1_623064_337584 n1_625064_337584 0.333333
R11-533-101 n1_625064_337584 n1_627064_337584 0.357143
R11-534-100 n1_625064_337584 n1_627064_337584 0.333333
R11-535-100 n1_44000_340928 n1_46000_340928 0.333333
R11-536-100 n1_44000_340928 n1_46000_340928 0.357143
R11-536-101 n1_46000_340928 n1_48000_340928 0.333333
R11-537-100 n1_46000_340928 n1_48000_340928 0.357143
R11-537-101 n1_48000_340928 n1_65594_340928 3.14179
R11-537-102 n1_65594_340928 n1_88090_340928 4.0171399999999995
R11-537-103 n1_88090_340928 n1_110282_340928 3.96286
R11-537-104 n1_110282_340928 n1_132778_340928 4.0171399999999995
R11-537-105 n1_132778_340928 n1_154970_340928 3.96286
R11-537-106 n1_154970_340928 n1_177466_340928 4.0171399999999995
R11-537-107 n1_177466_340928 n1_199658_340928 3.96286
R11-537-108 n1_199658_340928 n1_221850_340928 3.96286
R11-537-109 n1_221850_340928 n1_244346_340928 4.0171399999999995
R11-537-110 n1_244346_340928 n1_266538_340928 3.96286
R11-537-111 n1_266538_340928 n1_289034_340928 4.0171399999999995
R11-537-112 n1_289034_340928 n1_311226_340928 3.96286
R11-537-113 n1_311226_340928 n1_333722_340928 4.0171399999999995
R11-537-114 n1_333722_340928 n1_355914_340928 3.96286
R11-537-115 n1_355914_340928 n1_378410_340928 4.0171399999999995
R11-537-116 n1_378410_340928 n1_400602_340928 3.96286
R11-537-117 n1_400602_340928 n1_422794_340928 3.96286
R11-537-118 n1_422794_340928 n1_445290_340928 4.0171399999999995
R11-537-119 n1_445290_340928 n1_467482_340928 3.96286
R11-537-120 n1_467482_340928 n1_489978_340928 4.0171399999999995
R11-537-121 n1_489978_340928 n1_512170_340928 3.96286
R11-537-122 n1_512170_340928 n1_534666_340928 4.0171399999999995
R11-537-123 n1_534666_340928 n1_556858_340928 3.96286
R11-537-124 n1_556858_340928 n1_579050_340928 3.96286
R11-537-125 n1_579050_340928 n1_601546_340928 4.0171399999999995
R11-537-126 n1_601546_340928 n1_623064_340928 3.8425
R11-537-127 n1_623064_340928 n1_625064_340928 0.357143
R11-538-100 n1_623064_340928 n1_625064_340928 0.333333
R11-538-101 n1_625064_340928 n1_627064_340928 0.357143
R11-539-100 n1_625064_340928 n1_627064_340928 0.333333
R11-540-100 n1_44000_344272 n1_46000_344272 0.333333
R11-541-100 n1_44000_344272 n1_46000_344272 0.357143
R11-541-101 n1_46000_344272 n1_48000_344272 0.333333
R11-542-100 n1_46000_344272 n1_48000_344272 0.357143
R11-542-101 n1_48000_344272 n1_65594_344272 3.14179
R11-542-102 n1_65594_344272 n1_88090_344272 4.0171399999999995
R11-542-103 n1_88090_344272 n1_110282_344272 3.96286
R11-542-104 n1_110282_344272 n1_132778_344272 4.0171399999999995
R11-542-105 n1_132778_344272 n1_154970_344272 3.96286
R11-542-106 n1_154970_344272 n1_177466_344272 4.0171399999999995
R11-542-107 n1_177466_344272 n1_199658_344272 3.96286
R11-542-108 n1_199658_344272 n1_221850_344272 3.96286
R11-542-109 n1_221850_344272 n1_244346_344272 4.0171399999999995
R11-542-110 n1_244346_344272 n1_266538_344272 3.96286
R11-542-111 n1_266538_344272 n1_289034_344272 4.0171399999999995
R11-542-112 n1_289034_344272 n1_311226_344272 3.96286
R11-542-113 n1_311226_344272 n1_333722_344272 4.0171399999999995
R11-542-114 n1_333722_344272 n1_355914_344272 3.96286
R11-542-115 n1_355914_344272 n1_378410_344272 4.0171399999999995
R11-542-116 n1_378410_344272 n1_400602_344272 3.96286
R11-542-117 n1_400602_344272 n1_422794_344272 3.96286
R11-542-118 n1_422794_344272 n1_445290_344272 4.0171399999999995
R11-542-119 n1_445290_344272 n1_467482_344272 3.96286
R11-542-120 n1_467482_344272 n1_489978_344272 4.0171399999999995
R11-542-121 n1_489978_344272 n1_512170_344272 3.96286
R11-542-122 n1_512170_344272 n1_534666_344272 4.0171399999999995
R11-542-123 n1_534666_344272 n1_556858_344272 3.96286
R11-542-124 n1_556858_344272 n1_579050_344272 3.96286
R11-542-125 n1_579050_344272 n1_601546_344272 4.0171399999999995
R11-542-126 n1_601546_344272 n1_623064_344272 3.8425
R11-542-127 n1_623064_344272 n1_625064_344272 0.357143
R11-543-100 n1_623064_344272 n1_625064_344272 0.333333
R11-543-101 n1_625064_344272 n1_627064_344272 0.357143
R11-544-100 n1_625064_344272 n1_627064_344272 0.333333
R11-545-100 n1_44000_347616 n1_46000_347616 0.333333
R11-546-100 n1_44000_347616 n1_46000_347616 0.357143
R11-546-101 n1_46000_347616 n1_48000_347616 0.333333
R11-547-100 n1_46000_347616 n1_48000_347616 0.357143
R11-547-101 n1_48000_347616 n1_65594_347616 3.14179
R11-547-102 n1_65594_347616 n1_88090_347616 4.0171399999999995
R11-547-103 n1_88090_347616 n1_110282_347616 3.96286
R11-547-104 n1_110282_347616 n1_132778_347616 4.0171399999999995
R11-547-105 n1_132778_347616 n1_154970_347616 3.96286
R11-547-106 n1_154970_347616 n1_177466_347616 4.0171399999999995
R11-547-107 n1_177466_347616 n1_199658_347616 3.96286
R11-547-108 n1_199658_347616 n1_221850_347616 3.96286
R11-547-109 n1_221850_347616 n1_244346_347616 4.0171399999999995
R11-547-110 n1_244346_347616 n1_266538_347616 3.96286
R11-547-111 n1_266538_347616 n1_289034_347616 4.0171399999999995
R11-547-112 n1_289034_347616 n1_311226_347616 3.96286
R11-547-113 n1_311226_347616 n1_333722_347616 4.0171399999999995
R11-547-114 n1_333722_347616 n1_355914_347616 3.96286
R11-547-115 n1_355914_347616 n1_378410_347616 4.0171399999999995
R11-547-116 n1_378410_347616 n1_400602_347616 3.96286
R11-547-117 n1_400602_347616 n1_422794_347616 3.96286
R11-547-118 n1_422794_347616 n1_445290_347616 4.0171399999999995
R11-547-119 n1_445290_347616 n1_467482_347616 3.96286
R11-547-120 n1_467482_347616 n1_489978_347616 4.0171399999999995
R11-547-121 n1_489978_347616 n1_512170_347616 3.96286
R11-547-122 n1_512170_347616 n1_534666_347616 4.0171399999999995
R11-547-123 n1_534666_347616 n1_556858_347616 3.96286
R11-547-124 n1_556858_347616 n1_579050_347616 3.96286
R11-547-125 n1_579050_347616 n1_601546_347616 4.0171399999999995
R11-547-126 n1_601546_347616 n1_623064_347616 3.8425
R11-547-127 n1_623064_347616 n1_625064_347616 0.357143
R11-548-100 n1_623064_347616 n1_625064_347616 0.333333
R11-548-101 n1_625064_347616 n1_627064_347616 0.357143
R11-549-100 n1_625064_347616 n1_627064_347616 0.333333
R11-550-100 n1_44000_350960 n1_46000_350960 0.333333
R11-551-100 n1_44000_350960 n1_46000_350960 0.357143
R11-551-101 n1_46000_350960 n1_48000_350960 0.333333
R11-552-100 n1_46000_350960 n1_48000_350960 0.357143
R11-552-101 n1_48000_350960 n1_65594_350960 3.14179
R11-552-102 n1_65594_350960 n1_88090_350960 4.0171399999999995
R11-552-103 n1_88090_350960 n1_110282_350960 3.96286
R11-552-104 n1_110282_350960 n1_132778_350960 4.0171399999999995
R11-552-105 n1_132778_350960 n1_154970_350960 3.96286
R11-552-106 n1_154970_350960 n1_177466_350960 4.0171399999999995
R11-552-107 n1_177466_350960 n1_199658_350960 3.96286
R11-552-108 n1_199658_350960 n1_221850_350960 3.96286
R11-552-109 n1_221850_350960 n1_244346_350960 4.0171399999999995
R11-552-110 n1_244346_350960 n1_266538_350960 3.96286
R11-552-111 n1_266538_350960 n1_289034_350960 4.0171399999999995
R11-552-112 n1_289034_350960 n1_311226_350960 3.96286
R11-552-113 n1_311226_350960 n1_333722_350960 4.0171399999999995
R11-552-114 n1_333722_350960 n1_355914_350960 3.96286
R11-552-115 n1_355914_350960 n1_378410_350960 4.0171399999999995
R11-552-116 n1_378410_350960 n1_400602_350960 3.96286
R11-552-117 n1_400602_350960 n1_422794_350960 3.96286
R11-552-118 n1_422794_350960 n1_445290_350960 4.0171399999999995
R11-552-119 n1_445290_350960 n1_467482_350960 3.96286
R11-552-120 n1_467482_350960 n1_489978_350960 4.0171399999999995
R11-552-121 n1_489978_350960 n1_512170_350960 3.96286
R11-552-122 n1_512170_350960 n1_534666_350960 4.0171399999999995
R11-552-123 n1_534666_350960 n1_556858_350960 3.96286
R11-552-124 n1_556858_350960 n1_579050_350960 3.96286
R11-552-125 n1_579050_350960 n1_601546_350960 4.0171399999999995
R11-552-126 n1_601546_350960 n1_623064_350960 3.8425
R11-552-127 n1_623064_350960 n1_625064_350960 0.357143
R11-553-100 n1_623064_350960 n1_625064_350960 0.333333
R11-553-101 n1_625064_350960 n1_627064_350960 0.357143
R11-554-100 n1_625064_350960 n1_627064_350960 0.333333
R11-555-100 n1_44000_354304 n1_46000_354304 0.333333
R11-556-100 n1_44000_354304 n1_46000_354304 0.357143
R11-556-101 n1_46000_354304 n1_48000_354304 0.333333
R11-557-100 n1_46000_354304 n1_48000_354304 0.357143
R11-557-101 n1_48000_354304 n1_65594_354304 3.14179
R11-557-102 n1_65594_354304 n1_88090_354304 4.0171399999999995
R11-557-103 n1_88090_354304 n1_110282_354304 3.96286
R11-557-104 n1_110282_354304 n1_132778_354304 4.0171399999999995
R11-557-105 n1_132778_354304 n1_154970_354304 3.96286
R11-557-106 n1_154970_354304 n1_177466_354304 4.0171399999999995
R11-557-107 n1_177466_354304 n1_199658_354304 3.96286
R11-557-108 n1_199658_354304 n1_221850_354304 3.96286
R11-557-109 n1_221850_354304 n1_244346_354304 4.0171399999999995
R11-557-110 n1_244346_354304 n1_266538_354304 3.96286
R11-557-111 n1_266538_354304 n1_289034_354304 4.0171399999999995
R11-557-112 n1_289034_354304 n1_311226_354304 3.96286
R11-557-113 n1_311226_354304 n1_333722_354304 4.0171399999999995
R11-557-114 n1_333722_354304 n1_355914_354304 3.96286
R11-557-115 n1_355914_354304 n1_378410_354304 4.0171399999999995
R11-557-116 n1_378410_354304 n1_400602_354304 3.96286
R11-557-117 n1_400602_354304 n1_422794_354304 3.96286
R11-557-118 n1_422794_354304 n1_445290_354304 4.0171399999999995
R11-557-119 n1_445290_354304 n1_467482_354304 3.96286
R11-557-120 n1_467482_354304 n1_489978_354304 4.0171399999999995
R11-557-121 n1_489978_354304 n1_512170_354304 3.96286
R11-557-122 n1_512170_354304 n1_534666_354304 4.0171399999999995
R11-557-123 n1_534666_354304 n1_556858_354304 3.96286
R11-557-124 n1_556858_354304 n1_579050_354304 3.96286
R11-557-125 n1_579050_354304 n1_601546_354304 4.0171399999999995
R11-557-126 n1_601546_354304 n1_623064_354304 3.8425
R11-557-127 n1_623064_354304 n1_625064_354304 0.357143
R11-558-100 n1_623064_354304 n1_625064_354304 0.333333
R11-558-101 n1_625064_354304 n1_627064_354304 0.357143
R11-559-100 n1_625064_354304 n1_627064_354304 0.333333
R11-560-100 n1_44000_357648 n1_46000_357648 0.333333
R11-561-100 n1_44000_357648 n1_46000_357648 0.357143
R11-561-101 n1_46000_357648 n1_48000_357648 0.333333
R11-562-100 n1_46000_357648 n1_48000_357648 0.357143
R11-562-101 n1_48000_357648 n1_65594_357648 3.14179
R11-562-102 n1_65594_357648 n1_88090_357648 4.0171399999999995
R11-562-103 n1_88090_357648 n1_110282_357648 3.96286
R11-562-104 n1_110282_357648 n1_132778_357648 4.0171399999999995
R11-562-105 n1_132778_357648 n1_154970_357648 3.96286
R11-562-106 n1_154970_357648 n1_177466_357648 4.0171399999999995
R11-562-107 n1_177466_357648 n1_199658_357648 3.96286
R11-562-108 n1_199658_357648 n1_221850_357648 3.96286
R11-562-109 n1_221850_357648 n1_244346_357648 4.0171399999999995
R11-562-110 n1_244346_357648 n1_266538_357648 3.96286
R11-562-111 n1_266538_357648 n1_289034_357648 4.0171399999999995
R11-562-112 n1_289034_357648 n1_311226_357648 3.96286
R11-562-113 n1_311226_357648 n1_333722_357648 4.0171399999999995
R11-562-114 n1_333722_357648 n1_355914_357648 3.96286
R11-562-115 n1_355914_357648 n1_378410_357648 4.0171399999999995
R11-562-116 n1_378410_357648 n1_400602_357648 3.96286
R11-562-117 n1_400602_357648 n1_422794_357648 3.96286
R11-562-118 n1_422794_357648 n1_445290_357648 4.0171399999999995
R11-562-119 n1_445290_357648 n1_467482_357648 3.96286
R11-562-120 n1_467482_357648 n1_489978_357648 4.0171399999999995
R11-562-121 n1_489978_357648 n1_512170_357648 3.96286
R11-562-122 n1_512170_357648 n1_534666_357648 4.0171399999999995
R11-562-123 n1_534666_357648 n1_556858_357648 3.96286
R11-562-124 n1_556858_357648 n1_579050_357648 3.96286
R11-562-125 n1_579050_357648 n1_601546_357648 4.0171399999999995
R11-562-126 n1_601546_357648 n1_623064_357648 3.8425
R11-562-127 n1_623064_357648 n1_625064_357648 0.357143
R11-563-100 n1_623064_357648 n1_625064_357648 0.333333
R11-563-101 n1_625064_357648 n1_627064_357648 0.357143
R11-564-100 n1_625064_357648 n1_627064_357648 0.333333
R11-565-100 n1_44000_360992 n1_46000_360992 0.333333
R11-566-100 n1_44000_360992 n1_46000_360992 0.357143
R11-566-101 n1_46000_360992 n1_48000_360992 0.333333
R11-567-100 n1_46000_360992 n1_48000_360992 0.357143
R11-567-101 n1_48000_360992 n1_65594_360992 3.14179
R11-567-102 n1_65594_360992 n1_88090_360992 4.0171399999999995
R11-567-103 n1_88090_360992 n1_110282_360992 3.96286
R11-567-104 n1_110282_360992 n1_132778_360992 4.0171399999999995
R11-567-105 n1_132778_360992 n1_154970_360992 3.96286
R11-567-106 n1_154970_360992 n1_177466_360992 4.0171399999999995
R11-567-107 n1_177466_360992 n1_199658_360992 3.96286
R11-567-108 n1_199658_360992 n1_221850_360992 3.96286
R11-567-109 n1_221850_360992 n1_244346_360992 4.0171399999999995
R11-567-110 n1_244346_360992 n1_266538_360992 3.96286
R11-567-111 n1_266538_360992 n1_289034_360992 4.0171399999999995
R11-567-112 n1_289034_360992 n1_311226_360992 3.96286
R11-567-113 n1_311226_360992 n1_333722_360992 4.0171399999999995
R11-567-114 n1_333722_360992 n1_355914_360992 3.96286
R11-567-115 n1_355914_360992 n1_378410_360992 4.0171399999999995
R11-567-116 n1_378410_360992 n1_400602_360992 3.96286
R11-567-117 n1_400602_360992 n1_422794_360992 3.96286
R11-567-118 n1_422794_360992 n1_445290_360992 4.0171399999999995
R11-567-119 n1_445290_360992 n1_467482_360992 3.96286
R11-567-120 n1_467482_360992 n1_489978_360992 4.0171399999999995
R11-567-121 n1_489978_360992 n1_512170_360992 3.96286
R11-567-122 n1_512170_360992 n1_534666_360992 4.0171399999999995
R11-567-123 n1_534666_360992 n1_556858_360992 3.96286
R11-567-124 n1_556858_360992 n1_579050_360992 3.96286
R11-567-125 n1_579050_360992 n1_601546_360992 4.0171399999999995
R11-567-126 n1_601546_360992 n1_623064_360992 3.8425
R11-567-127 n1_623064_360992 n1_625064_360992 0.357143
R11-568-100 n1_623064_360992 n1_625064_360992 0.333333
R11-568-101 n1_625064_360992 n1_627064_360992 0.357143
R11-569-100 n1_625064_360992 n1_627064_360992 0.333333
R11-570-100 n1_44000_364336 n1_46000_364336 0.333333
R11-571-100 n1_44000_364336 n1_46000_364336 0.357143
R11-571-101 n1_46000_364336 n1_48000_364336 0.333333
R11-572-100 n1_46000_364336 n1_48000_364336 0.357143
R11-572-101 n1_48000_364336 n1_65594_364336 3.14179
R11-572-102 n1_65594_364336 n1_88090_364336 4.0171399999999995
R11-572-103 n1_88090_364336 n1_110282_364336 3.96286
R11-572-104 n1_110282_364336 n1_132778_364336 4.0171399999999995
R11-572-105 n1_132778_364336 n1_154970_364336 3.96286
R11-572-106 n1_154970_364336 n1_177466_364336 4.0171399999999995
R11-572-107 n1_177466_364336 n1_199658_364336 3.96286
R11-572-108 n1_199658_364336 n1_221850_364336 3.96286
R11-572-109 n1_221850_364336 n1_244346_364336 4.0171399999999995
R11-572-110 n1_244346_364336 n1_266538_364336 3.96286
R11-572-111 n1_266538_364336 n1_289034_364336 4.0171399999999995
R11-572-112 n1_289034_364336 n1_311226_364336 3.96286
R11-572-113 n1_311226_364336 n1_333722_364336 4.0171399999999995
R11-572-114 n1_333722_364336 n1_355914_364336 3.96286
R11-572-115 n1_355914_364336 n1_378410_364336 4.0171399999999995
R11-572-116 n1_378410_364336 n1_400602_364336 3.96286
R11-572-117 n1_400602_364336 n1_422794_364336 3.96286
R11-572-118 n1_422794_364336 n1_445290_364336 4.0171399999999995
R11-572-119 n1_445290_364336 n1_467482_364336 3.96286
R11-572-120 n1_467482_364336 n1_489978_364336 4.0171399999999995
R11-572-121 n1_489978_364336 n1_512170_364336 3.96286
R11-572-122 n1_512170_364336 n1_534666_364336 4.0171399999999995
R11-572-123 n1_534666_364336 n1_556858_364336 3.96286
R11-572-124 n1_556858_364336 n1_579050_364336 3.96286
R11-572-125 n1_579050_364336 n1_601546_364336 4.0171399999999995
R11-572-126 n1_601546_364336 n1_623064_364336 3.8425
R11-572-127 n1_623064_364336 n1_625064_364336 0.357143
R11-573-100 n1_623064_364336 n1_625064_364336 0.333333
R11-573-101 n1_625064_364336 n1_627064_364336 0.357143
R11-574-100 n1_625064_364336 n1_627064_364336 0.333333
R11-575-100 n1_44000_367680 n1_46000_367680 0.333333
R11-576-100 n1_44000_367680 n1_46000_367680 0.357143
R11-576-101 n1_46000_367680 n1_48000_367680 0.333333
R11-577-100 n1_46000_367680 n1_48000_367680 0.357143
R11-577-101 n1_48000_367680 n1_65594_367680 3.14179
R11-577-102 n1_65594_367680 n1_88090_367680 4.0171399999999995
R11-577-103 n1_88090_367680 n1_110282_367680 3.96286
R11-577-104 n1_110282_367680 n1_132778_367680 4.0171399999999995
R11-577-105 n1_132778_367680 n1_154970_367680 3.96286
R11-577-106 n1_154970_367680 n1_177466_367680 4.0171399999999995
R11-577-107 n1_177466_367680 n1_199658_367680 3.96286
R11-577-108 n1_199658_367680 n1_221850_367680 3.96286
R11-577-109 n1_221850_367680 n1_244346_367680 4.0171399999999995
R11-577-110 n1_244346_367680 n1_266538_367680 3.96286
R11-577-111 n1_266538_367680 n1_289034_367680 4.0171399999999995
R11-577-112 n1_289034_367680 n1_311226_367680 3.96286
R11-577-113 n1_311226_367680 n1_333722_367680 4.0171399999999995
R11-577-114 n1_333722_367680 n1_355914_367680 3.96286
R11-577-115 n1_355914_367680 n1_378410_367680 4.0171399999999995
R11-577-116 n1_378410_367680 n1_400602_367680 3.96286
R11-577-117 n1_400602_367680 n1_422794_367680 3.96286
R11-577-118 n1_422794_367680 n1_445290_367680 4.0171399999999995
R11-577-119 n1_445290_367680 n1_467482_367680 3.96286
R11-577-120 n1_467482_367680 n1_489978_367680 4.0171399999999995
R11-577-121 n1_489978_367680 n1_512170_367680 3.96286
R11-577-122 n1_512170_367680 n1_534666_367680 4.0171399999999995
R11-577-123 n1_534666_367680 n1_556858_367680 3.96286
R11-577-124 n1_556858_367680 n1_579050_367680 3.96286
R11-577-125 n1_579050_367680 n1_601546_367680 4.0171399999999995
R11-577-126 n1_601546_367680 n1_623064_367680 3.8425
R11-577-127 n1_623064_367680 n1_625064_367680 0.357143
R11-578-100 n1_623064_367680 n1_625064_367680 0.333333
R11-578-101 n1_625064_367680 n1_627064_367680 0.357143
R11-579-100 n1_625064_367680 n1_627064_367680 0.333333
R11-580-100 n1_44000_371024 n1_46000_371024 0.333333
R11-581-100 n1_44000_371024 n1_46000_371024 0.357143
R11-581-101 n1_46000_371024 n1_48000_371024 0.333333
R11-582-100 n1_46000_371024 n1_48000_371024 0.357143
R11-582-101 n1_48000_371024 n1_65594_371024 3.14179
R11-582-102 n1_65594_371024 n1_88090_371024 4.0171399999999995
R11-582-103 n1_88090_371024 n1_110282_371024 3.96286
R11-582-104 n1_110282_371024 n1_132778_371024 4.0171399999999995
R11-582-105 n1_132778_371024 n1_154970_371024 3.96286
R11-582-106 n1_154970_371024 n1_177466_371024 4.0171399999999995
R11-582-107 n1_177466_371024 n1_199658_371024 3.96286
R11-582-108 n1_199658_371024 n1_221850_371024 3.96286
R11-582-109 n1_221850_371024 n1_244346_371024 4.0171399999999995
R11-582-110 n1_244346_371024 n1_266538_371024 3.96286
R11-582-111 n1_266538_371024 n1_289034_371024 4.0171399999999995
R11-582-112 n1_289034_371024 n1_311226_371024 3.96286
R11-582-113 n1_311226_371024 n1_333722_371024 4.0171399999999995
R11-582-114 n1_333722_371024 n1_355914_371024 3.96286
R11-582-115 n1_355914_371024 n1_378410_371024 4.0171399999999995
R11-582-116 n1_378410_371024 n1_400602_371024 3.96286
R11-582-117 n1_400602_371024 n1_422794_371024 3.96286
R11-582-118 n1_422794_371024 n1_445290_371024 4.0171399999999995
R11-582-119 n1_445290_371024 n1_467482_371024 3.96286
R11-582-120 n1_467482_371024 n1_489978_371024 4.0171399999999995
R11-582-121 n1_489978_371024 n1_512170_371024 3.96286
R11-582-122 n1_512170_371024 n1_534666_371024 4.0171399999999995
R11-582-123 n1_534666_371024 n1_556858_371024 3.96286
R11-582-124 n1_556858_371024 n1_579050_371024 3.96286
R11-582-125 n1_579050_371024 n1_601546_371024 4.0171399999999995
R11-582-126 n1_601546_371024 n1_623064_371024 3.8425
R11-582-127 n1_623064_371024 n1_625064_371024 0.357143
R11-583-100 n1_623064_371024 n1_625064_371024 0.333333
R11-583-101 n1_625064_371024 n1_627064_371024 0.357143
R11-584-100 n1_625064_371024 n1_627064_371024 0.333333
R11-585-100 n1_44000_374368 n1_46000_374368 0.333333
R11-586-100 n1_44000_374368 n1_46000_374368 0.357143
R11-586-101 n1_46000_374368 n1_48000_374368 0.333333
R11-587-100 n1_46000_374368 n1_48000_374368 0.357143
R11-587-101 n1_48000_374368 n1_65594_374368 3.14179
R11-587-102 n1_65594_374368 n1_88090_374368 4.0171399999999995
R11-587-103 n1_88090_374368 n1_110282_374368 3.96286
R11-587-104 n1_110282_374368 n1_132778_374368 4.0171399999999995
R11-587-105 n1_132778_374368 n1_154970_374368 3.96286
R11-587-106 n1_154970_374368 n1_177466_374368 4.0171399999999995
R11-587-107 n1_177466_374368 n1_199658_374368 3.96286
R11-587-108 n1_199658_374368 n1_221850_374368 3.96286
R11-587-109 n1_221850_374368 n1_244346_374368 4.0171399999999995
R11-587-110 n1_244346_374368 n1_266538_374368 3.96286
R11-587-111 n1_266538_374368 n1_289034_374368 4.0171399999999995
R11-587-112 n1_289034_374368 n1_311226_374368 3.96286
R11-587-113 n1_311226_374368 n1_333722_374368 4.0171399999999995
R11-587-114 n1_333722_374368 n1_355914_374368 3.96286
R11-587-115 n1_355914_374368 n1_378410_374368 4.0171399999999995
R11-587-116 n1_378410_374368 n1_400602_374368 3.96286
R11-587-117 n1_400602_374368 n1_422794_374368 3.96286
R11-587-118 n1_422794_374368 n1_445290_374368 4.0171399999999995
R11-587-119 n1_445290_374368 n1_467482_374368 3.96286
R11-587-120 n1_467482_374368 n1_489978_374368 4.0171399999999995
R11-587-121 n1_489978_374368 n1_512170_374368 3.96286
R11-587-122 n1_512170_374368 n1_534666_374368 4.0171399999999995
R11-587-123 n1_534666_374368 n1_556858_374368 3.96286
R11-587-124 n1_556858_374368 n1_579050_374368 3.96286
R11-587-125 n1_579050_374368 n1_601546_374368 4.0171399999999995
R11-587-126 n1_601546_374368 n1_623064_374368 3.8425
R11-587-127 n1_623064_374368 n1_625064_374368 0.357143
R11-588-100 n1_623064_374368 n1_625064_374368 0.333333
R11-588-101 n1_625064_374368 n1_627064_374368 0.357143
R11-589-100 n1_625064_374368 n1_627064_374368 0.333333
R11-590-100 n1_44000_377712 n1_46000_377712 0.333333
R11-591-100 n1_44000_377712 n1_46000_377712 0.357143
R11-591-101 n1_46000_377712 n1_48000_377712 0.333333
R11-592-100 n1_46000_377712 n1_48000_377712 0.357143
R11-592-101 n1_48000_377712 n1_65594_377712 3.14179
R11-592-102 n1_65594_377712 n1_88090_377712 4.0171399999999995
R11-592-103 n1_88090_377712 n1_110282_377712 3.96286
R11-592-104 n1_110282_377712 n1_132778_377712 4.0171399999999995
R11-592-105 n1_132778_377712 n1_154970_377712 3.96286
R11-592-106 n1_154970_377712 n1_177466_377712 4.0171399999999995
R11-592-107 n1_177466_377712 n1_199658_377712 3.96286
R11-592-108 n1_199658_377712 n1_221850_377712 3.96286
R11-592-109 n1_221850_377712 n1_244346_377712 4.0171399999999995
R11-592-110 n1_244346_377712 n1_266538_377712 3.96286
R11-592-111 n1_266538_377712 n1_289034_377712 4.0171399999999995
R11-592-112 n1_289034_377712 n1_311226_377712 3.96286
R11-592-113 n1_311226_377712 n1_333722_377712 4.0171399999999995
R11-592-114 n1_333722_377712 n1_355914_377712 3.96286
R11-592-115 n1_355914_377712 n1_378410_377712 4.0171399999999995
R11-592-116 n1_378410_377712 n1_400602_377712 3.96286
R11-592-117 n1_400602_377712 n1_422794_377712 3.96286
R11-592-118 n1_422794_377712 n1_445290_377712 4.0171399999999995
R11-592-119 n1_445290_377712 n1_467482_377712 3.96286
R11-592-120 n1_467482_377712 n1_489978_377712 4.0171399999999995
R11-592-121 n1_489978_377712 n1_512170_377712 3.96286
R11-592-122 n1_512170_377712 n1_534666_377712 4.0171399999999995
R11-592-123 n1_534666_377712 n1_556858_377712 3.96286
R11-592-124 n1_556858_377712 n1_579050_377712 3.96286
R11-592-125 n1_579050_377712 n1_601546_377712 4.0171399999999995
R11-592-126 n1_601546_377712 n1_623064_377712 3.8425
R11-592-127 n1_623064_377712 n1_625064_377712 0.357143
R11-593-100 n1_623064_377712 n1_625064_377712 0.333333
R11-593-101 n1_625064_377712 n1_627064_377712 0.357143
R11-594-100 n1_625064_377712 n1_627064_377712 0.333333
R11-595-100 n1_44000_381056 n1_46000_381056 0.333333
R11-596-100 n1_44000_381056 n1_46000_381056 0.357143
R11-596-101 n1_46000_381056 n1_48000_381056 0.333333
R11-597-100 n1_46000_381056 n1_48000_381056 0.357143
R11-597-101 n1_48000_381056 n1_65594_381056 3.14179
R11-597-102 n1_65594_381056 n1_88090_381056 4.0171399999999995
R11-597-103 n1_88090_381056 n1_110282_381056 3.96286
R11-597-104 n1_110282_381056 n1_132778_381056 4.0171399999999995
R11-597-105 n1_132778_381056 n1_154970_381056 3.96286
R11-597-106 n1_154970_381056 n1_177466_381056 4.0171399999999995
R11-597-107 n1_177466_381056 n1_199658_381056 3.96286
R11-597-108 n1_199658_381056 n1_221850_381056 3.96286
R11-597-109 n1_221850_381056 n1_244346_381056 4.0171399999999995
R11-597-110 n1_244346_381056 n1_266538_381056 3.96286
R11-597-111 n1_266538_381056 n1_289034_381056 4.0171399999999995
R11-597-112 n1_289034_381056 n1_311226_381056 3.96286
R11-597-113 n1_311226_381056 n1_333722_381056 4.0171399999999995
R11-597-114 n1_333722_381056 n1_355914_381056 3.96286
R11-597-115 n1_355914_381056 n1_378410_381056 4.0171399999999995
R11-597-116 n1_378410_381056 n1_400602_381056 3.96286
R11-597-117 n1_400602_381056 n1_422794_381056 3.96286
R11-597-118 n1_422794_381056 n1_445290_381056 4.0171399999999995
R11-597-119 n1_445290_381056 n1_467482_381056 3.96286
R11-597-120 n1_467482_381056 n1_489978_381056 4.0171399999999995
R11-597-121 n1_489978_381056 n1_512170_381056 3.96286
R11-597-122 n1_512170_381056 n1_534666_381056 4.0171399999999995
R11-597-123 n1_534666_381056 n1_556858_381056 3.96286
R11-597-124 n1_556858_381056 n1_579050_381056 3.96286
R11-597-125 n1_579050_381056 n1_601546_381056 4.0171399999999995
R11-597-126 n1_601546_381056 n1_623064_381056 3.8425
R11-597-127 n1_623064_381056 n1_625064_381056 0.357143
R11-598-100 n1_623064_381056 n1_625064_381056 0.333333
R11-598-101 n1_625064_381056 n1_627064_381056 0.357143
R11-599-100 n1_625064_381056 n1_627064_381056 0.333333
R11-600-100 n1_44000_384400 n1_46000_384400 0.333333
R11-601-100 n1_44000_384400 n1_46000_384400 0.357143
R11-601-101 n1_46000_384400 n1_48000_384400 0.333333
R11-602-100 n1_46000_384400 n1_48000_384400 0.357143
R11-602-101 n1_48000_384400 n1_65594_384400 3.14179
R11-602-102 n1_65594_384400 n1_88090_384400 4.0171399999999995
R11-602-103 n1_88090_384400 n1_110282_384400 3.96286
R11-602-104 n1_110282_384400 n1_132778_384400 4.0171399999999995
R11-602-105 n1_132778_384400 n1_154970_384400 3.96286
R11-602-106 n1_154970_384400 n1_177466_384400 4.0171399999999995
R11-602-107 n1_177466_384400 n1_199658_384400 3.96286
R11-602-108 n1_199658_384400 n1_221850_384400 3.96286
R11-602-109 n1_221850_384400 n1_244346_384400 4.0171399999999995
R11-602-110 n1_244346_384400 n1_266538_384400 3.96286
R11-602-111 n1_266538_384400 n1_289034_384400 4.0171399999999995
R11-602-112 n1_289034_384400 n1_311226_384400 3.96286
R11-602-113 n1_311226_384400 n1_333722_384400 4.0171399999999995
R11-602-114 n1_333722_384400 n1_355914_384400 3.96286
R11-602-115 n1_355914_384400 n1_378410_384400 4.0171399999999995
R11-602-116 n1_378410_384400 n1_400602_384400 3.96286
R11-602-117 n1_400602_384400 n1_422794_384400 3.96286
R11-602-118 n1_422794_384400 n1_445290_384400 4.0171399999999995
R11-602-119 n1_445290_384400 n1_467482_384400 3.96286
R11-602-120 n1_467482_384400 n1_489978_384400 4.0171399999999995
R11-602-121 n1_489978_384400 n1_512170_384400 3.96286
R11-602-122 n1_512170_384400 n1_534666_384400 4.0171399999999995
R11-602-123 n1_534666_384400 n1_556858_384400 3.96286
R11-602-124 n1_556858_384400 n1_579050_384400 3.96286
R11-602-125 n1_579050_384400 n1_601546_384400 4.0171399999999995
R11-602-126 n1_601546_384400 n1_623064_384400 3.8425
R11-602-127 n1_623064_384400 n1_625064_384400 0.357143
R11-603-100 n1_623064_384400 n1_625064_384400 0.333333
R11-603-101 n1_625064_384400 n1_627064_384400 0.357143
R11-604-100 n1_625064_384400 n1_627064_384400 0.333333
R11-605-100 n1_44000_387744 n1_46000_387744 0.333333
R11-606-100 n1_44000_387744 n1_46000_387744 0.357143
R11-606-101 n1_46000_387744 n1_48000_387744 0.333333
R11-607-100 n1_46000_387744 n1_48000_387744 0.357143
R11-607-101 n1_48000_387744 n1_65594_387744 3.14179
R11-607-102 n1_65594_387744 n1_88090_387744 4.0171399999999995
R11-607-103 n1_88090_387744 n1_110282_387744 3.96286
R11-607-104 n1_110282_387744 n1_132778_387744 4.0171399999999995
R11-607-105 n1_132778_387744 n1_154970_387744 3.96286
R11-607-106 n1_154970_387744 n1_177466_387744 4.0171399999999995
R11-607-107 n1_177466_387744 n1_199658_387744 3.96286
R11-607-108 n1_199658_387744 n1_221850_387744 3.96286
R11-607-109 n1_221850_387744 n1_244346_387744 4.0171399999999995
R11-607-110 n1_244346_387744 n1_266538_387744 3.96286
R11-607-111 n1_266538_387744 n1_289034_387744 4.0171399999999995
R11-607-112 n1_289034_387744 n1_311226_387744 3.96286
R11-607-113 n1_311226_387744 n1_333722_387744 4.0171399999999995
R11-607-114 n1_333722_387744 n1_355914_387744 3.96286
R11-607-115 n1_355914_387744 n1_378410_387744 4.0171399999999995
R11-607-116 n1_378410_387744 n1_400602_387744 3.96286
R11-607-117 n1_400602_387744 n1_422794_387744 3.96286
R11-607-118 n1_422794_387744 n1_445290_387744 4.0171399999999995
R11-607-119 n1_445290_387744 n1_467482_387744 3.96286
R11-607-120 n1_467482_387744 n1_489978_387744 4.0171399999999995
R11-607-121 n1_489978_387744 n1_512170_387744 3.96286
R11-607-122 n1_512170_387744 n1_534666_387744 4.0171399999999995
R11-607-123 n1_534666_387744 n1_556858_387744 3.96286
R11-607-124 n1_556858_387744 n1_579050_387744 3.96286
R11-607-125 n1_579050_387744 n1_601546_387744 4.0171399999999995
R11-607-126 n1_601546_387744 n1_623064_387744 3.8425
R11-607-127 n1_623064_387744 n1_625064_387744 0.357143
R11-608-100 n1_623064_387744 n1_625064_387744 0.333333
R11-608-101 n1_625064_387744 n1_627064_387744 0.357143
R11-609-100 n1_625064_387744 n1_627064_387744 0.333333
R11-610-100 n1_44000_391088 n1_46000_391088 0.357143
R11-611-100 n1_44000_391088 n1_46000_391088 0.333333
R11-611-101 n1_46000_391088 n1_48000_391088 0.357143
R11-612-100 n1_46000_391088 n1_48000_391088 0.333333
R11-612-101 n1_48000_391088 n1_65594_391088 3.14179
R11-612-102 n1_65594_391088 n1_88090_391088 4.0171399999999995
R11-612-103 n1_88090_391088 n1_110282_391088 3.96286
R11-612-104 n1_110282_391088 n1_132778_391088 4.0171399999999995
R11-612-105 n1_132778_391088 n1_154970_391088 3.96286
R11-612-106 n1_154970_391088 n1_177466_391088 4.0171399999999995
R11-612-107 n1_177466_391088 n1_199658_391088 3.96286
R11-612-108 n1_199658_391088 n1_221850_391088 3.96286
R11-612-109 n1_221850_391088 n1_244346_391088 4.0171399999999995
R11-612-110 n1_244346_391088 n1_266538_391088 3.96286
R11-612-111 n1_266538_391088 n1_289034_391088 4.0171399999999995
R11-612-112 n1_289034_391088 n1_311226_391088 3.96286
R11-612-113 n1_311226_391088 n1_333722_391088 4.0171399999999995
R11-612-114 n1_333722_391088 n1_355914_391088 3.96286
R11-612-115 n1_355914_391088 n1_378410_391088 4.0171399999999995
R11-612-116 n1_378410_391088 n1_400602_391088 3.96286
R11-612-117 n1_400602_391088 n1_422794_391088 3.96286
R11-612-118 n1_422794_391088 n1_445290_391088 4.0171399999999995
R11-612-119 n1_445290_391088 n1_467482_391088 3.96286
R11-612-120 n1_467482_391088 n1_489978_391088 4.0171399999999995
R11-612-121 n1_489978_391088 n1_512170_391088 3.96286
R11-612-122 n1_512170_391088 n1_534666_391088 4.0171399999999995
R11-612-123 n1_534666_391088 n1_556858_391088 3.96286
R11-612-124 n1_556858_391088 n1_579050_391088 3.96286
R11-612-125 n1_579050_391088 n1_601546_391088 4.0171399999999995
R11-612-126 n1_601546_391088 n1_623064_391088 3.8425
R11-612-127 n1_623064_391088 n1_625064_391088 0.357143
R11-613-100 n1_623064_391088 n1_625064_391088 0.333333
R11-613-101 n1_625064_391088 n1_627064_391088 0.357143
R11-614-100 n1_625064_391088 n1_627064_391088 0.333333
R11-615-100 n1_44000_394432 n1_46000_394432 0.357143
R11-616-100 n1_44000_394432 n1_46000_394432 0.333333
R11-616-101 n1_46000_394432 n1_48000_394432 0.357143
R11-617-100 n1_46000_394432 n1_48000_394432 0.333333
R11-617-101 n1_48000_394432 n1_65594_394432 3.14179
R11-617-102 n1_65594_394432 n1_88090_394432 4.0171399999999995
R11-617-103 n1_88090_394432 n1_110282_394432 3.96286
R11-617-104 n1_110282_394432 n1_132778_394432 4.0171399999999995
R11-617-105 n1_132778_394432 n1_154970_394432 3.96286
R11-617-106 n1_154970_394432 n1_177466_394432 4.0171399999999995
R11-617-107 n1_177466_394432 n1_199658_394432 3.96286
R11-617-108 n1_199658_394432 n1_221850_394432 3.96286
R11-617-109 n1_221850_394432 n1_244346_394432 4.0171399999999995
R11-617-110 n1_244346_394432 n1_266538_394432 3.96286
R11-617-111 n1_266538_394432 n1_289034_394432 4.0171399999999995
R11-617-112 n1_289034_394432 n1_311226_394432 3.96286
R11-617-113 n1_311226_394432 n1_333722_394432 4.0171399999999995
R11-617-114 n1_333722_394432 n1_355914_394432 3.96286
R11-617-115 n1_355914_394432 n1_378410_394432 4.0171399999999995
R11-617-116 n1_378410_394432 n1_400602_394432 3.96286
R11-617-117 n1_400602_394432 n1_422794_394432 3.96286
R11-617-118 n1_422794_394432 n1_445290_394432 4.0171399999999995
R11-617-119 n1_445290_394432 n1_467482_394432 3.96286
R11-617-120 n1_467482_394432 n1_489978_394432 4.0171399999999995
R11-617-121 n1_489978_394432 n1_512170_394432 3.96286
R11-617-122 n1_512170_394432 n1_534666_394432 4.0171399999999995
R11-617-123 n1_534666_394432 n1_556858_394432 3.96286
R11-617-124 n1_556858_394432 n1_579050_394432 3.96286
R11-617-125 n1_579050_394432 n1_601546_394432 4.0171399999999995
R11-617-126 n1_601546_394432 n1_623064_394432 3.8425
R11-617-127 n1_623064_394432 n1_625064_394432 0.357143
R11-618-100 n1_623064_394432 n1_625064_394432 0.333333
R11-618-101 n1_625064_394432 n1_627064_394432 0.357143
R11-619-100 n1_625064_394432 n1_627064_394432 0.333333
R11-620-100 n1_44000_397776 n1_46000_397776 0.357143
R11-621-100 n1_44000_397776 n1_46000_397776 0.333333
R11-621-101 n1_46000_397776 n1_48000_397776 0.357143
R11-622-100 n1_46000_397776 n1_48000_397776 0.333333
R11-622-101 n1_48000_397776 n1_65594_397776 3.14179
R11-622-102 n1_65594_397776 n1_88090_397776 4.0171399999999995
R11-622-103 n1_88090_397776 n1_110282_397776 3.96286
R11-622-104 n1_110282_397776 n1_132778_397776 4.0171399999999995
R11-622-105 n1_132778_397776 n1_154970_397776 3.96286
R11-622-106 n1_154970_397776 n1_177466_397776 4.0171399999999995
R11-622-107 n1_177466_397776 n1_199658_397776 3.96286
R11-622-108 n1_199658_397776 n1_221850_397776 3.96286
R11-622-109 n1_221850_397776 n1_244346_397776 4.0171399999999995
R11-622-110 n1_244346_397776 n1_266538_397776 3.96286
R11-622-111 n1_266538_397776 n1_289034_397776 4.0171399999999995
R11-622-112 n1_289034_397776 n1_311226_397776 3.96286
R11-622-113 n1_311226_397776 n1_333722_397776 4.0171399999999995
R11-622-114 n1_333722_397776 n1_355914_397776 3.96286
R11-622-115 n1_355914_397776 n1_378410_397776 4.0171399999999995
R11-622-116 n1_378410_397776 n1_400602_397776 3.96286
R11-622-117 n1_400602_397776 n1_422794_397776 3.96286
R11-622-118 n1_422794_397776 n1_445290_397776 4.0171399999999995
R11-622-119 n1_445290_397776 n1_467482_397776 3.96286
R11-622-120 n1_467482_397776 n1_489978_397776 4.0171399999999995
R11-622-121 n1_489978_397776 n1_512170_397776 3.96286
R11-622-122 n1_512170_397776 n1_534666_397776 4.0171399999999995
R11-622-123 n1_534666_397776 n1_556858_397776 3.96286
R11-622-124 n1_556858_397776 n1_579050_397776 3.96286
R11-622-125 n1_579050_397776 n1_601546_397776 4.0171399999999995
R11-622-126 n1_601546_397776 n1_623064_397776 3.8425
R11-622-127 n1_623064_397776 n1_625064_397776 0.357143
R11-623-100 n1_623064_397776 n1_625064_397776 0.333333
R11-623-101 n1_625064_397776 n1_627064_397776 0.357143
R11-624-100 n1_625064_397776 n1_627064_397776 0.333333
R11-625-100 n1_44000_401120 n1_46000_401120 0.357143
R11-626-100 n1_44000_401120 n1_46000_401120 0.333333
R11-626-101 n1_46000_401120 n1_48000_401120 0.357143
R11-627-100 n1_46000_401120 n1_48000_401120 0.333333
R11-627-101 n1_48000_401120 n1_65594_401120 3.14179
R11-627-102 n1_65594_401120 n1_88090_401120 4.0171399999999995
R11-627-103 n1_88090_401120 n1_110282_401120 3.96286
R11-627-104 n1_110282_401120 n1_132778_401120 4.0171399999999995
R11-627-105 n1_132778_401120 n1_154970_401120 3.96286
R11-627-106 n1_154970_401120 n1_177466_401120 4.0171399999999995
R11-627-107 n1_177466_401120 n1_199658_401120 3.96286
R11-627-108 n1_199658_401120 n1_221850_401120 3.96286
R11-627-109 n1_221850_401120 n1_244346_401120 4.0171399999999995
R11-627-110 n1_244346_401120 n1_266538_401120 3.96286
R11-627-111 n1_266538_401120 n1_289034_401120 4.0171399999999995
R11-627-112 n1_289034_401120 n1_311226_401120 3.96286
R11-627-113 n1_311226_401120 n1_333722_401120 4.0171399999999995
R11-627-114 n1_333722_401120 n1_355914_401120 3.96286
R11-627-115 n1_355914_401120 n1_378410_401120 4.0171399999999995
R11-627-116 n1_378410_401120 n1_400602_401120 3.96286
R11-627-117 n1_400602_401120 n1_422794_401120 3.96286
R11-627-118 n1_422794_401120 n1_445290_401120 4.0171399999999995
R11-627-119 n1_445290_401120 n1_467482_401120 3.96286
R11-627-120 n1_467482_401120 n1_489978_401120 4.0171399999999995
R11-627-121 n1_489978_401120 n1_512170_401120 3.96286
R11-627-122 n1_512170_401120 n1_534666_401120 4.0171399999999995
R11-627-123 n1_534666_401120 n1_556858_401120 3.96286
R11-627-124 n1_556858_401120 n1_579050_401120 3.96286
R11-627-125 n1_579050_401120 n1_601546_401120 4.0171399999999995
R11-627-126 n1_601546_401120 n1_623064_401120 3.8425
R11-627-127 n1_623064_401120 n1_625064_401120 0.357143
R11-628-100 n1_623064_401120 n1_625064_401120 0.333333
R11-628-101 n1_625064_401120 n1_627064_401120 0.357143
R11-629-100 n1_625064_401120 n1_627064_401120 0.333333
R11-630-100 n1_44000_404464 n1_46000_404464 0.357143
R11-631-100 n1_44000_404464 n1_46000_404464 0.333333
R11-631-101 n1_46000_404464 n1_48000_404464 0.357143
R11-632-100 n1_46000_404464 n1_48000_404464 0.333333
R11-632-101 n1_48000_404464 n1_65594_404464 3.14179
R11-632-102 n1_65594_404464 n1_88090_404464 4.0171399999999995
R11-632-103 n1_88090_404464 n1_110282_404464 3.96286
R11-632-104 n1_110282_404464 n1_132778_404464 4.0171399999999995
R11-632-105 n1_132778_404464 n1_154970_404464 3.96286
R11-632-106 n1_154970_404464 n1_177466_404464 4.0171399999999995
R11-632-107 n1_177466_404464 n1_199658_404464 3.96286
R11-632-108 n1_199658_404464 n1_221850_404464 3.96286
R11-632-109 n1_221850_404464 n1_244346_404464 4.0171399999999995
R11-632-110 n1_244346_404464 n1_266538_404464 3.96286
R11-632-111 n1_266538_404464 n1_289034_404464 4.0171399999999995
R11-632-112 n1_289034_404464 n1_311226_404464 3.96286
R11-632-113 n1_311226_404464 n1_333722_404464 4.0171399999999995
R11-632-114 n1_333722_404464 n1_355914_404464 3.96286
R11-632-115 n1_355914_404464 n1_378410_404464 4.0171399999999995
R11-632-116 n1_378410_404464 n1_400602_404464 3.96286
R11-632-117 n1_400602_404464 n1_422794_404464 3.96286
R11-632-118 n1_422794_404464 n1_445290_404464 4.0171399999999995
R11-632-119 n1_445290_404464 n1_467482_404464 3.96286
R11-632-120 n1_467482_404464 n1_489978_404464 4.0171399999999995
R11-632-121 n1_489978_404464 n1_512170_404464 3.96286
R11-632-122 n1_512170_404464 n1_534666_404464 4.0171399999999995
R11-632-123 n1_534666_404464 n1_556858_404464 3.96286
R11-632-124 n1_556858_404464 n1_579050_404464 3.96286
R11-632-125 n1_579050_404464 n1_601546_404464 4.0171399999999995
R11-632-126 n1_601546_404464 n1_623064_404464 3.8425
R11-632-127 n1_623064_404464 n1_625064_404464 0.357143
R11-633-100 n1_623064_404464 n1_625064_404464 0.333333
R11-633-101 n1_625064_404464 n1_627064_404464 0.357143
R11-634-100 n1_625064_404464 n1_627064_404464 0.333333
R11-635-100 n1_44000_407808 n1_46000_407808 0.333333
R11-636-100 n1_44000_407808 n1_46000_407808 0.357143
R11-636-101 n1_46000_407808 n1_48000_407808 0.333333
R11-637-100 n1_46000_407808 n1_48000_407808 0.357143
R11-637-101 n1_48000_407808 n1_65594_407808 3.14179
R11-637-102 n1_65594_407808 n1_88090_407808 4.0171399999999995
R11-637-103 n1_88090_407808 n1_110282_407808 3.96286
R11-637-104 n1_110282_407808 n1_132778_407808 4.0171399999999995
R11-637-105 n1_132778_407808 n1_154970_407808 3.96286
R11-637-106 n1_154970_407808 n1_177466_407808 4.0171399999999995
R11-637-107 n1_177466_407808 n1_199658_407808 3.96286
R11-637-108 n1_199658_407808 n1_221850_407808 3.96286
R11-637-109 n1_221850_407808 n1_244346_407808 4.0171399999999995
R11-637-110 n1_244346_407808 n1_266538_407808 3.96286
R11-637-111 n1_266538_407808 n1_289034_407808 4.0171399999999995
R11-637-112 n1_289034_407808 n1_311226_407808 3.96286
R11-637-113 n1_311226_407808 n1_333722_407808 4.0171399999999995
R11-637-114 n1_333722_407808 n1_355914_407808 3.96286
R11-637-115 n1_355914_407808 n1_378410_407808 4.0171399999999995
R11-637-116 n1_378410_407808 n1_400602_407808 3.96286
R11-637-117 n1_400602_407808 n1_422794_407808 3.96286
R11-637-118 n1_422794_407808 n1_445290_407808 4.0171399999999995
R11-637-119 n1_445290_407808 n1_467482_407808 3.96286
R11-637-120 n1_467482_407808 n1_489978_407808 4.0171399999999995
R11-637-121 n1_489978_407808 n1_512170_407808 3.96286
R11-637-122 n1_512170_407808 n1_534666_407808 4.0171399999999995
R11-637-123 n1_534666_407808 n1_556858_407808 3.96286
R11-637-124 n1_556858_407808 n1_579050_407808 3.96286
R11-637-125 n1_579050_407808 n1_601546_407808 4.0171399999999995
R11-637-126 n1_601546_407808 n1_623064_407808 3.8425
R11-637-127 n1_623064_407808 n1_625064_407808 0.357143
R11-638-100 n1_623064_407808 n1_625064_407808 0.333333
R11-638-101 n1_625064_407808 n1_627064_407808 0.357143
R11-639-100 n1_625064_407808 n1_627064_407808 0.333333
R11-640-100 n1_44000_411152 n1_46000_411152 0.333333
R11-641-100 n1_44000_411152 n1_46000_411152 0.357143
R11-641-101 n1_46000_411152 n1_48000_411152 0.333333
R11-642-100 n1_46000_411152 n1_48000_411152 0.357143
R11-642-101 n1_48000_411152 n1_65594_411152 3.14179
R11-642-102 n1_65594_411152 n1_88090_411152 4.0171399999999995
R11-642-103 n1_88090_411152 n1_110282_411152 3.96286
R11-642-104 n1_110282_411152 n1_132778_411152 4.0171399999999995
R11-642-105 n1_132778_411152 n1_154970_411152 3.96286
R11-642-106 n1_154970_411152 n1_177466_411152 4.0171399999999995
R11-642-107 n1_177466_411152 n1_199658_411152 3.96286
R11-642-108 n1_199658_411152 n1_221850_411152 3.96286
R11-642-109 n1_221850_411152 n1_244346_411152 4.0171399999999995
R11-642-110 n1_244346_411152 n1_266538_411152 3.96286
R11-642-111 n1_266538_411152 n1_289034_411152 4.0171399999999995
R11-642-112 n1_289034_411152 n1_311226_411152 3.96286
R11-642-113 n1_311226_411152 n1_333722_411152 4.0171399999999995
R11-642-114 n1_333722_411152 n1_355914_411152 3.96286
R11-642-115 n1_355914_411152 n1_378410_411152 4.0171399999999995
R11-642-116 n1_378410_411152 n1_400602_411152 3.96286
R11-642-117 n1_400602_411152 n1_422794_411152 3.96286
R11-642-118 n1_422794_411152 n1_445290_411152 4.0171399999999995
R11-642-119 n1_445290_411152 n1_467482_411152 3.96286
R11-642-120 n1_467482_411152 n1_489978_411152 4.0171399999999995
R11-642-121 n1_489978_411152 n1_512170_411152 3.96286
R11-642-122 n1_512170_411152 n1_534666_411152 4.0171399999999995
R11-642-123 n1_534666_411152 n1_556858_411152 3.96286
R11-642-124 n1_556858_411152 n1_579050_411152 3.96286
R11-642-125 n1_579050_411152 n1_601546_411152 4.0171399999999995
R11-642-126 n1_601546_411152 n1_623064_411152 3.8425
R11-642-127 n1_623064_411152 n1_625064_411152 0.357143
R11-643-100 n1_623064_411152 n1_625064_411152 0.333333
R11-643-101 n1_625064_411152 n1_627064_411152 0.357143
R11-644-100 n1_625064_411152 n1_627064_411152 0.333333
R11-645-100 n1_44000_414496 n1_46000_414496 0.333333
R11-646-100 n1_44000_414496 n1_46000_414496 0.357143
R11-646-101 n1_46000_414496 n1_48000_414496 0.333333
R11-647-100 n1_46000_414496 n1_48000_414496 0.357143
R11-647-101 n1_48000_414496 n1_65594_414496 3.14179
R11-647-102 n1_65594_414496 n1_88090_414496 4.0171399999999995
R11-647-103 n1_88090_414496 n1_110282_414496 3.96286
R11-647-104 n1_110282_414496 n1_132778_414496 4.0171399999999995
R11-647-105 n1_132778_414496 n1_154970_414496 3.96286
R11-647-106 n1_154970_414496 n1_177466_414496 4.0171399999999995
R11-647-107 n1_177466_414496 n1_199658_414496 3.96286
R11-647-108 n1_199658_414496 n1_221850_414496 3.96286
R11-647-109 n1_221850_414496 n1_244346_414496 4.0171399999999995
R11-647-110 n1_244346_414496 n1_266538_414496 3.96286
R11-647-111 n1_266538_414496 n1_289034_414496 4.0171399999999995
R11-647-112 n1_289034_414496 n1_311226_414496 3.96286
R11-647-113 n1_311226_414496 n1_333722_414496 4.0171399999999995
R11-647-114 n1_333722_414496 n1_355914_414496 3.96286
R11-647-115 n1_355914_414496 n1_378410_414496 4.0171399999999995
R11-647-116 n1_378410_414496 n1_400602_414496 3.96286
R11-647-117 n1_400602_414496 n1_422794_414496 3.96286
R11-647-118 n1_422794_414496 n1_445290_414496 4.0171399999999995
R11-647-119 n1_445290_414496 n1_467482_414496 3.96286
R11-647-120 n1_467482_414496 n1_489978_414496 4.0171399999999995
R11-647-121 n1_489978_414496 n1_512170_414496 3.96286
R11-647-122 n1_512170_414496 n1_534666_414496 4.0171399999999995
R11-647-123 n1_534666_414496 n1_556858_414496 3.96286
R11-647-124 n1_556858_414496 n1_579050_414496 3.96286
R11-647-125 n1_579050_414496 n1_601546_414496 4.0171399999999995
R11-647-126 n1_601546_414496 n1_623064_414496 3.8425
R11-647-127 n1_623064_414496 n1_625064_414496 0.357143
R11-648-100 n1_623064_414496 n1_625064_414496 0.333333
R11-648-101 n1_625064_414496 n1_627064_414496 0.357143
R11-649-100 n1_625064_414496 n1_627064_414496 0.333333
R11-650-100 n1_44000_417840 n1_46000_417840 0.333333
R11-651-100 n1_44000_417840 n1_46000_417840 0.357143
R11-651-101 n1_46000_417840 n1_48000_417840 0.333333
R11-652-100 n1_46000_417840 n1_48000_417840 0.357143
R11-652-101 n1_48000_417840 n1_65594_417840 3.14179
R11-652-102 n1_65594_417840 n1_88090_417840 4.0171399999999995
R11-652-103 n1_88090_417840 n1_110282_417840 3.96286
R11-652-104 n1_110282_417840 n1_132778_417840 4.0171399999999995
R11-652-105 n1_132778_417840 n1_154970_417840 3.96286
R11-652-106 n1_154970_417840 n1_177466_417840 4.0171399999999995
R11-652-107 n1_177466_417840 n1_199658_417840 3.96286
R11-652-108 n1_199658_417840 n1_221850_417840 3.96286
R11-652-109 n1_221850_417840 n1_244346_417840 4.0171399999999995
R11-652-110 n1_244346_417840 n1_266538_417840 3.96286
R11-652-111 n1_266538_417840 n1_289034_417840 4.0171399999999995
R11-652-112 n1_289034_417840 n1_311226_417840 3.96286
R11-652-113 n1_311226_417840 n1_333722_417840 4.0171399999999995
R11-652-114 n1_333722_417840 n1_355914_417840 3.96286
R11-652-115 n1_355914_417840 n1_378410_417840 4.0171399999999995
R11-652-116 n1_378410_417840 n1_400602_417840 3.96286
R11-652-117 n1_400602_417840 n1_422794_417840 3.96286
R11-652-118 n1_422794_417840 n1_445290_417840 4.0171399999999995
R11-652-119 n1_445290_417840 n1_467482_417840 3.96286
R11-652-120 n1_467482_417840 n1_489978_417840 4.0171399999999995
R11-652-121 n1_489978_417840 n1_512170_417840 3.96286
R11-652-122 n1_512170_417840 n1_534666_417840 4.0171399999999995
R11-652-123 n1_534666_417840 n1_556858_417840 3.96286
R11-652-124 n1_556858_417840 n1_579050_417840 3.96286
R11-652-125 n1_579050_417840 n1_601546_417840 4.0171399999999995
R11-652-126 n1_601546_417840 n1_623064_417840 3.8425
R11-652-127 n1_623064_417840 n1_625064_417840 0.357143
R11-653-100 n1_623064_417840 n1_625064_417840 0.333333
R11-653-101 n1_625064_417840 n1_627064_417840 0.357143
R11-654-100 n1_625064_417840 n1_627064_417840 0.333333
R11-655-100 n1_44000_421184 n1_46000_421184 0.333333
R11-656-100 n1_44000_421184 n1_46000_421184 0.357143
R11-656-101 n1_46000_421184 n1_48000_421184 0.333333
R11-657-100 n1_46000_421184 n1_48000_421184 0.357143
R11-657-101 n1_48000_421184 n1_65594_421184 3.14179
R11-657-102 n1_65594_421184 n1_88090_421184 4.0171399999999995
R11-657-103 n1_88090_421184 n1_110282_421184 3.96286
R11-657-104 n1_110282_421184 n1_132778_421184 4.0171399999999995
R11-657-105 n1_132778_421184 n1_154970_421184 3.96286
R11-657-106 n1_154970_421184 n1_177466_421184 4.0171399999999995
R11-657-107 n1_177466_421184 n1_199658_421184 3.96286
R11-657-108 n1_199658_421184 n1_221850_421184 3.96286
R11-657-109 n1_221850_421184 n1_244346_421184 4.0171399999999995
R11-657-110 n1_244346_421184 n1_266538_421184 3.96286
R11-657-111 n1_266538_421184 n1_289034_421184 4.0171399999999995
R11-657-112 n1_289034_421184 n1_311226_421184 3.96286
R11-657-113 n1_311226_421184 n1_333722_421184 4.0171399999999995
R11-657-114 n1_333722_421184 n1_355914_421184 3.96286
R11-657-115 n1_355914_421184 n1_378410_421184 4.0171399999999995
R11-657-116 n1_378410_421184 n1_400602_421184 3.96286
R11-657-117 n1_400602_421184 n1_422794_421184 3.96286
R11-657-118 n1_422794_421184 n1_445290_421184 4.0171399999999995
R11-657-119 n1_445290_421184 n1_467482_421184 3.96286
R11-657-120 n1_467482_421184 n1_489978_421184 4.0171399999999995
R11-657-121 n1_489978_421184 n1_512170_421184 3.96286
R11-657-122 n1_512170_421184 n1_534666_421184 4.0171399999999995
R11-657-123 n1_534666_421184 n1_556858_421184 3.96286
R11-657-124 n1_556858_421184 n1_579050_421184 3.96286
R11-657-125 n1_579050_421184 n1_601546_421184 4.0171399999999995
R11-657-126 n1_601546_421184 n1_623064_421184 3.8425
R11-657-127 n1_623064_421184 n1_625064_421184 0.357143
R11-658-100 n1_623064_421184 n1_625064_421184 0.333333
R11-658-101 n1_625064_421184 n1_627064_421184 0.357143
R11-659-100 n1_625064_421184 n1_627064_421184 0.333333
R11-660-100 n1_44000_424528 n1_46000_424528 0.333333
R11-661-100 n1_44000_424528 n1_46000_424528 0.357143
R11-661-101 n1_46000_424528 n1_48000_424528 0.333333
R11-662-100 n1_46000_424528 n1_48000_424528 0.357143
R11-662-101 n1_48000_424528 n1_65594_424528 3.14179
R11-662-102 n1_65594_424528 n1_88090_424528 4.0171399999999995
R11-662-103 n1_88090_424528 n1_110282_424528 3.96286
R11-662-104 n1_110282_424528 n1_132778_424528 4.0171399999999995
R11-662-105 n1_132778_424528 n1_154970_424528 3.96286
R11-662-106 n1_154970_424528 n1_177466_424528 4.0171399999999995
R11-662-107 n1_177466_424528 n1_199658_424528 3.96286
R11-662-108 n1_199658_424528 n1_221850_424528 3.96286
R11-662-109 n1_221850_424528 n1_244346_424528 4.0171399999999995
R11-662-110 n1_244346_424528 n1_266538_424528 3.96286
R11-662-111 n1_266538_424528 n1_289034_424528 4.0171399999999995
R11-662-112 n1_289034_424528 n1_311226_424528 3.96286
R11-662-113 n1_311226_424528 n1_333722_424528 4.0171399999999995
R11-662-114 n1_333722_424528 n1_355914_424528 3.96286
R11-662-115 n1_355914_424528 n1_378410_424528 4.0171399999999995
R11-662-116 n1_378410_424528 n1_400602_424528 3.96286
R11-662-117 n1_400602_424528 n1_422794_424528 3.96286
R11-662-118 n1_422794_424528 n1_445290_424528 4.0171399999999995
R11-662-119 n1_445290_424528 n1_467482_424528 3.96286
R11-662-120 n1_467482_424528 n1_489978_424528 4.0171399999999995
R11-662-121 n1_489978_424528 n1_512170_424528 3.96286
R11-662-122 n1_512170_424528 n1_534666_424528 4.0171399999999995
R11-662-123 n1_534666_424528 n1_556858_424528 3.96286
R11-662-124 n1_556858_424528 n1_579050_424528 3.96286
R11-662-125 n1_579050_424528 n1_601546_424528 4.0171399999999995
R11-662-126 n1_601546_424528 n1_623064_424528 3.8425
R11-662-127 n1_623064_424528 n1_625064_424528 0.357143
R11-663-100 n1_623064_424528 n1_625064_424528 0.333333
R11-663-101 n1_625064_424528 n1_627064_424528 0.357143
R11-664-100 n1_625064_424528 n1_627064_424528 0.333333
R11-665-100 n1_44000_427872 n1_46000_427872 0.333333
R11-666-100 n1_44000_427872 n1_46000_427872 0.357143
R11-666-101 n1_46000_427872 n1_48000_427872 0.333333
R11-667-100 n1_46000_427872 n1_48000_427872 0.357143
R11-667-101 n1_48000_427872 n1_65594_427872 3.14179
R11-667-102 n1_65594_427872 n1_88090_427872 4.0171399999999995
R11-667-103 n1_88090_427872 n1_110282_427872 3.96286
R11-667-104 n1_110282_427872 n1_132778_427872 4.0171399999999995
R11-667-105 n1_132778_427872 n1_154970_427872 3.96286
R11-667-106 n1_154970_427872 n1_177466_427872 4.0171399999999995
R11-667-107 n1_177466_427872 n1_199658_427872 3.96286
R11-667-108 n1_199658_427872 n1_221850_427872 3.96286
R11-667-109 n1_221850_427872 n1_244346_427872 4.0171399999999995
R11-667-110 n1_244346_427872 n1_266538_427872 3.96286
R11-667-111 n1_266538_427872 n1_289034_427872 4.0171399999999995
R11-667-112 n1_289034_427872 n1_311226_427872 3.96286
R11-667-113 n1_311226_427872 n1_333722_427872 4.0171399999999995
R11-667-114 n1_333722_427872 n1_355914_427872 3.96286
R11-667-115 n1_355914_427872 n1_378410_427872 4.0171399999999995
R11-667-116 n1_378410_427872 n1_400602_427872 3.96286
R11-667-117 n1_400602_427872 n1_422794_427872 3.96286
R11-667-118 n1_422794_427872 n1_445290_427872 4.0171399999999995
R11-667-119 n1_445290_427872 n1_467482_427872 3.96286
R11-667-120 n1_467482_427872 n1_489978_427872 4.0171399999999995
R11-667-121 n1_489978_427872 n1_512170_427872 3.96286
R11-667-122 n1_512170_427872 n1_534666_427872 4.0171399999999995
R11-667-123 n1_534666_427872 n1_556858_427872 3.96286
R11-667-124 n1_556858_427872 n1_579050_427872 3.96286
R11-667-125 n1_579050_427872 n1_601546_427872 4.0171399999999995
R11-667-126 n1_601546_427872 n1_623064_427872 3.8425
R11-667-127 n1_623064_427872 n1_625064_427872 0.357143
R11-668-100 n1_623064_427872 n1_625064_427872 0.333333
R11-668-101 n1_625064_427872 n1_627064_427872 0.357143
R11-669-100 n1_625064_427872 n1_627064_427872 0.333333
R11-670-100 n1_44000_431216 n1_46000_431216 0.333333
R11-671-100 n1_44000_431216 n1_46000_431216 0.357143
R11-671-101 n1_46000_431216 n1_48000_431216 0.333333
R11-672-100 n1_46000_431216 n1_48000_431216 0.357143
R11-672-101 n1_48000_431216 n1_65594_431216 3.14179
R11-672-102 n1_65594_431216 n1_88090_431216 4.0171399999999995
R11-672-103 n1_88090_431216 n1_110282_431216 3.96286
R11-672-104 n1_110282_431216 n1_132778_431216 4.0171399999999995
R11-672-105 n1_132778_431216 n1_154970_431216 3.96286
R11-672-106 n1_154970_431216 n1_177466_431216 4.0171399999999995
R11-672-107 n1_177466_431216 n1_199658_431216 3.96286
R11-672-108 n1_199658_431216 n1_221850_431216 3.96286
R11-672-109 n1_221850_431216 n1_244346_431216 4.0171399999999995
R11-672-110 n1_244346_431216 n1_266538_431216 3.96286
R11-672-111 n1_266538_431216 n1_289034_431216 4.0171399999999995
R11-672-112 n1_289034_431216 n1_311226_431216 3.96286
R11-672-113 n1_311226_431216 n1_333722_431216 4.0171399999999995
R11-672-114 n1_333722_431216 n1_355914_431216 3.96286
R11-672-115 n1_355914_431216 n1_378410_431216 4.0171399999999995
R11-672-116 n1_378410_431216 n1_400602_431216 3.96286
R11-672-117 n1_400602_431216 n1_422794_431216 3.96286
R11-672-118 n1_422794_431216 n1_445290_431216 4.0171399999999995
R11-672-119 n1_445290_431216 n1_467482_431216 3.96286
R11-672-120 n1_467482_431216 n1_489978_431216 4.0171399999999995
R11-672-121 n1_489978_431216 n1_512170_431216 3.96286
R11-672-122 n1_512170_431216 n1_534666_431216 4.0171399999999995
R11-672-123 n1_534666_431216 n1_556858_431216 3.96286
R11-672-124 n1_556858_431216 n1_579050_431216 3.96286
R11-672-125 n1_579050_431216 n1_601546_431216 4.0171399999999995
R11-672-126 n1_601546_431216 n1_623064_431216 3.8425
R11-672-127 n1_623064_431216 n1_625064_431216 0.357143
R11-673-100 n1_623064_431216 n1_625064_431216 0.333333
R11-673-101 n1_625064_431216 n1_627064_431216 0.357143
R11-674-100 n1_625064_431216 n1_627064_431216 0.333333
R11-675-100 n1_44000_434560 n1_46000_434560 0.333333
R11-676-100 n1_44000_434560 n1_46000_434560 0.357143
R11-676-101 n1_46000_434560 n1_48000_434560 0.333333
R11-677-100 n1_46000_434560 n1_48000_434560 0.357143
R11-677-101 n1_48000_434560 n1_65594_434560 3.14179
R11-677-102 n1_65594_434560 n1_88090_434560 4.0171399999999995
R11-677-103 n1_88090_434560 n1_110282_434560 3.96286
R11-677-104 n1_110282_434560 n1_132778_434560 4.0171399999999995
R11-677-105 n1_132778_434560 n1_154970_434560 3.96286
R11-677-106 n1_154970_434560 n1_177466_434560 4.0171399999999995
R11-677-107 n1_177466_434560 n1_199658_434560 3.96286
R11-677-108 n1_199658_434560 n1_221850_434560 3.96286
R11-677-109 n1_221850_434560 n1_244346_434560 4.0171399999999995
R11-677-110 n1_244346_434560 n1_266538_434560 3.96286
R11-677-111 n1_266538_434560 n1_289034_434560 4.0171399999999995
R11-677-112 n1_289034_434560 n1_311226_434560 3.96286
R11-677-113 n1_311226_434560 n1_333722_434560 4.0171399999999995
R11-677-114 n1_333722_434560 n1_355914_434560 3.96286
R11-677-115 n1_355914_434560 n1_378410_434560 4.0171399999999995
R11-677-116 n1_378410_434560 n1_400602_434560 3.96286
R11-677-117 n1_400602_434560 n1_422794_434560 3.96286
R11-677-118 n1_422794_434560 n1_445290_434560 4.0171399999999995
R11-677-119 n1_445290_434560 n1_467482_434560 3.96286
R11-677-120 n1_467482_434560 n1_489978_434560 4.0171399999999995
R11-677-121 n1_489978_434560 n1_512170_434560 3.96286
R11-677-122 n1_512170_434560 n1_534666_434560 4.0171399999999995
R11-677-123 n1_534666_434560 n1_556858_434560 3.96286
R11-677-124 n1_556858_434560 n1_579050_434560 3.96286
R11-677-125 n1_579050_434560 n1_601546_434560 4.0171399999999995
R11-677-126 n1_601546_434560 n1_623064_434560 3.8425
R11-677-127 n1_623064_434560 n1_625064_434560 0.357143
R11-678-100 n1_623064_434560 n1_625064_434560 0.333333
R11-678-101 n1_625064_434560 n1_627064_434560 0.357143
R11-679-100 n1_625064_434560 n1_627064_434560 0.333333
R11-680-100 n1_44000_437904 n1_46000_437904 0.333333
R11-681-100 n1_44000_437904 n1_46000_437904 0.357143
R11-681-101 n1_46000_437904 n1_48000_437904 0.333333
R11-682-100 n1_46000_437904 n1_48000_437904 0.357143
R11-682-101 n1_48000_437904 n1_65594_437904 3.14179
R11-682-102 n1_65594_437904 n1_88090_437904 4.0171399999999995
R11-682-103 n1_88090_437904 n1_110282_437904 3.96286
R11-682-104 n1_110282_437904 n1_132778_437904 4.0171399999999995
R11-682-105 n1_132778_437904 n1_154970_437904 3.96286
R11-682-106 n1_154970_437904 n1_177466_437904 4.0171399999999995
R11-682-107 n1_177466_437904 n1_199658_437904 3.96286
R11-682-108 n1_199658_437904 n1_221850_437904 3.96286
R11-682-109 n1_221850_437904 n1_244346_437904 4.0171399999999995
R11-682-110 n1_244346_437904 n1_266538_437904 3.96286
R11-682-111 n1_266538_437904 n1_289034_437904 4.0171399999999995
R11-682-112 n1_289034_437904 n1_311226_437904 3.96286
R11-682-113 n1_311226_437904 n1_333722_437904 4.0171399999999995
R11-682-114 n1_333722_437904 n1_355914_437904 3.96286
R11-682-115 n1_355914_437904 n1_378410_437904 4.0171399999999995
R11-682-116 n1_378410_437904 n1_400602_437904 3.96286
R11-682-117 n1_400602_437904 n1_422794_437904 3.96286
R11-682-118 n1_422794_437904 n1_445290_437904 4.0171399999999995
R11-682-119 n1_445290_437904 n1_467482_437904 3.96286
R11-682-120 n1_467482_437904 n1_489978_437904 4.0171399999999995
R11-682-121 n1_489978_437904 n1_512170_437904 3.96286
R11-682-122 n1_512170_437904 n1_534666_437904 4.0171399999999995
R11-682-123 n1_534666_437904 n1_556858_437904 3.96286
R11-682-124 n1_556858_437904 n1_579050_437904 3.96286
R11-682-125 n1_579050_437904 n1_601546_437904 4.0171399999999995
R11-682-126 n1_601546_437904 n1_623064_437904 3.8425
R11-682-127 n1_623064_437904 n1_625064_437904 0.357143
R11-683-100 n1_623064_437904 n1_625064_437904 0.333333
R11-683-101 n1_625064_437904 n1_627064_437904 0.357143
R11-684-100 n1_625064_437904 n1_627064_437904 0.333333
R11-685-100 n1_44000_441248 n1_46000_441248 0.333333
R11-686-100 n1_44000_441248 n1_46000_441248 0.357143
R11-686-101 n1_46000_441248 n1_48000_441248 0.333333
R11-687-100 n1_46000_441248 n1_48000_441248 0.357143
R11-687-101 n1_48000_441248 n1_65594_441248 3.14179
R11-687-102 n1_65594_441248 n1_88090_441248 4.0171399999999995
R11-687-103 n1_88090_441248 n1_110282_441248 3.96286
R11-687-104 n1_110282_441248 n1_132778_441248 4.0171399999999995
R11-687-105 n1_132778_441248 n1_154970_441248 3.96286
R11-687-106 n1_154970_441248 n1_177466_441248 4.0171399999999995
R11-687-107 n1_177466_441248 n1_199658_441248 3.96286
R11-687-108 n1_199658_441248 n1_221850_441248 3.96286
R11-687-109 n1_221850_441248 n1_244346_441248 4.0171399999999995
R11-687-110 n1_244346_441248 n1_266538_441248 3.96286
R11-687-111 n1_266538_441248 n1_289034_441248 4.0171399999999995
R11-687-112 n1_289034_441248 n1_311226_441248 3.96286
R11-687-113 n1_311226_441248 n1_333722_441248 4.0171399999999995
R11-687-114 n1_333722_441248 n1_355914_441248 3.96286
R11-687-115 n1_355914_441248 n1_378410_441248 4.0171399999999995
R11-687-116 n1_378410_441248 n1_400602_441248 3.96286
R11-687-117 n1_400602_441248 n1_422794_441248 3.96286
R11-687-118 n1_422794_441248 n1_445290_441248 4.0171399999999995
R11-687-119 n1_445290_441248 n1_467482_441248 3.96286
R11-687-120 n1_467482_441248 n1_489978_441248 4.0171399999999995
R11-687-121 n1_489978_441248 n1_512170_441248 3.96286
R11-687-122 n1_512170_441248 n1_534666_441248 4.0171399999999995
R11-687-123 n1_534666_441248 n1_556858_441248 3.96286
R11-687-124 n1_556858_441248 n1_579050_441248 3.96286
R11-687-125 n1_579050_441248 n1_601546_441248 4.0171399999999995
R11-687-126 n1_601546_441248 n1_623064_441248 3.8425
R11-687-127 n1_623064_441248 n1_625064_441248 0.357143
R11-688-100 n1_623064_441248 n1_625064_441248 0.333333
R11-688-101 n1_625064_441248 n1_627064_441248 0.357143
R11-689-100 n1_625064_441248 n1_627064_441248 0.333333
R11-690-100 n1_44000_444592 n1_46000_444592 0.333333
R11-691-100 n1_44000_444592 n1_46000_444592 0.357143
R11-691-101 n1_46000_444592 n1_48000_444592 0.333333
R11-692-100 n1_46000_444592 n1_48000_444592 0.357143
R11-692-101 n1_48000_444592 n1_65594_444592 3.14179
R11-692-102 n1_65594_444592 n1_88090_444592 4.0171399999999995
R11-692-103 n1_88090_444592 n1_110282_444592 3.96286
R11-692-104 n1_110282_444592 n1_132778_444592 4.0171399999999995
R11-692-105 n1_132778_444592 n1_154970_444592 3.96286
R11-692-106 n1_154970_444592 n1_177466_444592 4.0171399999999995
R11-692-107 n1_177466_444592 n1_199658_444592 3.96286
R11-692-108 n1_199658_444592 n1_221850_444592 3.96286
R11-692-109 n1_221850_444592 n1_244346_444592 4.0171399999999995
R11-692-110 n1_244346_444592 n1_266538_444592 3.96286
R11-692-111 n1_266538_444592 n1_289034_444592 4.0171399999999995
R11-692-112 n1_289034_444592 n1_311226_444592 3.96286
R11-692-113 n1_311226_444592 n1_333722_444592 4.0171399999999995
R11-692-114 n1_333722_444592 n1_355914_444592 3.96286
R11-692-115 n1_355914_444592 n1_378410_444592 4.0171399999999995
R11-692-116 n1_378410_444592 n1_400602_444592 3.96286
R11-692-117 n1_400602_444592 n1_422794_444592 3.96286
R11-692-118 n1_422794_444592 n1_445290_444592 4.0171399999999995
R11-692-119 n1_445290_444592 n1_467482_444592 3.96286
R11-692-120 n1_467482_444592 n1_489978_444592 4.0171399999999995
R11-692-121 n1_489978_444592 n1_512170_444592 3.96286
R11-692-122 n1_512170_444592 n1_534666_444592 4.0171399999999995
R11-692-123 n1_534666_444592 n1_556858_444592 3.96286
R11-692-124 n1_556858_444592 n1_579050_444592 3.96286
R11-692-125 n1_579050_444592 n1_601546_444592 4.0171399999999995
R11-692-126 n1_601546_444592 n1_623064_444592 3.8425
R11-692-127 n1_623064_444592 n1_625064_444592 0.357143
R11-693-100 n1_623064_444592 n1_625064_444592 0.333333
R11-693-101 n1_625064_444592 n1_627064_444592 0.357143
R11-694-100 n1_625064_444592 n1_627064_444592 0.333333
R11-695-100 n1_44000_447936 n1_46000_447936 0.333333
R11-696-100 n1_44000_447936 n1_46000_447936 0.357143
R11-696-101 n1_46000_447936 n1_48000_447936 0.333333
R11-697-100 n1_46000_447936 n1_48000_447936 0.357143
R11-697-101 n1_48000_447936 n1_65594_447936 3.14179
R11-697-102 n1_65594_447936 n1_88090_447936 4.0171399999999995
R11-697-103 n1_88090_447936 n1_110282_447936 3.96286
R11-697-104 n1_110282_447936 n1_132778_447936 4.0171399999999995
R11-697-105 n1_132778_447936 n1_154970_447936 3.96286
R11-697-106 n1_154970_447936 n1_177466_447936 4.0171399999999995
R11-697-107 n1_177466_447936 n1_199658_447936 3.96286
R11-697-108 n1_199658_447936 n1_221850_447936 3.96286
R11-697-109 n1_221850_447936 n1_244346_447936 4.0171399999999995
R11-697-110 n1_244346_447936 n1_266538_447936 3.96286
R11-697-111 n1_266538_447936 n1_289034_447936 4.0171399999999995
R11-697-112 n1_289034_447936 n1_311226_447936 3.96286
R11-697-113 n1_311226_447936 n1_333722_447936 4.0171399999999995
R11-697-114 n1_333722_447936 n1_355914_447936 3.96286
R11-697-115 n1_355914_447936 n1_378410_447936 4.0171399999999995
R11-697-116 n1_378410_447936 n1_400602_447936 3.96286
R11-697-117 n1_400602_447936 n1_422794_447936 3.96286
R11-697-118 n1_422794_447936 n1_445290_447936 4.0171399999999995
R11-697-119 n1_445290_447936 n1_467482_447936 3.96286
R11-697-120 n1_467482_447936 n1_489978_447936 4.0171399999999995
R11-697-121 n1_489978_447936 n1_512170_447936 3.96286
R11-697-122 n1_512170_447936 n1_534666_447936 4.0171399999999995
R11-697-123 n1_534666_447936 n1_556858_447936 3.96286
R11-697-124 n1_556858_447936 n1_579050_447936 3.96286
R11-697-125 n1_579050_447936 n1_601546_447936 4.0171399999999995
R11-697-126 n1_601546_447936 n1_623064_447936 3.8425
R11-697-127 n1_623064_447936 n1_625064_447936 0.357143
R11-698-100 n1_623064_447936 n1_625064_447936 0.333333
R11-698-101 n1_625064_447936 n1_627064_447936 0.357143
R11-699-100 n1_625064_447936 n1_627064_447936 0.333333
R11-700-100 n1_44000_451280 n1_46000_451280 0.333333
R11-701-100 n1_44000_451280 n1_46000_451280 0.357143
R11-701-101 n1_46000_451280 n1_48000_451280 0.333333
R11-702-100 n1_46000_451280 n1_48000_451280 0.357143
R11-702-101 n1_48000_451280 n1_65594_451280 3.14179
R11-702-102 n1_65594_451280 n1_88090_451280 4.0171399999999995
R11-702-103 n1_88090_451280 n1_110282_451280 3.96286
R11-702-104 n1_110282_451280 n1_132778_451280 4.0171399999999995
R11-702-105 n1_132778_451280 n1_154970_451280 3.96286
R11-702-106 n1_154970_451280 n1_177466_451280 4.0171399999999995
R11-702-107 n1_177466_451280 n1_199658_451280 3.96286
R11-702-108 n1_199658_451280 n1_221850_451280 3.96286
R11-702-109 n1_221850_451280 n1_244346_451280 4.0171399999999995
R11-702-110 n1_244346_451280 n1_266538_451280 3.96286
R11-702-111 n1_266538_451280 n1_289034_451280 4.0171399999999995
R11-702-112 n1_289034_451280 n1_311226_451280 3.96286
R11-702-113 n1_311226_451280 n1_333722_451280 4.0171399999999995
R11-702-114 n1_333722_451280 n1_355914_451280 3.96286
R11-702-115 n1_355914_451280 n1_378410_451280 4.0171399999999995
R11-702-116 n1_378410_451280 n1_400602_451280 3.96286
R11-702-117 n1_400602_451280 n1_422794_451280 3.96286
R11-702-118 n1_422794_451280 n1_445290_451280 4.0171399999999995
R11-702-119 n1_445290_451280 n1_467482_451280 3.96286
R11-702-120 n1_467482_451280 n1_489978_451280 4.0171399999999995
R11-702-121 n1_489978_451280 n1_512170_451280 3.96286
R11-702-122 n1_512170_451280 n1_534666_451280 4.0171399999999995
R11-702-123 n1_534666_451280 n1_556858_451280 3.96286
R11-702-124 n1_556858_451280 n1_579050_451280 3.96286
R11-702-125 n1_579050_451280 n1_601546_451280 4.0171399999999995
R11-702-126 n1_601546_451280 n1_623064_451280 3.8425
R11-702-127 n1_623064_451280 n1_625064_451280 0.357143
R11-703-100 n1_623064_451280 n1_625064_451280 0.333333
R11-703-101 n1_625064_451280 n1_627064_451280 0.357143
R11-704-100 n1_625064_451280 n1_627064_451280 0.333333
R11-705-100 n1_44000_454624 n1_46000_454624 0.333333
R11-706-100 n1_44000_454624 n1_46000_454624 0.357143
R11-706-101 n1_46000_454624 n1_48000_454624 0.333333
R11-707-100 n1_46000_454624 n1_48000_454624 0.357143
R11-707-101 n1_48000_454624 n1_65594_454624 3.14179
R11-707-102 n1_65594_454624 n1_88090_454624 4.0171399999999995
R11-707-103 n1_88090_454624 n1_110282_454624 3.96286
R11-707-104 n1_110282_454624 n1_132778_454624 4.0171399999999995
R11-707-105 n1_132778_454624 n1_154970_454624 3.96286
R11-707-106 n1_154970_454624 n1_177466_454624 4.0171399999999995
R11-707-107 n1_177466_454624 n1_199658_454624 3.96286
R11-707-108 n1_199658_454624 n1_221850_454624 3.96286
R11-707-109 n1_221850_454624 n1_244346_454624 4.0171399999999995
R11-707-110 n1_244346_454624 n1_266538_454624 3.96286
R11-707-111 n1_266538_454624 n1_289034_454624 4.0171399999999995
R11-707-112 n1_289034_454624 n1_311226_454624 3.96286
R11-707-113 n1_311226_454624 n1_333722_454624 4.0171399999999995
R11-707-114 n1_333722_454624 n1_355914_454624 3.96286
R11-707-115 n1_355914_454624 n1_378410_454624 4.0171399999999995
R11-707-116 n1_378410_454624 n1_400602_454624 3.96286
R11-707-117 n1_400602_454624 n1_422794_454624 3.96286
R11-707-118 n1_422794_454624 n1_445290_454624 4.0171399999999995
R11-707-119 n1_445290_454624 n1_467482_454624 3.96286
R11-707-120 n1_467482_454624 n1_489978_454624 4.0171399999999995
R11-707-121 n1_489978_454624 n1_512170_454624 3.96286
R11-707-122 n1_512170_454624 n1_534666_454624 4.0171399999999995
R11-707-123 n1_534666_454624 n1_556858_454624 3.96286
R11-707-124 n1_556858_454624 n1_579050_454624 3.96286
R11-707-125 n1_579050_454624 n1_601546_454624 4.0171399999999995
R11-707-126 n1_601546_454624 n1_623064_454624 3.8425
R11-707-127 n1_623064_454624 n1_625064_454624 0.357143
R11-708-100 n1_623064_454624 n1_625064_454624 0.333333
R11-708-101 n1_625064_454624 n1_627064_454624 0.357143
R11-709-100 n1_625064_454624 n1_627064_454624 0.333333
R11-710-100 n1_44000_457968 n1_46000_457968 0.333333
R11-711-100 n1_44000_457968 n1_46000_457968 0.357143
R11-711-101 n1_46000_457968 n1_48000_457968 0.333333
R11-712-100 n1_46000_457968 n1_48000_457968 0.357143
R11-712-101 n1_48000_457968 n1_65594_457968 3.14179
R11-712-102 n1_65594_457968 n1_88090_457968 4.0171399999999995
R11-712-103 n1_88090_457968 n1_110282_457968 3.96286
R11-712-104 n1_110282_457968 n1_132778_457968 4.0171399999999995
R11-712-105 n1_132778_457968 n1_154970_457968 3.96286
R11-712-106 n1_154970_457968 n1_177466_457968 4.0171399999999995
R11-712-107 n1_177466_457968 n1_199658_457968 3.96286
R11-712-108 n1_199658_457968 n1_221850_457968 3.96286
R11-712-109 n1_221850_457968 n1_244346_457968 4.0171399999999995
R11-712-110 n1_244346_457968 n1_266538_457968 3.96286
R11-712-111 n1_266538_457968 n1_289034_457968 4.0171399999999995
R11-712-112 n1_289034_457968 n1_311226_457968 3.96286
R11-712-113 n1_311226_457968 n1_333722_457968 4.0171399999999995
R11-712-114 n1_333722_457968 n1_355914_457968 3.96286
R11-712-115 n1_355914_457968 n1_378410_457968 4.0171399999999995
R11-712-116 n1_378410_457968 n1_400602_457968 3.96286
R11-712-117 n1_400602_457968 n1_422794_457968 3.96286
R11-712-118 n1_422794_457968 n1_445290_457968 4.0171399999999995
R11-712-119 n1_445290_457968 n1_467482_457968 3.96286
R11-712-120 n1_467482_457968 n1_489978_457968 4.0171399999999995
R11-712-121 n1_489978_457968 n1_512170_457968 3.96286
R11-712-122 n1_512170_457968 n1_534666_457968 4.0171399999999995
R11-712-123 n1_534666_457968 n1_556858_457968 3.96286
R11-712-124 n1_556858_457968 n1_579050_457968 3.96286
R11-712-125 n1_579050_457968 n1_601546_457968 4.0171399999999995
R11-712-126 n1_601546_457968 n1_623064_457968 3.8425
R11-712-127 n1_623064_457968 n1_625064_457968 0.357143
R11-713-100 n1_623064_457968 n1_625064_457968 0.333333
R11-713-101 n1_625064_457968 n1_627064_457968 0.357143
R11-714-100 n1_625064_457968 n1_627064_457968 0.333333
R11-715-100 n1_44000_461312 n1_46000_461312 0.333333
R11-716-100 n1_44000_461312 n1_46000_461312 0.357143
R11-716-101 n1_46000_461312 n1_48000_461312 0.333333
R11-717-100 n1_46000_461312 n1_48000_461312 0.357143
R11-717-101 n1_48000_461312 n1_65594_461312 3.14179
R11-717-102 n1_65594_461312 n1_88090_461312 4.0171399999999995
R11-717-103 n1_88090_461312 n1_110282_461312 3.96286
R11-717-104 n1_110282_461312 n1_132778_461312 4.0171399999999995
R11-717-105 n1_132778_461312 n1_154970_461312 3.96286
R11-717-106 n1_154970_461312 n1_177466_461312 4.0171399999999995
R11-717-107 n1_177466_461312 n1_199658_461312 3.96286
R11-717-108 n1_199658_461312 n1_221850_461312 3.96286
R11-717-109 n1_221850_461312 n1_244346_461312 4.0171399999999995
R11-717-110 n1_244346_461312 n1_266538_461312 3.96286
R11-717-111 n1_266538_461312 n1_289034_461312 4.0171399999999995
R11-717-112 n1_289034_461312 n1_311226_461312 3.96286
R11-717-113 n1_311226_461312 n1_333722_461312 4.0171399999999995
R11-717-114 n1_333722_461312 n1_355914_461312 3.96286
R11-717-115 n1_355914_461312 n1_378410_461312 4.0171399999999995
R11-717-116 n1_378410_461312 n1_400602_461312 3.96286
R11-717-117 n1_400602_461312 n1_422794_461312 3.96286
R11-717-118 n1_422794_461312 n1_445290_461312 4.0171399999999995
R11-717-119 n1_445290_461312 n1_467482_461312 3.96286
R11-717-120 n1_467482_461312 n1_489978_461312 4.0171399999999995
R11-717-121 n1_489978_461312 n1_512170_461312 3.96286
R11-717-122 n1_512170_461312 n1_534666_461312 4.0171399999999995
R11-717-123 n1_534666_461312 n1_556858_461312 3.96286
R11-717-124 n1_556858_461312 n1_579050_461312 3.96286
R11-717-125 n1_579050_461312 n1_601546_461312 4.0171399999999995
R11-717-126 n1_601546_461312 n1_623064_461312 3.8425
R11-717-127 n1_623064_461312 n1_625064_461312 0.357143
R11-718-100 n1_623064_461312 n1_625064_461312 0.333333
R11-718-101 n1_625064_461312 n1_627064_461312 0.357143
R11-719-100 n1_625064_461312 n1_627064_461312 0.333333
R11-720-100 n1_44000_464656 n1_46000_464656 0.357143
R11-721-100 n1_44000_464656 n1_46000_464656 0.333333
R11-721-101 n1_46000_464656 n1_48000_464656 0.357143
R11-722-100 n1_46000_464656 n1_48000_464656 0.333333
R11-722-101 n1_48000_464656 n1_65594_464656 3.14179
R11-722-102 n1_65594_464656 n1_88090_464656 4.0171399999999995
R11-722-103 n1_88090_464656 n1_110282_464656 3.96286
R11-722-104 n1_110282_464656 n1_132778_464656 4.0171399999999995
R11-722-105 n1_132778_464656 n1_154970_464656 3.96286
R11-722-106 n1_154970_464656 n1_177466_464656 4.0171399999999995
R11-722-107 n1_177466_464656 n1_199658_464656 3.96286
R11-722-108 n1_199658_464656 n1_221850_464656 3.96286
R11-722-109 n1_221850_464656 n1_244346_464656 4.0171399999999995
R11-722-110 n1_244346_464656 n1_266538_464656 3.96286
R11-722-111 n1_266538_464656 n1_289034_464656 4.0171399999999995
R11-722-112 n1_289034_464656 n1_311226_464656 3.96286
R11-722-113 n1_311226_464656 n1_333722_464656 4.0171399999999995
R11-722-114 n1_333722_464656 n1_355914_464656 3.96286
R11-722-115 n1_355914_464656 n1_378410_464656 4.0171399999999995
R11-722-116 n1_378410_464656 n1_400602_464656 3.96286
R11-722-117 n1_400602_464656 n1_422794_464656 3.96286
R11-722-118 n1_422794_464656 n1_445290_464656 4.0171399999999995
R11-722-119 n1_445290_464656 n1_467482_464656 3.96286
R11-722-120 n1_467482_464656 n1_489978_464656 4.0171399999999995
R11-722-121 n1_489978_464656 n1_512170_464656 3.96286
R11-722-122 n1_512170_464656 n1_534666_464656 4.0171399999999995
R11-722-123 n1_534666_464656 n1_556858_464656 3.96286
R11-722-124 n1_556858_464656 n1_579050_464656 3.96286
R11-722-125 n1_579050_464656 n1_601546_464656 4.0171399999999995
R11-722-126 n1_601546_464656 n1_623064_464656 3.8425
R11-722-127 n1_623064_464656 n1_625064_464656 0.357143
R11-723-100 n1_623064_464656 n1_625064_464656 0.333333
R11-723-101 n1_625064_464656 n1_627064_464656 0.357143
R11-724-100 n1_625064_464656 n1_627064_464656 0.333333
R11-725-100 n1_44000_468000 n1_46000_468000 0.357143
R11-726-100 n1_44000_468000 n1_46000_468000 0.333333
R11-726-101 n1_46000_468000 n1_48000_468000 0.357143
R11-727-100 n1_46000_468000 n1_48000_468000 0.333333
R11-727-101 n1_48000_468000 n1_65594_468000 3.14179
R11-727-102 n1_65594_468000 n1_88090_468000 4.0171399999999995
R11-727-103 n1_88090_468000 n1_110282_468000 3.96286
R11-727-104 n1_110282_468000 n1_132778_468000 4.0171399999999995
R11-727-105 n1_132778_468000 n1_154970_468000 3.96286
R11-727-106 n1_154970_468000 n1_177466_468000 4.0171399999999995
R11-727-107 n1_177466_468000 n1_199658_468000 3.96286
R11-727-108 n1_199658_468000 n1_221850_468000 3.96286
R11-727-109 n1_221850_468000 n1_244346_468000 4.0171399999999995
R11-727-110 n1_244346_468000 n1_266538_468000 3.96286
R11-727-111 n1_266538_468000 n1_289034_468000 4.0171399999999995
R11-727-112 n1_289034_468000 n1_311226_468000 3.96286
R11-727-113 n1_311226_468000 n1_333722_468000 4.0171399999999995
R11-727-114 n1_333722_468000 n1_355914_468000 3.96286
R11-727-115 n1_355914_468000 n1_378410_468000 4.0171399999999995
R11-727-116 n1_378410_468000 n1_400602_468000 3.96286
R11-727-117 n1_400602_468000 n1_422794_468000 3.96286
R11-727-118 n1_422794_468000 n1_445290_468000 4.0171399999999995
R11-727-119 n1_445290_468000 n1_467482_468000 3.96286
R11-727-120 n1_467482_468000 n1_489978_468000 4.0171399999999995
R11-727-121 n1_489978_468000 n1_512170_468000 3.96286
R11-727-122 n1_512170_468000 n1_534666_468000 4.0171399999999995
R11-727-123 n1_534666_468000 n1_556858_468000 3.96286
R11-727-124 n1_556858_468000 n1_579050_468000 3.96286
R11-727-125 n1_579050_468000 n1_601546_468000 4.0171399999999995
R11-727-126 n1_601546_468000 n1_623064_468000 3.8425
R11-727-127 n1_623064_468000 n1_625064_468000 0.357143
R11-728-100 n1_623064_468000 n1_625064_468000 0.333333
R11-728-101 n1_625064_468000 n1_627064_468000 0.357143
R11-729-100 n1_625064_468000 n1_627064_468000 0.333333
R11-730-100 n1_44000_471344 n1_46000_471344 0.357143
R11-731-100 n1_44000_471344 n1_46000_471344 0.333333
R11-731-101 n1_46000_471344 n1_48000_471344 0.357143
R11-732-100 n1_46000_471344 n1_48000_471344 0.333333
R11-732-101 n1_48000_471344 n1_65594_471344 3.14179
R11-732-102 n1_65594_471344 n1_88090_471344 4.0171399999999995
R11-732-103 n1_88090_471344 n1_110282_471344 3.96286
R11-732-104 n1_110282_471344 n1_132778_471344 4.0171399999999995
R11-732-105 n1_132778_471344 n1_154970_471344 3.96286
R11-732-106 n1_154970_471344 n1_177466_471344 4.0171399999999995
R11-732-107 n1_177466_471344 n1_199658_471344 3.96286
R11-732-108 n1_199658_471344 n1_221850_471344 3.96286
R11-732-109 n1_221850_471344 n1_244346_471344 4.0171399999999995
R11-732-110 n1_244346_471344 n1_266538_471344 3.96286
R11-732-111 n1_266538_471344 n1_289034_471344 4.0171399999999995
R11-732-112 n1_289034_471344 n1_311226_471344 3.96286
R11-732-113 n1_311226_471344 n1_333722_471344 4.0171399999999995
R11-732-114 n1_333722_471344 n1_355914_471344 3.96286
R11-732-115 n1_355914_471344 n1_378410_471344 4.0171399999999995
R11-732-116 n1_378410_471344 n1_400602_471344 3.96286
R11-732-117 n1_400602_471344 n1_422794_471344 3.96286
R11-732-118 n1_422794_471344 n1_445290_471344 4.0171399999999995
R11-732-119 n1_445290_471344 n1_467482_471344 3.96286
R11-732-120 n1_467482_471344 n1_489978_471344 4.0171399999999995
R11-732-121 n1_489978_471344 n1_512170_471344 3.96286
R11-732-122 n1_512170_471344 n1_534666_471344 4.0171399999999995
R11-732-123 n1_534666_471344 n1_556858_471344 3.96286
R11-732-124 n1_556858_471344 n1_579050_471344 3.96286
R11-732-125 n1_579050_471344 n1_601546_471344 4.0171399999999995
R11-732-126 n1_601546_471344 n1_623064_471344 3.8425
R11-732-127 n1_623064_471344 n1_625064_471344 0.357143
R11-733-100 n1_623064_471344 n1_625064_471344 0.333333
R11-733-101 n1_625064_471344 n1_627064_471344 0.357143
R11-734-100 n1_625064_471344 n1_627064_471344 0.333333
R11-735-100 n1_44000_474688 n1_46000_474688 0.357143
R11-736-100 n1_44000_474688 n1_46000_474688 0.333333
R11-736-101 n1_46000_474688 n1_48000_474688 0.357143
R11-737-100 n1_46000_474688 n1_48000_474688 0.333333
R11-737-101 n1_48000_474688 n1_65594_474688 3.14179
R11-737-102 n1_65594_474688 n1_88090_474688 4.0171399999999995
R11-737-103 n1_88090_474688 n1_110282_474688 3.96286
R11-737-104 n1_110282_474688 n1_132778_474688 4.0171399999999995
R11-737-105 n1_132778_474688 n1_154970_474688 3.96286
R11-737-106 n1_154970_474688 n1_177466_474688 4.0171399999999995
R11-737-107 n1_177466_474688 n1_199658_474688 3.96286
R11-737-108 n1_199658_474688 n1_221850_474688 3.96286
R11-737-109 n1_221850_474688 n1_244346_474688 4.0171399999999995
R11-737-110 n1_244346_474688 n1_266538_474688 3.96286
R11-737-111 n1_266538_474688 n1_289034_474688 4.0171399999999995
R11-737-112 n1_289034_474688 n1_311226_474688 3.96286
R11-737-113 n1_311226_474688 n1_333722_474688 4.0171399999999995
R11-737-114 n1_333722_474688 n1_355914_474688 3.96286
R11-737-115 n1_355914_474688 n1_378410_474688 4.0171399999999995
R11-737-116 n1_378410_474688 n1_400602_474688 3.96286
R11-737-117 n1_400602_474688 n1_422794_474688 3.96286
R11-737-118 n1_422794_474688 n1_445290_474688 4.0171399999999995
R11-737-119 n1_445290_474688 n1_467482_474688 3.96286
R11-737-120 n1_467482_474688 n1_489978_474688 4.0171399999999995
R11-737-121 n1_489978_474688 n1_512170_474688 3.96286
R11-737-122 n1_512170_474688 n1_534666_474688 4.0171399999999995
R11-737-123 n1_534666_474688 n1_556858_474688 3.96286
R11-737-124 n1_556858_474688 n1_579050_474688 3.96286
R11-737-125 n1_579050_474688 n1_601546_474688 4.0171399999999995
R11-737-126 n1_601546_474688 n1_623064_474688 3.8425
R11-737-127 n1_623064_474688 n1_625064_474688 0.357143
R11-738-100 n1_623064_474688 n1_625064_474688 0.333333
R11-738-101 n1_625064_474688 n1_627064_474688 0.357143
R11-739-100 n1_625064_474688 n1_627064_474688 0.333333
R11-740-100 n1_44000_478032 n1_46000_478032 0.357143
R11-741-100 n1_44000_478032 n1_46000_478032 0.333333
R11-741-101 n1_46000_478032 n1_48000_478032 0.357143
R11-742-100 n1_46000_478032 n1_48000_478032 0.333333
R11-742-101 n1_48000_478032 n1_65594_478032 3.14179
R11-742-102 n1_65594_478032 n1_88090_478032 4.0171399999999995
R11-742-103 n1_88090_478032 n1_110282_478032 3.96286
R11-742-104 n1_110282_478032 n1_132778_478032 4.0171399999999995
R11-742-105 n1_132778_478032 n1_154970_478032 3.96286
R11-742-106 n1_154970_478032 n1_177466_478032 4.0171399999999995
R11-742-107 n1_177466_478032 n1_199658_478032 3.96286
R11-742-108 n1_199658_478032 n1_221850_478032 3.96286
R11-742-109 n1_221850_478032 n1_244346_478032 4.0171399999999995
R11-742-110 n1_244346_478032 n1_266538_478032 3.96286
R11-742-111 n1_266538_478032 n1_289034_478032 4.0171399999999995
R11-742-112 n1_289034_478032 n1_311226_478032 3.96286
R11-742-113 n1_311226_478032 n1_333722_478032 4.0171399999999995
R11-742-114 n1_333722_478032 n1_355914_478032 3.96286
R11-742-115 n1_355914_478032 n1_378410_478032 4.0171399999999995
R11-742-116 n1_378410_478032 n1_400602_478032 3.96286
R11-742-117 n1_400602_478032 n1_422794_478032 3.96286
R11-742-118 n1_422794_478032 n1_445290_478032 4.0171399999999995
R11-742-119 n1_445290_478032 n1_467482_478032 3.96286
R11-742-120 n1_467482_478032 n1_489978_478032 4.0171399999999995
R11-742-121 n1_489978_478032 n1_512170_478032 3.96286
R11-742-122 n1_512170_478032 n1_534666_478032 4.0171399999999995
R11-742-123 n1_534666_478032 n1_556858_478032 3.96286
R11-742-124 n1_556858_478032 n1_579050_478032 3.96286
R11-742-125 n1_579050_478032 n1_601546_478032 4.0171399999999995
R11-742-126 n1_601546_478032 n1_623064_478032 3.8425
R11-742-127 n1_623064_478032 n1_625064_478032 0.357143
R11-743-100 n1_623064_478032 n1_625064_478032 0.333333
R11-743-101 n1_625064_478032 n1_627064_478032 0.357143
R11-744-100 n1_625064_478032 n1_627064_478032 0.333333
R11-745-100 n1_44000_481376 n1_46000_481376 0.333333
R11-746-100 n1_44000_481376 n1_46000_481376 0.357143
R11-746-101 n1_46000_481376 n1_48000_481376 0.333333
R11-747-100 n1_46000_481376 n1_48000_481376 0.357143
R11-747-101 n1_48000_481376 n1_65594_481376 3.14179
R11-747-102 n1_65594_481376 n1_88090_481376 4.0171399999999995
R11-747-103 n1_88090_481376 n1_110282_481376 3.96286
R11-747-104 n1_110282_481376 n1_132778_481376 4.0171399999999995
R11-747-105 n1_132778_481376 n1_154970_481376 3.96286
R11-747-106 n1_154970_481376 n1_177466_481376 4.0171399999999995
R11-747-107 n1_177466_481376 n1_199658_481376 3.96286
R11-747-108 n1_199658_481376 n1_221850_481376 3.96286
R11-747-109 n1_221850_481376 n1_244346_481376 4.0171399999999995
R11-747-110 n1_244346_481376 n1_266538_481376 3.96286
R11-747-111 n1_266538_481376 n1_289034_481376 4.0171399999999995
R11-747-112 n1_289034_481376 n1_311226_481376 3.96286
R11-747-113 n1_311226_481376 n1_333722_481376 4.0171399999999995
R11-747-114 n1_333722_481376 n1_355914_481376 3.96286
R11-747-115 n1_355914_481376 n1_378410_481376 4.0171399999999995
R11-747-116 n1_378410_481376 n1_400602_481376 3.96286
R11-747-117 n1_400602_481376 n1_422794_481376 3.96286
R11-747-118 n1_422794_481376 n1_445290_481376 4.0171399999999995
R11-747-119 n1_445290_481376 n1_467482_481376 3.96286
R11-747-120 n1_467482_481376 n1_489978_481376 4.0171399999999995
R11-747-121 n1_489978_481376 n1_512170_481376 3.96286
R11-747-122 n1_512170_481376 n1_534666_481376 4.0171399999999995
R11-747-123 n1_534666_481376 n1_556858_481376 3.96286
R11-747-124 n1_556858_481376 n1_579050_481376 3.96286
R11-747-125 n1_579050_481376 n1_601546_481376 4.0171399999999995
R11-747-126 n1_601546_481376 n1_623064_481376 3.8425
R11-747-127 n1_623064_481376 n1_625064_481376 0.357143
R11-748-100 n1_623064_481376 n1_625064_481376 0.333333
R11-748-101 n1_625064_481376 n1_627064_481376 0.357143
R11-749-100 n1_625064_481376 n1_627064_481376 0.333333
R11-750-100 n1_44000_484720 n1_46000_484720 0.333333
R11-751-100 n1_44000_484720 n1_46000_484720 0.357143
R11-751-101 n1_46000_484720 n1_48000_484720 0.333333
R11-752-100 n1_46000_484720 n1_48000_484720 0.357143
R11-752-101 n1_48000_484720 n1_65594_484720 3.14179
R11-752-102 n1_65594_484720 n1_88090_484720 4.0171399999999995
R11-752-103 n1_88090_484720 n1_110282_484720 3.96286
R11-752-104 n1_110282_484720 n1_132778_484720 4.0171399999999995
R11-752-105 n1_132778_484720 n1_154970_484720 3.96286
R11-752-106 n1_154970_484720 n1_177466_484720 4.0171399999999995
R11-752-107 n1_177466_484720 n1_199658_484720 3.96286
R11-752-108 n1_199658_484720 n1_221850_484720 3.96286
R11-752-109 n1_221850_484720 n1_244346_484720 4.0171399999999995
R11-752-110 n1_244346_484720 n1_266538_484720 3.96286
R11-752-111 n1_266538_484720 n1_289034_484720 4.0171399999999995
R11-752-112 n1_289034_484720 n1_311226_484720 3.96286
R11-752-113 n1_311226_484720 n1_333722_484720 4.0171399999999995
R11-752-114 n1_333722_484720 n1_355914_484720 3.96286
R11-752-115 n1_355914_484720 n1_378410_484720 4.0171399999999995
R11-752-116 n1_378410_484720 n1_400602_484720 3.96286
R11-752-117 n1_400602_484720 n1_422794_484720 3.96286
R11-752-118 n1_422794_484720 n1_445290_484720 4.0171399999999995
R11-752-119 n1_445290_484720 n1_467482_484720 3.96286
R11-752-120 n1_467482_484720 n1_489978_484720 4.0171399999999995
R11-752-121 n1_489978_484720 n1_512170_484720 3.96286
R11-752-122 n1_512170_484720 n1_534666_484720 4.0171399999999995
R11-752-123 n1_534666_484720 n1_556858_484720 3.96286
R11-752-124 n1_556858_484720 n1_579050_484720 3.96286
R11-752-125 n1_579050_484720 n1_601546_484720 4.0171399999999995
R11-752-126 n1_601546_484720 n1_623064_484720 3.8425
R11-752-127 n1_623064_484720 n1_625064_484720 0.357143
R11-753-100 n1_623064_484720 n1_625064_484720 0.333333
R11-753-101 n1_625064_484720 n1_627064_484720 0.357143
R11-754-100 n1_625064_484720 n1_627064_484720 0.333333
R11-755-100 n1_44000_488064 n1_46000_488064 0.333333
R11-756-100 n1_44000_488064 n1_46000_488064 0.357143
R11-756-101 n1_46000_488064 n1_48000_488064 0.333333
R11-757-100 n1_46000_488064 n1_48000_488064 0.357143
R11-757-101 n1_48000_488064 n1_65594_488064 3.14179
R11-757-102 n1_65594_488064 n1_88090_488064 4.0171399999999995
R11-757-103 n1_88090_488064 n1_110282_488064 3.96286
R11-757-104 n1_110282_488064 n1_132778_488064 4.0171399999999995
R11-757-105 n1_132778_488064 n1_154970_488064 3.96286
R11-757-106 n1_154970_488064 n1_177466_488064 4.0171399999999995
R11-757-107 n1_177466_488064 n1_199658_488064 3.96286
R11-757-108 n1_199658_488064 n1_221850_488064 3.96286
R11-757-109 n1_221850_488064 n1_244346_488064 4.0171399999999995
R11-757-110 n1_244346_488064 n1_266538_488064 3.96286
R11-757-111 n1_266538_488064 n1_289034_488064 4.0171399999999995
R11-757-112 n1_289034_488064 n1_311226_488064 3.96286
R11-757-113 n1_311226_488064 n1_333722_488064 4.0171399999999995
R11-757-114 n1_333722_488064 n1_355914_488064 3.96286
R11-757-115 n1_355914_488064 n1_378410_488064 4.0171399999999995
R11-757-116 n1_378410_488064 n1_400602_488064 3.96286
R11-757-117 n1_400602_488064 n1_422794_488064 3.96286
R11-757-118 n1_422794_488064 n1_445290_488064 4.0171399999999995
R11-757-119 n1_445290_488064 n1_467482_488064 3.96286
R11-757-120 n1_467482_488064 n1_489978_488064 4.0171399999999995
R11-757-121 n1_489978_488064 n1_512170_488064 3.96286
R11-757-122 n1_512170_488064 n1_534666_488064 4.0171399999999995
R11-757-123 n1_534666_488064 n1_556858_488064 3.96286
R11-757-124 n1_556858_488064 n1_579050_488064 3.96286
R11-757-125 n1_579050_488064 n1_601546_488064 4.0171399999999995
R11-757-126 n1_601546_488064 n1_623064_488064 3.8425
R11-757-127 n1_623064_488064 n1_625064_488064 0.357143
R11-758-100 n1_623064_488064 n1_625064_488064 0.333333
R11-758-101 n1_625064_488064 n1_627064_488064 0.357143
R11-759-100 n1_625064_488064 n1_627064_488064 0.333333
R11-760-100 n1_44000_491408 n1_46000_491408 0.333333
R11-761-100 n1_44000_491408 n1_46000_491408 0.357143
R11-761-101 n1_46000_491408 n1_48000_491408 0.333333
R11-762-100 n1_46000_491408 n1_48000_491408 0.357143
R11-762-101 n1_48000_491408 n1_65594_491408 3.14179
R11-762-102 n1_65594_491408 n1_88090_491408 4.0171399999999995
R11-762-103 n1_88090_491408 n1_110282_491408 3.96286
R11-762-104 n1_110282_491408 n1_132778_491408 4.0171399999999995
R11-762-105 n1_132778_491408 n1_154970_491408 3.96286
R11-762-106 n1_154970_491408 n1_177466_491408 4.0171399999999995
R11-762-107 n1_177466_491408 n1_199658_491408 3.96286
R11-762-108 n1_199658_491408 n1_221850_491408 3.96286
R11-762-109 n1_221850_491408 n1_244346_491408 4.0171399999999995
R11-762-110 n1_244346_491408 n1_266538_491408 3.96286
R11-762-111 n1_266538_491408 n1_289034_491408 4.0171399999999995
R11-762-112 n1_289034_491408 n1_311226_491408 3.96286
R11-762-113 n1_311226_491408 n1_333722_491408 4.0171399999999995
R11-762-114 n1_333722_491408 n1_355914_491408 3.96286
R11-762-115 n1_355914_491408 n1_378410_491408 4.0171399999999995
R11-762-116 n1_378410_491408 n1_400602_491408 3.96286
R11-762-117 n1_400602_491408 n1_422794_491408 3.96286
R11-762-118 n1_422794_491408 n1_445290_491408 4.0171399999999995
R11-762-119 n1_445290_491408 n1_467482_491408 3.96286
R11-762-120 n1_467482_491408 n1_489978_491408 4.0171399999999995
R11-762-121 n1_489978_491408 n1_512170_491408 3.96286
R11-762-122 n1_512170_491408 n1_534666_491408 4.0171399999999995
R11-762-123 n1_534666_491408 n1_556858_491408 3.96286
R11-762-124 n1_556858_491408 n1_579050_491408 3.96286
R11-762-125 n1_579050_491408 n1_601546_491408 4.0171399999999995
R11-762-126 n1_601546_491408 n1_623064_491408 3.8425
R11-762-127 n1_623064_491408 n1_625064_491408 0.357143
R11-763-100 n1_623064_491408 n1_625064_491408 0.333333
R11-763-101 n1_625064_491408 n1_627064_491408 0.357143
R11-764-100 n1_625064_491408 n1_627064_491408 0.333333
R11-765-100 n1_44000_494752 n1_46000_494752 0.333333
R11-766-100 n1_44000_494752 n1_46000_494752 0.357143
R11-766-101 n1_46000_494752 n1_48000_494752 0.333333
R11-767-100 n1_46000_494752 n1_48000_494752 0.357143
R11-767-101 n1_48000_494752 n1_65594_494752 3.14179
R11-767-102 n1_65594_494752 n1_88090_494752 4.0171399999999995
R11-767-103 n1_88090_494752 n1_110282_494752 3.96286
R11-767-104 n1_110282_494752 n1_132778_494752 4.0171399999999995
R11-767-105 n1_132778_494752 n1_154970_494752 3.96286
R11-767-106 n1_154970_494752 n1_177466_494752 4.0171399999999995
R11-767-107 n1_177466_494752 n1_199658_494752 3.96286
R11-767-108 n1_199658_494752 n1_221850_494752 3.96286
R11-767-109 n1_221850_494752 n1_244346_494752 4.0171399999999995
R11-767-110 n1_244346_494752 n1_266538_494752 3.96286
R11-767-111 n1_266538_494752 n1_289034_494752 4.0171399999999995
R11-767-112 n1_289034_494752 n1_311226_494752 3.96286
R11-767-113 n1_311226_494752 n1_333722_494752 4.0171399999999995
R11-767-114 n1_333722_494752 n1_355914_494752 3.96286
R11-767-115 n1_355914_494752 n1_378410_494752 4.0171399999999995
R11-767-116 n1_378410_494752 n1_400602_494752 3.96286
R11-767-117 n1_400602_494752 n1_422794_494752 3.96286
R11-767-118 n1_422794_494752 n1_445290_494752 4.0171399999999995
R11-767-119 n1_445290_494752 n1_467482_494752 3.96286
R11-767-120 n1_467482_494752 n1_489978_494752 4.0171399999999995
R11-767-121 n1_489978_494752 n1_512170_494752 3.96286
R11-767-122 n1_512170_494752 n1_534666_494752 4.0171399999999995
R11-767-123 n1_534666_494752 n1_556858_494752 3.96286
R11-767-124 n1_556858_494752 n1_579050_494752 3.96286
R11-767-125 n1_579050_494752 n1_601546_494752 4.0171399999999995
R11-767-126 n1_601546_494752 n1_623064_494752 3.8425
R11-767-127 n1_623064_494752 n1_625064_494752 0.357143
R11-768-100 n1_623064_494752 n1_625064_494752 0.333333
R11-768-101 n1_625064_494752 n1_627064_494752 0.357143
R11-769-100 n1_625064_494752 n1_627064_494752 0.333333
R11-770-100 n1_44000_498096 n1_46000_498096 0.333333
R11-771-100 n1_44000_498096 n1_46000_498096 0.357143
R11-771-101 n1_46000_498096 n1_48000_498096 0.333333
R11-772-100 n1_46000_498096 n1_48000_498096 0.357143
R11-772-101 n1_48000_498096 n1_65594_498096 3.14179
R11-772-102 n1_65594_498096 n1_88090_498096 4.0171399999999995
R11-772-103 n1_88090_498096 n1_110282_498096 3.96286
R11-772-104 n1_110282_498096 n1_132778_498096 4.0171399999999995
R11-772-105 n1_132778_498096 n1_154970_498096 3.96286
R11-772-106 n1_154970_498096 n1_177466_498096 4.0171399999999995
R11-772-107 n1_177466_498096 n1_199658_498096 3.96286
R11-772-108 n1_199658_498096 n1_221850_498096 3.96286
R11-772-109 n1_221850_498096 n1_244346_498096 4.0171399999999995
R11-772-110 n1_244346_498096 n1_266538_498096 3.96286
R11-772-111 n1_266538_498096 n1_289034_498096 4.0171399999999995
R11-772-112 n1_289034_498096 n1_311226_498096 3.96286
R11-772-113 n1_311226_498096 n1_333722_498096 4.0171399999999995
R11-772-114 n1_333722_498096 n1_355914_498096 3.96286
R11-772-115 n1_355914_498096 n1_378410_498096 4.0171399999999995
R11-772-116 n1_378410_498096 n1_400602_498096 3.96286
R11-772-117 n1_400602_498096 n1_422794_498096 3.96286
R11-772-118 n1_422794_498096 n1_445290_498096 4.0171399999999995
R11-772-119 n1_445290_498096 n1_467482_498096 3.96286
R11-772-120 n1_467482_498096 n1_489978_498096 4.0171399999999995
R11-772-121 n1_489978_498096 n1_512170_498096 3.96286
R11-772-122 n1_512170_498096 n1_534666_498096 4.0171399999999995
R11-772-123 n1_534666_498096 n1_556858_498096 3.96286
R11-772-124 n1_556858_498096 n1_579050_498096 3.96286
R11-772-125 n1_579050_498096 n1_601546_498096 4.0171399999999995
R11-772-126 n1_601546_498096 n1_623064_498096 3.8425
R11-772-127 n1_623064_498096 n1_625064_498096 0.357143
R11-773-100 n1_623064_498096 n1_625064_498096 0.333333
R11-773-101 n1_625064_498096 n1_627064_498096 0.357143
R11-774-100 n1_625064_498096 n1_627064_498096 0.333333
R11-775-100 n1_44000_501440 n1_46000_501440 0.357143
R11-776-100 n1_44000_501440 n1_46000_501440 0.333333
R11-776-101 n1_46000_501440 n1_48000_501440 0.357143
R11-777-100 n1_46000_501440 n1_48000_501440 0.333333
R11-777-101 n1_48000_501440 n1_65594_501440 3.14179
R11-777-102 n1_65594_501440 n1_88090_501440 4.0171399999999995
R11-777-103 n1_88090_501440 n1_110282_501440 3.96286
R11-777-104 n1_110282_501440 n1_132778_501440 4.0171399999999995
R11-777-105 n1_132778_501440 n1_154970_501440 3.96286
R11-777-106 n1_154970_501440 n1_177466_501440 4.0171399999999995
R11-777-107 n1_177466_501440 n1_199658_501440 3.96286
R11-777-108 n1_199658_501440 n1_221850_501440 3.96286
R11-777-109 n1_221850_501440 n1_244346_501440 4.0171399999999995
R11-777-110 n1_244346_501440 n1_266538_501440 3.96286
R11-777-111 n1_266538_501440 n1_289034_501440 4.0171399999999995
R11-777-112 n1_289034_501440 n1_311226_501440 3.96286
R11-777-113 n1_311226_501440 n1_333722_501440 4.0171399999999995
R11-777-114 n1_333722_501440 n1_355914_501440 3.96286
R11-777-115 n1_355914_501440 n1_378410_501440 4.0171399999999995
R11-777-116 n1_378410_501440 n1_400602_501440 3.96286
R11-777-117 n1_400602_501440 n1_422794_501440 3.96286
R11-777-118 n1_422794_501440 n1_445290_501440 4.0171399999999995
R11-777-119 n1_445290_501440 n1_467482_501440 3.96286
R11-777-120 n1_467482_501440 n1_489978_501440 4.0171399999999995
R11-777-121 n1_489978_501440 n1_512170_501440 3.96286
R11-777-122 n1_512170_501440 n1_534666_501440 4.0171399999999995
R11-777-123 n1_534666_501440 n1_556858_501440 3.96286
R11-777-124 n1_556858_501440 n1_579050_501440 3.96286
R11-777-125 n1_579050_501440 n1_601546_501440 4.0171399999999995
R11-777-126 n1_601546_501440 n1_623064_501440 3.8425
R11-777-127 n1_623064_501440 n1_625064_501440 0.357143
R11-778-100 n1_623064_501440 n1_625064_501440 0.333333
R11-778-101 n1_625064_501440 n1_627064_501440 0.357143
R11-779-100 n1_625064_501440 n1_627064_501440 0.333333
R11-780-100 n1_44000_504784 n1_46000_504784 0.357143
R11-781-100 n1_44000_504784 n1_46000_504784 0.333333
R11-781-101 n1_46000_504784 n1_48000_504784 0.357143
R11-782-100 n1_46000_504784 n1_48000_504784 0.333333
R11-782-101 n1_48000_504784 n1_65594_504784 3.14179
R11-782-102 n1_65594_504784 n1_88090_504784 4.0171399999999995
R11-782-103 n1_88090_504784 n1_110282_504784 3.96286
R11-782-104 n1_110282_504784 n1_132778_504784 4.0171399999999995
R11-782-105 n1_132778_504784 n1_154970_504784 3.96286
R11-782-106 n1_154970_504784 n1_177466_504784 4.0171399999999995
R11-782-107 n1_177466_504784 n1_199658_504784 3.96286
R11-782-108 n1_199658_504784 n1_221850_504784 3.96286
R11-782-109 n1_221850_504784 n1_244346_504784 4.0171399999999995
R11-782-110 n1_244346_504784 n1_266538_504784 3.96286
R11-782-111 n1_266538_504784 n1_289034_504784 4.0171399999999995
R11-782-112 n1_289034_504784 n1_311226_504784 3.96286
R11-782-113 n1_311226_504784 n1_333722_504784 4.0171399999999995
R11-782-114 n1_333722_504784 n1_355914_504784 3.96286
R11-782-115 n1_355914_504784 n1_378410_504784 4.0171399999999995
R11-782-116 n1_378410_504784 n1_400602_504784 3.96286
R11-782-117 n1_400602_504784 n1_422794_504784 3.96286
R11-782-118 n1_422794_504784 n1_445290_504784 4.0171399999999995
R11-782-119 n1_445290_504784 n1_467482_504784 3.96286
R11-782-120 n1_467482_504784 n1_489978_504784 4.0171399999999995
R11-782-121 n1_489978_504784 n1_512170_504784 3.96286
R11-782-122 n1_512170_504784 n1_534666_504784 4.0171399999999995
R11-782-123 n1_534666_504784 n1_556858_504784 3.96286
R11-782-124 n1_556858_504784 n1_579050_504784 3.96286
R11-782-125 n1_579050_504784 n1_601546_504784 4.0171399999999995
R11-782-126 n1_601546_504784 n1_623064_504784 3.8425
R11-782-127 n1_623064_504784 n1_625064_504784 0.357143
R11-783-100 n1_623064_504784 n1_625064_504784 0.333333
R11-783-101 n1_625064_504784 n1_627064_504784 0.357143
R11-784-100 n1_625064_504784 n1_627064_504784 0.333333
R11-785-100 n1_44000_508128 n1_46000_508128 0.357143
R11-786-100 n1_44000_508128 n1_46000_508128 0.333333
R11-786-101 n1_46000_508128 n1_48000_508128 0.357143
R11-787-100 n1_46000_508128 n1_48000_508128 0.333333
R11-787-101 n1_48000_508128 n1_65594_508128 3.14179
R11-787-102 n1_65594_508128 n1_88090_508128 4.0171399999999995
R11-787-103 n1_88090_508128 n1_110282_508128 3.96286
R11-787-104 n1_110282_508128 n1_132778_508128 4.0171399999999995
R11-787-105 n1_132778_508128 n1_154970_508128 3.96286
R11-787-106 n1_154970_508128 n1_177466_508128 4.0171399999999995
R11-787-107 n1_177466_508128 n1_199658_508128 3.96286
R11-787-108 n1_199658_508128 n1_221850_508128 3.96286
R11-787-109 n1_221850_508128 n1_244346_508128 4.0171399999999995
R11-787-110 n1_244346_508128 n1_266538_508128 3.96286
R11-787-111 n1_266538_508128 n1_289034_508128 4.0171399999999995
R11-787-112 n1_289034_508128 n1_311226_508128 3.96286
R11-787-113 n1_311226_508128 n1_333722_508128 4.0171399999999995
R11-787-114 n1_333722_508128 n1_355914_508128 3.96286
R11-787-115 n1_355914_508128 n1_378410_508128 4.0171399999999995
R11-787-116 n1_378410_508128 n1_400602_508128 3.96286
R11-787-117 n1_400602_508128 n1_422794_508128 3.96286
R11-787-118 n1_422794_508128 n1_445290_508128 4.0171399999999995
R11-787-119 n1_445290_508128 n1_467482_508128 3.96286
R11-787-120 n1_467482_508128 n1_489978_508128 4.0171399999999995
R11-787-121 n1_489978_508128 n1_512170_508128 3.96286
R11-787-122 n1_512170_508128 n1_534666_508128 4.0171399999999995
R11-787-123 n1_534666_508128 n1_556858_508128 3.96286
R11-787-124 n1_556858_508128 n1_579050_508128 3.96286
R11-787-125 n1_579050_508128 n1_601546_508128 4.0171399999999995
R11-787-126 n1_601546_508128 n1_623064_508128 3.8425
R11-787-127 n1_623064_508128 n1_625064_508128 0.357143
R11-788-100 n1_623064_508128 n1_625064_508128 0.333333
R11-788-101 n1_625064_508128 n1_627064_508128 0.357143
R11-789-100 n1_625064_508128 n1_627064_508128 0.333333
R11-790-100 n1_44000_511472 n1_46000_511472 0.357143
R11-791-100 n1_44000_511472 n1_46000_511472 0.333333
R11-791-101 n1_46000_511472 n1_48000_511472 0.357143
R11-792-100 n1_46000_511472 n1_48000_511472 0.333333
R11-792-101 n1_48000_511472 n1_65594_511472 3.14179
R11-792-102 n1_65594_511472 n1_88090_511472 4.0171399999999995
R11-792-103 n1_88090_511472 n1_110282_511472 3.96286
R11-792-104 n1_110282_511472 n1_132778_511472 4.0171399999999995
R11-792-105 n1_132778_511472 n1_154970_511472 3.96286
R11-792-106 n1_154970_511472 n1_177466_511472 4.0171399999999995
R11-792-107 n1_177466_511472 n1_199658_511472 3.96286
R11-792-108 n1_199658_511472 n1_221850_511472 3.96286
R11-792-109 n1_221850_511472 n1_244346_511472 4.0171399999999995
R11-792-110 n1_244346_511472 n1_266538_511472 3.96286
R11-792-111 n1_266538_511472 n1_289034_511472 4.0171399999999995
R11-792-112 n1_289034_511472 n1_311226_511472 3.96286
R11-792-113 n1_311226_511472 n1_333722_511472 4.0171399999999995
R11-792-114 n1_333722_511472 n1_355914_511472 3.96286
R11-792-115 n1_355914_511472 n1_378410_511472 4.0171399999999995
R11-792-116 n1_378410_511472 n1_400602_511472 3.96286
R11-792-117 n1_400602_511472 n1_422794_511472 3.96286
R11-792-118 n1_422794_511472 n1_445290_511472 4.0171399999999995
R11-792-119 n1_445290_511472 n1_467482_511472 3.96286
R11-792-120 n1_467482_511472 n1_489978_511472 4.0171399999999995
R11-792-121 n1_489978_511472 n1_512170_511472 3.96286
R11-792-122 n1_512170_511472 n1_534666_511472 4.0171399999999995
R11-792-123 n1_534666_511472 n1_556858_511472 3.96286
R11-792-124 n1_556858_511472 n1_579050_511472 3.96286
R11-792-125 n1_579050_511472 n1_601546_511472 4.0171399999999995
R11-792-126 n1_601546_511472 n1_623064_511472 3.8425
R11-792-127 n1_623064_511472 n1_625064_511472 0.357143
R11-793-100 n1_623064_511472 n1_625064_511472 0.333333
R11-793-101 n1_625064_511472 n1_627064_511472 0.357143
R11-794-100 n1_625064_511472 n1_627064_511472 0.333333
R11-795-100 n1_44000_514816 n1_46000_514816 0.357143
R11-796-100 n1_44000_514816 n1_46000_514816 0.333333
R11-796-101 n1_46000_514816 n1_48000_514816 0.357143
R11-797-100 n1_46000_514816 n1_48000_514816 0.333333
R11-797-101 n1_48000_514816 n1_65594_514816 3.14179
R11-797-102 n1_65594_514816 n1_88090_514816 4.0171399999999995
R11-797-103 n1_88090_514816 n1_110282_514816 3.96286
R11-797-104 n1_110282_514816 n1_132778_514816 4.0171399999999995
R11-797-105 n1_132778_514816 n1_154970_514816 3.96286
R11-797-106 n1_154970_514816 n1_177466_514816 4.0171399999999995
R11-797-107 n1_177466_514816 n1_199658_514816 3.96286
R11-797-108 n1_199658_514816 n1_221850_514816 3.96286
R11-797-109 n1_221850_514816 n1_244346_514816 4.0171399999999995
R11-797-110 n1_244346_514816 n1_266538_514816 3.96286
R11-797-111 n1_266538_514816 n1_289034_514816 4.0171399999999995
R11-797-112 n1_289034_514816 n1_311226_514816 3.96286
R11-797-113 n1_311226_514816 n1_333722_514816 4.0171399999999995
R11-797-114 n1_333722_514816 n1_355914_514816 3.96286
R11-797-115 n1_355914_514816 n1_378410_514816 4.0171399999999995
R11-797-116 n1_378410_514816 n1_400602_514816 3.96286
R11-797-117 n1_400602_514816 n1_422794_514816 3.96286
R11-797-118 n1_422794_514816 n1_445290_514816 4.0171399999999995
R11-797-119 n1_445290_514816 n1_467482_514816 3.96286
R11-797-120 n1_467482_514816 n1_489978_514816 4.0171399999999995
R11-797-121 n1_489978_514816 n1_512170_514816 3.96286
R11-797-122 n1_512170_514816 n1_534666_514816 4.0171399999999995
R11-797-123 n1_534666_514816 n1_556858_514816 3.96286
R11-797-124 n1_556858_514816 n1_579050_514816 3.96286
R11-797-125 n1_579050_514816 n1_601546_514816 4.0171399999999995
R11-797-126 n1_601546_514816 n1_623064_514816 3.8425
R11-797-127 n1_623064_514816 n1_625064_514816 0.357143
R11-798-100 n1_623064_514816 n1_625064_514816 0.333333
R11-798-101 n1_625064_514816 n1_627064_514816 0.357143
R11-799-100 n1_625064_514816 n1_627064_514816 0.333333
R11-800-100 n1_44000_518160 n1_46000_518160 0.333333
R11-801-100 n1_44000_518160 n1_46000_518160 0.357143
R11-801-101 n1_46000_518160 n1_48000_518160 0.333333
R11-802-100 n1_46000_518160 n1_48000_518160 0.357143
R11-802-101 n1_48000_518160 n1_65594_518160 3.14179
R11-802-102 n1_65594_518160 n1_88090_518160 4.0171399999999995
R11-802-103 n1_88090_518160 n1_110282_518160 3.96286
R11-802-104 n1_110282_518160 n1_132778_518160 4.0171399999999995
R11-802-105 n1_132778_518160 n1_154970_518160 3.96286
R11-802-106 n1_154970_518160 n1_177466_518160 4.0171399999999995
R11-802-107 n1_177466_518160 n1_199658_518160 3.96286
R11-802-108 n1_199658_518160 n1_221850_518160 3.96286
R11-802-109 n1_221850_518160 n1_244346_518160 4.0171399999999995
R11-802-110 n1_244346_518160 n1_266538_518160 3.96286
R11-802-111 n1_266538_518160 n1_289034_518160 4.0171399999999995
R11-802-112 n1_289034_518160 n1_311226_518160 3.96286
R11-802-113 n1_311226_518160 n1_333722_518160 4.0171399999999995
R11-802-114 n1_333722_518160 n1_355914_518160 3.96286
R11-802-115 n1_355914_518160 n1_378410_518160 4.0171399999999995
R11-802-116 n1_378410_518160 n1_400602_518160 3.96286
R11-802-117 n1_400602_518160 n1_422794_518160 3.96286
R11-802-118 n1_422794_518160 n1_445290_518160 4.0171399999999995
R11-802-119 n1_445290_518160 n1_467482_518160 3.96286
R11-802-120 n1_467482_518160 n1_489978_518160 4.0171399999999995
R11-802-121 n1_489978_518160 n1_512170_518160 3.96286
R11-802-122 n1_512170_518160 n1_534666_518160 4.0171399999999995
R11-802-123 n1_534666_518160 n1_556858_518160 3.96286
R11-802-124 n1_556858_518160 n1_579050_518160 3.96286
R11-802-125 n1_579050_518160 n1_601546_518160 4.0171399999999995
R11-802-126 n1_601546_518160 n1_623064_518160 3.8425
R11-802-127 n1_623064_518160 n1_625064_518160 0.357143
R11-803-100 n1_623064_518160 n1_625064_518160 0.333333
R11-803-101 n1_625064_518160 n1_627064_518160 0.357143
R11-804-100 n1_625064_518160 n1_627064_518160 0.333333
R11-805-100 n1_44000_521504 n1_46000_521504 0.333333
R11-806-100 n1_44000_521504 n1_46000_521504 0.357143
R11-806-101 n1_46000_521504 n1_48000_521504 0.333333
R11-807-100 n1_46000_521504 n1_48000_521504 0.357143
R11-807-101 n1_48000_521504 n1_65594_521504 3.14179
R11-807-102 n1_65594_521504 n1_88090_521504 4.0171399999999995
R11-807-103 n1_88090_521504 n1_110282_521504 3.96286
R11-807-104 n1_110282_521504 n1_132778_521504 4.0171399999999995
R11-807-105 n1_132778_521504 n1_154970_521504 3.96286
R11-807-106 n1_154970_521504 n1_177466_521504 4.0171399999999995
R11-807-107 n1_177466_521504 n1_199658_521504 3.96286
R11-807-108 n1_199658_521504 n1_221850_521504 3.96286
R11-807-109 n1_221850_521504 n1_244346_521504 4.0171399999999995
R11-807-110 n1_244346_521504 n1_266538_521504 3.96286
R11-807-111 n1_266538_521504 n1_289034_521504 4.0171399999999995
R11-807-112 n1_289034_521504 n1_311226_521504 3.96286
R11-807-113 n1_311226_521504 n1_333722_521504 4.0171399999999995
R11-807-114 n1_333722_521504 n1_355914_521504 3.96286
R11-807-115 n1_355914_521504 n1_378410_521504 4.0171399999999995
R11-807-116 n1_378410_521504 n1_400602_521504 3.96286
R11-807-117 n1_400602_521504 n1_422794_521504 3.96286
R11-807-118 n1_422794_521504 n1_445290_521504 4.0171399999999995
R11-807-119 n1_445290_521504 n1_467482_521504 3.96286
R11-807-120 n1_467482_521504 n1_489978_521504 4.0171399999999995
R11-807-121 n1_489978_521504 n1_512170_521504 3.96286
R11-807-122 n1_512170_521504 n1_534666_521504 4.0171399999999995
R11-807-123 n1_534666_521504 n1_556858_521504 3.96286
R11-807-124 n1_556858_521504 n1_579050_521504 3.96286
R11-807-125 n1_579050_521504 n1_601546_521504 4.0171399999999995
R11-807-126 n1_601546_521504 n1_623064_521504 3.8425
R11-807-127 n1_623064_521504 n1_625064_521504 0.357143
R11-808-100 n1_623064_521504 n1_625064_521504 0.333333
R11-808-101 n1_625064_521504 n1_627064_521504 0.357143
R11-809-100 n1_625064_521504 n1_627064_521504 0.333333
R11-810-100 n1_44000_524848 n1_46000_524848 0.333333
R11-811-100 n1_44000_524848 n1_46000_524848 0.357143
R11-811-101 n1_46000_524848 n1_48000_524848 0.333333
R11-812-100 n1_46000_524848 n1_48000_524848 0.357143
R11-812-101 n1_48000_524848 n1_65594_524848 3.14179
R11-812-102 n1_65594_524848 n1_88090_524848 4.0171399999999995
R11-812-103 n1_88090_524848 n1_110282_524848 3.96286
R11-812-104 n1_110282_524848 n1_132778_524848 4.0171399999999995
R11-812-105 n1_132778_524848 n1_154970_524848 3.96286
R11-812-106 n1_154970_524848 n1_177466_524848 4.0171399999999995
R11-812-107 n1_177466_524848 n1_199658_524848 3.96286
R11-812-108 n1_199658_524848 n1_221850_524848 3.96286
R11-812-109 n1_221850_524848 n1_244346_524848 4.0171399999999995
R11-812-110 n1_244346_524848 n1_266538_524848 3.96286
R11-812-111 n1_266538_524848 n1_289034_524848 4.0171399999999995
R11-812-112 n1_289034_524848 n1_311226_524848 3.96286
R11-812-113 n1_311226_524848 n1_333722_524848 4.0171399999999995
R11-812-114 n1_333722_524848 n1_355914_524848 3.96286
R11-812-115 n1_355914_524848 n1_378410_524848 4.0171399999999995
R11-812-116 n1_378410_524848 n1_400602_524848 3.96286
R11-812-117 n1_400602_524848 n1_422794_524848 3.96286
R11-812-118 n1_422794_524848 n1_445290_524848 4.0171399999999995
R11-812-119 n1_445290_524848 n1_467482_524848 3.96286
R11-812-120 n1_467482_524848 n1_489978_524848 4.0171399999999995
R11-812-121 n1_489978_524848 n1_512170_524848 3.96286
R11-812-122 n1_512170_524848 n1_534666_524848 4.0171399999999995
R11-812-123 n1_534666_524848 n1_556858_524848 3.96286
R11-812-124 n1_556858_524848 n1_579050_524848 3.96286
R11-812-125 n1_579050_524848 n1_601546_524848 4.0171399999999995
R11-812-126 n1_601546_524848 n1_623064_524848 3.8425
R11-812-127 n1_623064_524848 n1_625064_524848 0.357143
R11-813-100 n1_623064_524848 n1_625064_524848 0.333333
R11-813-101 n1_625064_524848 n1_627064_524848 0.357143
R11-814-100 n1_625064_524848 n1_627064_524848 0.333333
R11-815-100 n1_44000_528192 n1_46000_528192 0.333333
R11-816-100 n1_44000_528192 n1_46000_528192 0.357143
R11-816-101 n1_46000_528192 n1_48000_528192 0.333333
R11-817-100 n1_46000_528192 n1_48000_528192 0.357143
R11-817-101 n1_48000_528192 n1_65594_528192 3.14179
R11-817-102 n1_65594_528192 n1_88090_528192 4.0171399999999995
R11-817-103 n1_88090_528192 n1_110282_528192 3.96286
R11-817-104 n1_110282_528192 n1_132778_528192 4.0171399999999995
R11-817-105 n1_132778_528192 n1_154970_528192 3.96286
R11-817-106 n1_154970_528192 n1_177466_528192 4.0171399999999995
R11-817-107 n1_177466_528192 n1_199658_528192 3.96286
R11-817-108 n1_199658_528192 n1_221850_528192 3.96286
R11-817-109 n1_221850_528192 n1_244346_528192 4.0171399999999995
R11-817-110 n1_244346_528192 n1_266538_528192 3.96286
R11-817-111 n1_266538_528192 n1_289034_528192 4.0171399999999995
R11-817-112 n1_289034_528192 n1_311226_528192 3.96286
R11-817-113 n1_311226_528192 n1_333722_528192 4.0171399999999995
R11-817-114 n1_333722_528192 n1_355914_528192 3.96286
R11-817-115 n1_355914_528192 n1_378410_528192 4.0171399999999995
R11-817-116 n1_378410_528192 n1_400602_528192 3.96286
R11-817-117 n1_400602_528192 n1_422794_528192 3.96286
R11-817-118 n1_422794_528192 n1_445290_528192 4.0171399999999995
R11-817-119 n1_445290_528192 n1_467482_528192 3.96286
R11-817-120 n1_467482_528192 n1_489978_528192 4.0171399999999995
R11-817-121 n1_489978_528192 n1_512170_528192 3.96286
R11-817-122 n1_512170_528192 n1_534666_528192 4.0171399999999995
R11-817-123 n1_534666_528192 n1_556858_528192 3.96286
R11-817-124 n1_556858_528192 n1_579050_528192 3.96286
R11-817-125 n1_579050_528192 n1_601546_528192 4.0171399999999995
R11-817-126 n1_601546_528192 n1_623064_528192 3.8425
R11-817-127 n1_623064_528192 n1_625064_528192 0.357143
R11-818-100 n1_623064_528192 n1_625064_528192 0.333333
R11-818-101 n1_625064_528192 n1_627064_528192 0.357143
R11-819-100 n1_625064_528192 n1_627064_528192 0.333333
R11-820-100 n1_44000_531536 n1_46000_531536 0.333333
R11-821-100 n1_44000_531536 n1_46000_531536 0.357143
R11-821-101 n1_46000_531536 n1_48000_531536 0.333333
R11-822-100 n1_46000_531536 n1_48000_531536 0.357143
R11-822-101 n1_48000_531536 n1_65594_531536 3.14179
R11-822-102 n1_65594_531536 n1_88090_531536 4.0171399999999995
R11-822-103 n1_88090_531536 n1_110282_531536 3.96286
R11-822-104 n1_110282_531536 n1_132778_531536 4.0171399999999995
R11-822-105 n1_132778_531536 n1_154970_531536 3.96286
R11-822-106 n1_154970_531536 n1_177466_531536 4.0171399999999995
R11-822-107 n1_177466_531536 n1_199658_531536 3.96286
R11-822-108 n1_199658_531536 n1_221850_531536 3.96286
R11-822-109 n1_221850_531536 n1_244346_531536 4.0171399999999995
R11-822-110 n1_244346_531536 n1_266538_531536 3.96286
R11-822-111 n1_266538_531536 n1_289034_531536 4.0171399999999995
R11-822-112 n1_289034_531536 n1_311226_531536 3.96286
R11-822-113 n1_311226_531536 n1_333722_531536 4.0171399999999995
R11-822-114 n1_333722_531536 n1_355914_531536 3.96286
R11-822-115 n1_355914_531536 n1_378410_531536 4.0171399999999995
R11-822-116 n1_378410_531536 n1_400602_531536 3.96286
R11-822-117 n1_400602_531536 n1_422794_531536 3.96286
R11-822-118 n1_422794_531536 n1_445290_531536 4.0171399999999995
R11-822-119 n1_445290_531536 n1_467482_531536 3.96286
R11-822-120 n1_467482_531536 n1_489978_531536 4.0171399999999995
R11-822-121 n1_489978_531536 n1_512170_531536 3.96286
R11-822-122 n1_512170_531536 n1_534666_531536 4.0171399999999995
R11-822-123 n1_534666_531536 n1_556858_531536 3.96286
R11-822-124 n1_556858_531536 n1_579050_531536 3.96286
R11-822-125 n1_579050_531536 n1_601546_531536 4.0171399999999995
R11-822-126 n1_601546_531536 n1_623064_531536 3.8425
R11-822-127 n1_623064_531536 n1_625064_531536 0.357143
R11-823-100 n1_623064_531536 n1_625064_531536 0.333333
R11-823-101 n1_625064_531536 n1_627064_531536 0.357143
R11-824-100 n1_625064_531536 n1_627064_531536 0.333333
R11-825-100 n1_44000_534880 n1_46000_534880 0.333333
R11-826-100 n1_44000_534880 n1_46000_534880 0.357143
R11-826-101 n1_46000_534880 n1_48000_534880 0.333333
R11-827-100 n1_46000_534880 n1_48000_534880 0.357143
R11-827-101 n1_48000_534880 n1_65594_534880 3.14179
R11-827-102 n1_65594_534880 n1_88090_534880 4.0171399999999995
R11-827-103 n1_88090_534880 n1_110282_534880 3.96286
R11-827-104 n1_110282_534880 n1_132778_534880 4.0171399999999995
R11-827-105 n1_132778_534880 n1_154970_534880 3.96286
R11-827-106 n1_154970_534880 n1_177466_534880 4.0171399999999995
R11-827-107 n1_177466_534880 n1_199658_534880 3.96286
R11-827-108 n1_199658_534880 n1_221850_534880 3.96286
R11-827-109 n1_221850_534880 n1_244346_534880 4.0171399999999995
R11-827-110 n1_244346_534880 n1_266538_534880 3.96286
R11-827-111 n1_266538_534880 n1_289034_534880 4.0171399999999995
R11-827-112 n1_289034_534880 n1_311226_534880 3.96286
R11-827-113 n1_311226_534880 n1_333722_534880 4.0171399999999995
R11-827-114 n1_333722_534880 n1_355914_534880 3.96286
R11-827-115 n1_355914_534880 n1_378410_534880 4.0171399999999995
R11-827-116 n1_378410_534880 n1_400602_534880 3.96286
R11-827-117 n1_400602_534880 n1_422794_534880 3.96286
R11-827-118 n1_422794_534880 n1_445290_534880 4.0171399999999995
R11-827-119 n1_445290_534880 n1_467482_534880 3.96286
R11-827-120 n1_467482_534880 n1_489978_534880 4.0171399999999995
R11-827-121 n1_489978_534880 n1_512170_534880 3.96286
R11-827-122 n1_512170_534880 n1_534666_534880 4.0171399999999995
R11-827-123 n1_534666_534880 n1_556858_534880 3.96286
R11-827-124 n1_556858_534880 n1_579050_534880 3.96286
R11-827-125 n1_579050_534880 n1_601546_534880 4.0171399999999995
R11-827-126 n1_601546_534880 n1_623064_534880 3.8425
R11-827-127 n1_623064_534880 n1_625064_534880 0.357143
R11-828-100 n1_623064_534880 n1_625064_534880 0.333333
R11-828-101 n1_625064_534880 n1_627064_534880 0.357143
R11-829-100 n1_625064_534880 n1_627064_534880 0.333333
R11-830-100 n1_44000_538224 n1_46000_538224 0.357143
R11-831-100 n1_44000_538224 n1_46000_538224 0.333333
R11-831-101 n1_46000_538224 n1_48000_538224 0.357143
R11-832-100 n1_46000_538224 n1_48000_538224 0.333333
R11-832-101 n1_48000_538224 n1_65594_538224 3.14179
R11-832-102 n1_65594_538224 n1_88090_538224 4.0171399999999995
R11-832-103 n1_88090_538224 n1_110282_538224 3.96286
R11-832-104 n1_110282_538224 n1_132778_538224 4.0171399999999995
R11-832-105 n1_132778_538224 n1_154970_538224 3.96286
R11-832-106 n1_154970_538224 n1_177466_538224 4.0171399999999995
R11-832-107 n1_177466_538224 n1_199658_538224 3.96286
R11-832-108 n1_199658_538224 n1_221850_538224 3.96286
R11-832-109 n1_221850_538224 n1_244346_538224 4.0171399999999995
R11-832-110 n1_244346_538224 n1_266538_538224 3.96286
R11-832-111 n1_266538_538224 n1_289034_538224 4.0171399999999995
R11-832-112 n1_289034_538224 n1_311226_538224 3.96286
R11-832-113 n1_311226_538224 n1_333722_538224 4.0171399999999995
R11-832-114 n1_333722_538224 n1_355914_538224 3.96286
R11-832-115 n1_355914_538224 n1_378410_538224 4.0171399999999995
R11-832-116 n1_378410_538224 n1_400602_538224 3.96286
R11-832-117 n1_400602_538224 n1_422794_538224 3.96286
R11-832-118 n1_422794_538224 n1_445290_538224 4.0171399999999995
R11-832-119 n1_445290_538224 n1_467482_538224 3.96286
R11-832-120 n1_467482_538224 n1_489978_538224 4.0171399999999995
R11-832-121 n1_489978_538224 n1_512170_538224 3.96286
R11-832-122 n1_512170_538224 n1_534666_538224 4.0171399999999995
R11-832-123 n1_534666_538224 n1_556858_538224 3.96286
R11-832-124 n1_556858_538224 n1_579050_538224 3.96286
R11-832-125 n1_579050_538224 n1_601546_538224 4.0171399999999995
R11-832-126 n1_601546_538224 n1_623064_538224 3.8425
R11-832-127 n1_623064_538224 n1_625064_538224 0.357143
R11-833-100 n1_623064_538224 n1_625064_538224 0.333333
R11-833-101 n1_625064_538224 n1_627064_538224 0.357143
R11-834-100 n1_625064_538224 n1_627064_538224 0.333333
R11-835-100 n1_44000_541568 n1_46000_541568 0.357143
R11-836-100 n1_44000_541568 n1_46000_541568 0.333333
R11-836-101 n1_46000_541568 n1_48000_541568 0.357143
R11-837-100 n1_46000_541568 n1_48000_541568 0.333333
R11-837-101 n1_48000_541568 n1_65594_541568 3.14179
R11-837-102 n1_65594_541568 n1_88090_541568 4.0171399999999995
R11-837-103 n1_88090_541568 n1_110282_541568 3.96286
R11-837-104 n1_110282_541568 n1_132778_541568 4.0171399999999995
R11-837-105 n1_132778_541568 n1_154970_541568 3.96286
R11-837-106 n1_154970_541568 n1_177466_541568 4.0171399999999995
R11-837-107 n1_177466_541568 n1_199658_541568 3.96286
R11-837-108 n1_199658_541568 n1_221850_541568 3.96286
R11-837-109 n1_221850_541568 n1_244346_541568 4.0171399999999995
R11-837-110 n1_244346_541568 n1_266538_541568 3.96286
R11-837-111 n1_266538_541568 n1_289034_541568 4.0171399999999995
R11-837-112 n1_289034_541568 n1_311226_541568 3.96286
R11-837-113 n1_311226_541568 n1_333722_541568 4.0171399999999995
R11-837-114 n1_333722_541568 n1_355914_541568 3.96286
R11-837-115 n1_355914_541568 n1_378410_541568 4.0171399999999995
R11-837-116 n1_378410_541568 n1_400602_541568 3.96286
R11-837-117 n1_400602_541568 n1_422794_541568 3.96286
R11-837-118 n1_422794_541568 n1_445290_541568 4.0171399999999995
R11-837-119 n1_445290_541568 n1_467482_541568 3.96286
R11-837-120 n1_467482_541568 n1_489978_541568 4.0171399999999995
R11-837-121 n1_489978_541568 n1_512170_541568 3.96286
R11-837-122 n1_512170_541568 n1_534666_541568 4.0171399999999995
R11-837-123 n1_534666_541568 n1_556858_541568 3.96286
R11-837-124 n1_556858_541568 n1_579050_541568 3.96286
R11-837-125 n1_579050_541568 n1_601546_541568 4.0171399999999995
R11-837-126 n1_601546_541568 n1_623064_541568 3.8425
R11-837-127 n1_623064_541568 n1_625064_541568 0.357143
R11-838-100 n1_623064_541568 n1_625064_541568 0.333333
R11-838-101 n1_625064_541568 n1_627064_541568 0.357143
R11-839-100 n1_625064_541568 n1_627064_541568 0.333333
R11-840-100 n1_44000_544912 n1_46000_544912 0.357143
R11-841-100 n1_44000_544912 n1_46000_544912 0.333333
R11-841-101 n1_46000_544912 n1_48000_544912 0.357143
R11-842-100 n1_46000_544912 n1_48000_544912 0.333333
R11-842-101 n1_48000_544912 n1_65594_544912 3.14179
R11-842-102 n1_65594_544912 n1_88090_544912 4.0171399999999995
R11-842-103 n1_88090_544912 n1_110282_544912 3.96286
R11-842-104 n1_110282_544912 n1_132778_544912 4.0171399999999995
R11-842-105 n1_132778_544912 n1_154970_544912 3.96286
R11-842-106 n1_154970_544912 n1_177466_544912 4.0171399999999995
R11-842-107 n1_177466_544912 n1_199658_544912 3.96286
R11-842-108 n1_199658_544912 n1_221850_544912 3.96286
R11-842-109 n1_221850_544912 n1_244346_544912 4.0171399999999995
R11-842-110 n1_244346_544912 n1_266538_544912 3.96286
R11-842-111 n1_266538_544912 n1_289034_544912 4.0171399999999995
R11-842-112 n1_289034_544912 n1_311226_544912 3.96286
R11-842-113 n1_311226_544912 n1_333722_544912 4.0171399999999995
R11-842-114 n1_333722_544912 n1_355914_544912 3.96286
R11-842-115 n1_355914_544912 n1_378410_544912 4.0171399999999995
R11-842-116 n1_378410_544912 n1_400602_544912 3.96286
R11-842-117 n1_400602_544912 n1_422794_544912 3.96286
R11-842-118 n1_422794_544912 n1_445290_544912 4.0171399999999995
R11-842-119 n1_445290_544912 n1_467482_544912 3.96286
R11-842-120 n1_467482_544912 n1_489978_544912 4.0171399999999995
R11-842-121 n1_489978_544912 n1_512170_544912 3.96286
R11-842-122 n1_512170_544912 n1_534666_544912 4.0171399999999995
R11-842-123 n1_534666_544912 n1_556858_544912 3.96286
R11-842-124 n1_556858_544912 n1_579050_544912 3.96286
R11-842-125 n1_579050_544912 n1_601546_544912 4.0171399999999995
R11-842-126 n1_601546_544912 n1_623064_544912 3.8425
R11-842-127 n1_623064_544912 n1_625064_544912 0.357143
R11-843-100 n1_623064_544912 n1_625064_544912 0.333333
R11-843-101 n1_625064_544912 n1_627064_544912 0.357143
R11-844-100 n1_625064_544912 n1_627064_544912 0.333333
R11-845-100 n1_44000_548256 n1_46000_548256 0.357143
R11-846-100 n1_44000_548256 n1_46000_548256 0.333333
R11-846-101 n1_46000_548256 n1_48000_548256 0.357143
R11-847-100 n1_46000_548256 n1_48000_548256 0.333333
R11-847-101 n1_48000_548256 n1_65594_548256 3.14179
R11-847-102 n1_65594_548256 n1_88090_548256 4.0171399999999995
R11-847-103 n1_88090_548256 n1_110282_548256 3.96286
R11-847-104 n1_110282_548256 n1_132778_548256 4.0171399999999995
R11-847-105 n1_132778_548256 n1_154970_548256 3.96286
R11-847-106 n1_154970_548256 n1_177466_548256 4.0171399999999995
R11-847-107 n1_177466_548256 n1_199658_548256 3.96286
R11-847-108 n1_199658_548256 n1_221850_548256 3.96286
R11-847-109 n1_221850_548256 n1_244346_548256 4.0171399999999995
R11-847-110 n1_244346_548256 n1_266538_548256 3.96286
R11-847-111 n1_266538_548256 n1_289034_548256 4.0171399999999995
R11-847-112 n1_289034_548256 n1_311226_548256 3.96286
R11-847-113 n1_311226_548256 n1_333722_548256 4.0171399999999995
R11-847-114 n1_333722_548256 n1_355914_548256 3.96286
R11-847-115 n1_355914_548256 n1_378410_548256 4.0171399999999995
R11-847-116 n1_378410_548256 n1_400602_548256 3.96286
R11-847-117 n1_400602_548256 n1_422794_548256 3.96286
R11-847-118 n1_422794_548256 n1_445290_548256 4.0171399999999995
R11-847-119 n1_445290_548256 n1_467482_548256 3.96286
R11-847-120 n1_467482_548256 n1_489978_548256 4.0171399999999995
R11-847-121 n1_489978_548256 n1_512170_548256 3.96286
R11-847-122 n1_512170_548256 n1_534666_548256 4.0171399999999995
R11-847-123 n1_534666_548256 n1_556858_548256 3.96286
R11-847-124 n1_556858_548256 n1_579050_548256 3.96286
R11-847-125 n1_579050_548256 n1_601546_548256 4.0171399999999995
R11-847-126 n1_601546_548256 n1_623064_548256 3.8425
R11-847-127 n1_623064_548256 n1_625064_548256 0.357143
R11-848-100 n1_623064_548256 n1_625064_548256 0.333333
R11-848-101 n1_625064_548256 n1_627064_548256 0.357143
R11-849-100 n1_625064_548256 n1_627064_548256 0.333333
R11-850-100 n1_44000_551600 n1_46000_551600 0.357143
R11-851-100 n1_44000_551600 n1_46000_551600 0.333333
R11-851-101 n1_46000_551600 n1_48000_551600 0.357143
R11-852-100 n1_46000_551600 n1_48000_551600 0.333333
R11-852-101 n1_48000_551600 n1_65594_551600 3.14179
R11-852-102 n1_65594_551600 n1_88090_551600 4.0171399999999995
R11-852-103 n1_88090_551600 n1_110282_551600 3.96286
R11-852-104 n1_110282_551600 n1_132778_551600 4.0171399999999995
R11-852-105 n1_132778_551600 n1_154970_551600 3.96286
R11-852-106 n1_154970_551600 n1_177466_551600 4.0171399999999995
R11-852-107 n1_177466_551600 n1_199658_551600 3.96286
R11-852-108 n1_199658_551600 n1_221850_551600 3.96286
R11-852-109 n1_221850_551600 n1_244346_551600 4.0171399999999995
R11-852-110 n1_244346_551600 n1_266538_551600 3.96286
R11-852-111 n1_266538_551600 n1_289034_551600 4.0171399999999995
R11-852-112 n1_289034_551600 n1_311226_551600 3.96286
R11-852-113 n1_311226_551600 n1_333722_551600 4.0171399999999995
R11-852-114 n1_333722_551600 n1_355914_551600 3.96286
R11-852-115 n1_355914_551600 n1_378410_551600 4.0171399999999995
R11-852-116 n1_378410_551600 n1_400602_551600 3.96286
R11-852-117 n1_400602_551600 n1_422794_551600 3.96286
R11-852-118 n1_422794_551600 n1_445290_551600 4.0171399999999995
R11-852-119 n1_445290_551600 n1_467482_551600 3.96286
R11-852-120 n1_467482_551600 n1_489978_551600 4.0171399999999995
R11-852-121 n1_489978_551600 n1_512170_551600 3.96286
R11-852-122 n1_512170_551600 n1_534666_551600 4.0171399999999995
R11-852-123 n1_534666_551600 n1_556858_551600 3.96286
R11-852-124 n1_556858_551600 n1_579050_551600 3.96286
R11-852-125 n1_579050_551600 n1_601546_551600 4.0171399999999995
R11-852-126 n1_601546_551600 n1_623064_551600 3.8425
R11-852-127 n1_623064_551600 n1_625064_551600 0.357143
R11-853-100 n1_623064_551600 n1_625064_551600 0.333333
R11-853-101 n1_625064_551600 n1_627064_551600 0.357143
R11-854-100 n1_625064_551600 n1_627064_551600 0.333333
R11-855-100 n1_44000_554944 n1_46000_554944 0.333333
R11-856-100 n1_44000_554944 n1_46000_554944 0.357143
R11-856-101 n1_46000_554944 n1_48000_554944 0.333333
R11-857-100 n1_46000_554944 n1_48000_554944 0.357143
R11-857-101 n1_48000_554944 n1_65594_554944 3.14179
R11-857-102 n1_65594_554944 n1_88090_554944 4.0171399999999995
R11-857-103 n1_88090_554944 n1_110282_554944 3.96286
R11-857-104 n1_110282_554944 n1_132778_554944 4.0171399999999995
R11-857-105 n1_132778_554944 n1_154970_554944 3.96286
R11-857-106 n1_154970_554944 n1_177466_554944 4.0171399999999995
R11-857-107 n1_177466_554944 n1_199658_554944 3.96286
R11-857-108 n1_199658_554944 n1_221850_554944 3.96286
R11-857-109 n1_221850_554944 n1_244346_554944 4.0171399999999995
R11-857-110 n1_244346_554944 n1_266538_554944 3.96286
R11-857-111 n1_266538_554944 n1_289034_554944 4.0171399999999995
R11-857-112 n1_289034_554944 n1_311226_554944 3.96286
R11-857-113 n1_311226_554944 n1_333722_554944 4.0171399999999995
R11-857-114 n1_333722_554944 n1_355914_554944 3.96286
R11-857-115 n1_355914_554944 n1_378410_554944 4.0171399999999995
R11-857-116 n1_378410_554944 n1_400602_554944 3.96286
R11-857-117 n1_400602_554944 n1_422794_554944 3.96286
R11-857-118 n1_422794_554944 n1_445290_554944 4.0171399999999995
R11-857-119 n1_445290_554944 n1_467482_554944 3.96286
R11-857-120 n1_467482_554944 n1_489978_554944 4.0171399999999995
R11-857-121 n1_489978_554944 n1_512170_554944 3.96286
R11-857-122 n1_512170_554944 n1_534666_554944 4.0171399999999995
R11-857-123 n1_534666_554944 n1_556858_554944 3.96286
R11-857-124 n1_556858_554944 n1_579050_554944 3.96286
R11-857-125 n1_579050_554944 n1_601546_554944 4.0171399999999995
R11-857-126 n1_601546_554944 n1_623064_554944 3.8425
R11-857-127 n1_623064_554944 n1_625064_554944 0.357143
R11-858-100 n1_623064_554944 n1_625064_554944 0.333333
R11-858-101 n1_625064_554944 n1_627064_554944 0.357143
R11-859-100 n1_625064_554944 n1_627064_554944 0.333333
R11-860-100 n1_44000_558288 n1_46000_558288 0.333333
R11-861-100 n1_44000_558288 n1_46000_558288 0.357143
R11-861-101 n1_46000_558288 n1_48000_558288 0.333333
R11-862-100 n1_46000_558288 n1_48000_558288 0.357143
R11-862-101 n1_48000_558288 n1_65594_558288 3.14179
R11-862-102 n1_65594_558288 n1_88090_558288 4.0171399999999995
R11-862-103 n1_88090_558288 n1_110282_558288 3.96286
R11-862-104 n1_110282_558288 n1_132778_558288 4.0171399999999995
R11-862-105 n1_132778_558288 n1_154970_558288 3.96286
R11-862-106 n1_154970_558288 n1_177466_558288 4.0171399999999995
R11-862-107 n1_177466_558288 n1_199658_558288 3.96286
R11-862-108 n1_199658_558288 n1_221850_558288 3.96286
R11-862-109 n1_221850_558288 n1_244346_558288 4.0171399999999995
R11-862-110 n1_244346_558288 n1_266538_558288 3.96286
R11-862-111 n1_266538_558288 n1_289034_558288 4.0171399999999995
R11-862-112 n1_289034_558288 n1_311226_558288 3.96286
R11-862-113 n1_311226_558288 n1_333722_558288 4.0171399999999995
R11-862-114 n1_333722_558288 n1_355914_558288 3.96286
R11-862-115 n1_355914_558288 n1_378410_558288 4.0171399999999995
R11-862-116 n1_378410_558288 n1_400602_558288 3.96286
R11-862-117 n1_400602_558288 n1_422794_558288 3.96286
R11-862-118 n1_422794_558288 n1_445290_558288 4.0171399999999995
R11-862-119 n1_445290_558288 n1_467482_558288 3.96286
R11-862-120 n1_467482_558288 n1_489978_558288 4.0171399999999995
R11-862-121 n1_489978_558288 n1_512170_558288 3.96286
R11-862-122 n1_512170_558288 n1_534666_558288 4.0171399999999995
R11-862-123 n1_534666_558288 n1_556858_558288 3.96286
R11-862-124 n1_556858_558288 n1_579050_558288 3.96286
R11-862-125 n1_579050_558288 n1_601546_558288 4.0171399999999995
R11-862-126 n1_601546_558288 n1_623064_558288 3.8425
R11-862-127 n1_623064_558288 n1_625064_558288 0.357143
R11-863-100 n1_623064_558288 n1_625064_558288 0.333333
R11-863-101 n1_625064_558288 n1_627064_558288 0.357143
R11-864-100 n1_625064_558288 n1_627064_558288 0.333333
R11-865-100 n1_44000_561632 n1_46000_561632 0.333333
R11-866-100 n1_44000_561632 n1_46000_561632 0.357143
R11-866-101 n1_46000_561632 n1_48000_561632 0.333333
R11-867-100 n1_46000_561632 n1_48000_561632 0.357143
R11-867-101 n1_48000_561632 n1_65594_561632 3.14179
R11-867-102 n1_65594_561632 n1_88090_561632 4.0171399999999995
R11-867-103 n1_88090_561632 n1_110282_561632 3.96286
R11-867-104 n1_110282_561632 n1_132778_561632 4.0171399999999995
R11-867-105 n1_132778_561632 n1_154970_561632 3.96286
R11-867-106 n1_154970_561632 n1_177466_561632 4.0171399999999995
R11-867-107 n1_177466_561632 n1_199658_561632 3.96286
R11-867-108 n1_199658_561632 n1_221850_561632 3.96286
R11-867-109 n1_221850_561632 n1_244346_561632 4.0171399999999995
R11-867-110 n1_244346_561632 n1_266538_561632 3.96286
R11-867-111 n1_266538_561632 n1_289034_561632 4.0171399999999995
R11-867-112 n1_289034_561632 n1_311226_561632 3.96286
R11-867-113 n1_311226_561632 n1_333722_561632 4.0171399999999995
R11-867-114 n1_333722_561632 n1_355914_561632 3.96286
R11-867-115 n1_355914_561632 n1_378410_561632 4.0171399999999995
R11-867-116 n1_378410_561632 n1_400602_561632 3.96286
R11-867-117 n1_400602_561632 n1_422794_561632 3.96286
R11-867-118 n1_422794_561632 n1_445290_561632 4.0171399999999995
R11-867-119 n1_445290_561632 n1_467482_561632 3.96286
R11-867-120 n1_467482_561632 n1_489978_561632 4.0171399999999995
R11-867-121 n1_489978_561632 n1_512170_561632 3.96286
R11-867-122 n1_512170_561632 n1_534666_561632 4.0171399999999995
R11-867-123 n1_534666_561632 n1_556858_561632 3.96286
R11-867-124 n1_556858_561632 n1_579050_561632 3.96286
R11-867-125 n1_579050_561632 n1_601546_561632 4.0171399999999995
R11-867-126 n1_601546_561632 n1_623064_561632 3.8425
R11-867-127 n1_623064_561632 n1_625064_561632 0.357143
R11-868-100 n1_623064_561632 n1_625064_561632 0.333333
R11-868-101 n1_625064_561632 n1_627064_561632 0.357143
R11-869-100 n1_625064_561632 n1_627064_561632 0.333333
R11-870-100 n1_44000_564976 n1_46000_564976 0.333333
R11-871-100 n1_44000_564976 n1_46000_564976 0.357143
R11-871-101 n1_46000_564976 n1_48000_564976 0.333333
R11-872-100 n1_46000_564976 n1_48000_564976 0.357143
R11-872-101 n1_48000_564976 n1_65594_564976 3.14179
R11-872-102 n1_65594_564976 n1_88090_564976 4.0171399999999995
R11-872-103 n1_88090_564976 n1_110282_564976 3.96286
R11-872-104 n1_110282_564976 n1_132778_564976 4.0171399999999995
R11-872-105 n1_132778_564976 n1_154970_564976 3.96286
R11-872-106 n1_154970_564976 n1_177466_564976 4.0171399999999995
R11-872-107 n1_177466_564976 n1_199658_564976 3.96286
R11-872-108 n1_199658_564976 n1_221850_564976 3.96286
R11-872-109 n1_221850_564976 n1_244346_564976 4.0171399999999995
R11-872-110 n1_244346_564976 n1_266538_564976 3.96286
R11-872-111 n1_266538_564976 n1_289034_564976 4.0171399999999995
R11-872-112 n1_289034_564976 n1_311226_564976 3.96286
R11-872-113 n1_311226_564976 n1_333722_564976 4.0171399999999995
R11-872-114 n1_333722_564976 n1_355914_564976 3.96286
R11-872-115 n1_355914_564976 n1_378410_564976 4.0171399999999995
R11-872-116 n1_378410_564976 n1_400602_564976 3.96286
R11-872-117 n1_400602_564976 n1_422794_564976 3.96286
R11-872-118 n1_422794_564976 n1_445290_564976 4.0171399999999995
R11-872-119 n1_445290_564976 n1_467482_564976 3.96286
R11-872-120 n1_467482_564976 n1_489978_564976 4.0171399999999995
R11-872-121 n1_489978_564976 n1_512170_564976 3.96286
R11-872-122 n1_512170_564976 n1_534666_564976 4.0171399999999995
R11-872-123 n1_534666_564976 n1_556858_564976 3.96286
R11-872-124 n1_556858_564976 n1_579050_564976 3.96286
R11-872-125 n1_579050_564976 n1_601546_564976 4.0171399999999995
R11-872-126 n1_601546_564976 n1_623064_564976 3.8425
R11-872-127 n1_623064_564976 n1_625064_564976 0.357143
R11-873-100 n1_623064_564976 n1_625064_564976 0.333333
R11-873-101 n1_625064_564976 n1_627064_564976 0.357143
R11-874-100 n1_625064_564976 n1_627064_564976 0.333333
R11-875-100 n1_44000_568320 n1_46000_568320 0.333333
R11-876-100 n1_44000_568320 n1_46000_568320 0.357143
R11-876-101 n1_46000_568320 n1_48000_568320 0.333333
R11-877-100 n1_46000_568320 n1_48000_568320 0.357143
R11-877-101 n1_48000_568320 n1_65594_568320 3.14179
R11-877-102 n1_65594_568320 n1_88090_568320 4.0171399999999995
R11-877-103 n1_88090_568320 n1_110282_568320 3.96286
R11-877-104 n1_110282_568320 n1_132778_568320 4.0171399999999995
R11-877-105 n1_132778_568320 n1_154970_568320 3.96286
R11-877-106 n1_154970_568320 n1_177466_568320 4.0171399999999995
R11-877-107 n1_177466_568320 n1_199658_568320 3.96286
R11-877-108 n1_199658_568320 n1_221850_568320 3.96286
R11-877-109 n1_221850_568320 n1_244346_568320 4.0171399999999995
R11-877-110 n1_244346_568320 n1_266538_568320 3.96286
R11-877-111 n1_266538_568320 n1_289034_568320 4.0171399999999995
R11-877-112 n1_289034_568320 n1_311226_568320 3.96286
R11-877-113 n1_311226_568320 n1_333722_568320 4.0171399999999995
R11-877-114 n1_333722_568320 n1_355914_568320 3.96286
R11-877-115 n1_355914_568320 n1_378410_568320 4.0171399999999995
R11-877-116 n1_378410_568320 n1_400602_568320 3.96286
R11-877-117 n1_400602_568320 n1_422794_568320 3.96286
R11-877-118 n1_422794_568320 n1_445290_568320 4.0171399999999995
R11-877-119 n1_445290_568320 n1_467482_568320 3.96286
R11-877-120 n1_467482_568320 n1_489978_568320 4.0171399999999995
R11-877-121 n1_489978_568320 n1_512170_568320 3.96286
R11-877-122 n1_512170_568320 n1_534666_568320 4.0171399999999995
R11-877-123 n1_534666_568320 n1_556858_568320 3.96286
R11-877-124 n1_556858_568320 n1_579050_568320 3.96286
R11-877-125 n1_579050_568320 n1_601546_568320 4.0171399999999995
R11-877-126 n1_601546_568320 n1_623064_568320 3.8425
R11-877-127 n1_623064_568320 n1_625064_568320 0.357143
R11-878-100 n1_623064_568320 n1_625064_568320 0.333333
R11-878-101 n1_625064_568320 n1_627064_568320 0.333333
R11-879-100 n1_625064_568320 n1_627064_568320 0.357143
R11-880-100 n1_44000_571664 n1_46000_571664 0.333333
R11-881-100 n1_44000_571664 n1_46000_571664 0.357143
R11-881-101 n1_46000_571664 n1_48000_571664 0.333333
R11-882-100 n1_46000_571664 n1_48000_571664 0.357143
R11-882-101 n1_48000_571664 n1_65594_571664 3.14179
R11-882-102 n1_65594_571664 n1_88090_571664 4.0171399999999995
R11-882-103 n1_88090_571664 n1_110282_571664 3.96286
R11-882-104 n1_110282_571664 n1_132778_571664 4.0171399999999995
R11-882-105 n1_132778_571664 n1_154970_571664 3.96286
R11-882-106 n1_154970_571664 n1_177466_571664 4.0171399999999995
R11-882-107 n1_177466_571664 n1_199658_571664 3.96286
R11-882-108 n1_199658_571664 n1_221850_571664 3.96286
R11-882-109 n1_221850_571664 n1_244346_571664 4.0171399999999995
R11-882-110 n1_244346_571664 n1_266538_571664 3.96286
R11-882-111 n1_266538_571664 n1_289034_571664 4.0171399999999995
R11-882-112 n1_289034_571664 n1_311226_571664 3.96286
R11-882-113 n1_311226_571664 n1_333722_571664 4.0171399999999995
R11-882-114 n1_333722_571664 n1_355914_571664 3.96286
R11-882-115 n1_355914_571664 n1_378410_571664 4.0171399999999995
R11-882-116 n1_378410_571664 n1_400602_571664 3.96286
R11-882-117 n1_400602_571664 n1_422794_571664 3.96286
R11-882-118 n1_422794_571664 n1_445290_571664 4.0171399999999995
R11-882-119 n1_445290_571664 n1_467482_571664 3.96286
R11-882-120 n1_467482_571664 n1_489978_571664 4.0171399999999995
R11-882-121 n1_489978_571664 n1_512170_571664 3.96286
R11-882-122 n1_512170_571664 n1_534666_571664 4.0171399999999995
R11-882-123 n1_534666_571664 n1_556858_571664 3.96286
R11-882-124 n1_556858_571664 n1_579050_571664 3.96286
R11-882-125 n1_579050_571664 n1_601546_571664 4.0171399999999995
R11-882-126 n1_601546_571664 n1_623064_571664 3.8425
R11-882-127 n1_623064_571664 n1_625064_571664 0.357143
R11-883-100 n1_623064_571664 n1_625064_571664 0.333333
R11-883-101 n1_625064_571664 n1_627064_571664 0.357143
R11-884-100 n1_625064_571664 n1_627064_571664 0.333333
R11-885-100 n1_44000_575008 n1_46000_575008 0.333333
R11-886-100 n1_44000_575008 n1_46000_575008 0.357143
R11-886-101 n1_46000_575008 n1_48000_575008 0.333333
R11-887-100 n1_46000_575008 n1_48000_575008 0.357143
R11-887-101 n1_48000_575008 n1_65594_575008 3.14179
R11-887-102 n1_65594_575008 n1_88090_575008 4.0171399999999995
R11-887-103 n1_88090_575008 n1_110282_575008 3.96286
R11-887-104 n1_110282_575008 n1_132778_575008 4.0171399999999995
R11-887-105 n1_132778_575008 n1_154970_575008 3.96286
R11-887-106 n1_154970_575008 n1_177466_575008 4.0171399999999995
R11-887-107 n1_177466_575008 n1_199658_575008 3.96286
R11-887-108 n1_199658_575008 n1_221850_575008 3.96286
R11-887-109 n1_221850_575008 n1_244346_575008 4.0171399999999995
R11-887-110 n1_244346_575008 n1_266538_575008 3.96286
R11-887-111 n1_266538_575008 n1_289034_575008 4.0171399999999995
R11-887-112 n1_289034_575008 n1_311226_575008 3.96286
R11-887-113 n1_311226_575008 n1_333722_575008 4.0171399999999995
R11-887-114 n1_333722_575008 n1_355914_575008 3.96286
R11-887-115 n1_355914_575008 n1_378410_575008 4.0171399999999995
R11-887-116 n1_378410_575008 n1_400602_575008 3.96286
R11-887-117 n1_400602_575008 n1_422794_575008 3.96286
R11-887-118 n1_422794_575008 n1_445290_575008 4.0171399999999995
R11-887-119 n1_445290_575008 n1_467482_575008 3.96286
R11-887-120 n1_467482_575008 n1_489978_575008 4.0171399999999995
R11-887-121 n1_489978_575008 n1_512170_575008 3.96286
R11-887-122 n1_512170_575008 n1_534666_575008 4.0171399999999995
R11-887-123 n1_534666_575008 n1_556858_575008 3.96286
R11-887-124 n1_556858_575008 n1_579050_575008 3.96286
R11-887-125 n1_579050_575008 n1_601546_575008 4.0171399999999995
R11-887-126 n1_601546_575008 n1_623064_575008 3.8425
R11-887-127 n1_623064_575008 n1_625064_575008 0.357143
R11-888-100 n1_623064_575008 n1_625064_575008 0.333333
R11-888-101 n1_625064_575008 n1_627064_575008 0.357143
R11-889-100 n1_625064_575008 n1_627064_575008 0.333333
R11-890-100 n1_44000_578352 n1_46000_578352 0.333333
R11-891-100 n1_44000_578352 n1_46000_578352 0.357143
R11-891-101 n1_46000_578352 n1_48000_578352 0.333333
R11-892-100 n1_46000_578352 n1_48000_578352 0.357143
R11-892-101 n1_48000_578352 n1_65594_578352 3.14179
R11-892-102 n1_65594_578352 n1_88090_578352 4.0171399999999995
R11-892-103 n1_88090_578352 n1_110282_578352 3.96286
R11-892-104 n1_110282_578352 n1_132778_578352 4.0171399999999995
R11-892-105 n1_132778_578352 n1_154970_578352 3.96286
R11-892-106 n1_154970_578352 n1_177466_578352 4.0171399999999995
R11-892-107 n1_177466_578352 n1_199658_578352 3.96286
R11-892-108 n1_199658_578352 n1_221850_578352 3.96286
R11-892-109 n1_221850_578352 n1_244346_578352 4.0171399999999995
R11-892-110 n1_244346_578352 n1_266538_578352 3.96286
R11-892-111 n1_266538_578352 n1_289034_578352 4.0171399999999995
R11-892-112 n1_289034_578352 n1_311226_578352 3.96286
R11-892-113 n1_311226_578352 n1_333722_578352 4.0171399999999995
R11-892-114 n1_333722_578352 n1_355914_578352 3.96286
R11-892-115 n1_355914_578352 n1_378410_578352 4.0171399999999995
R11-892-116 n1_378410_578352 n1_400602_578352 3.96286
R11-892-117 n1_400602_578352 n1_422794_578352 3.96286
R11-892-118 n1_422794_578352 n1_445290_578352 4.0171399999999995
R11-892-119 n1_445290_578352 n1_467482_578352 3.96286
R11-892-120 n1_467482_578352 n1_489978_578352 4.0171399999999995
R11-892-121 n1_489978_578352 n1_512170_578352 3.96286
R11-892-122 n1_512170_578352 n1_534666_578352 4.0171399999999995
R11-892-123 n1_534666_578352 n1_556858_578352 3.96286
R11-892-124 n1_556858_578352 n1_579050_578352 3.96286
R11-892-125 n1_579050_578352 n1_601546_578352 4.0171399999999995
R11-892-126 n1_601546_578352 n1_623064_578352 3.8425
R11-892-127 n1_623064_578352 n1_625064_578352 0.357143
R11-893-100 n1_623064_578352 n1_625064_578352 0.333333
R11-893-101 n1_625064_578352 n1_627064_578352 0.333333
R11-894-100 n1_625064_578352 n1_627064_578352 0.357143
R11-895-100 n1_44000_581696 n1_46000_581696 0.333333
R11-896-100 n1_44000_581696 n1_46000_581696 0.357143
R11-896-101 n1_46000_581696 n1_48000_581696 0.333333
R11-897-100 n1_46000_581696 n1_48000_581696 0.357143
R11-897-101 n1_48000_581696 n1_65594_581696 3.14179
R11-897-102 n1_65594_581696 n1_88090_581696 4.0171399999999995
R11-897-103 n1_88090_581696 n1_110282_581696 3.96286
R11-897-104 n1_110282_581696 n1_132778_581696 4.0171399999999995
R11-897-105 n1_132778_581696 n1_154970_581696 3.96286
R11-897-106 n1_154970_581696 n1_177466_581696 4.0171399999999995
R11-897-107 n1_177466_581696 n1_199658_581696 3.96286
R11-897-108 n1_199658_581696 n1_221850_581696 3.96286
R11-897-109 n1_221850_581696 n1_244346_581696 4.0171399999999995
R11-897-110 n1_244346_581696 n1_266538_581696 3.96286
R11-897-111 n1_266538_581696 n1_289034_581696 4.0171399999999995
R11-897-112 n1_289034_581696 n1_311226_581696 3.96286
R11-897-113 n1_311226_581696 n1_333722_581696 4.0171399999999995
R11-897-114 n1_333722_581696 n1_355914_581696 3.96286
R11-897-115 n1_355914_581696 n1_378410_581696 4.0171399999999995
R11-897-116 n1_378410_581696 n1_400602_581696 3.96286
R11-897-117 n1_400602_581696 n1_422794_581696 3.96286
R11-897-118 n1_422794_581696 n1_445290_581696 4.0171399999999995
R11-897-119 n1_445290_581696 n1_467482_581696 3.96286
R11-897-120 n1_467482_581696 n1_489978_581696 4.0171399999999995
R11-897-121 n1_489978_581696 n1_512170_581696 3.96286
R11-897-122 n1_512170_581696 n1_534666_581696 4.0171399999999995
R11-897-123 n1_534666_581696 n1_556858_581696 3.96286
R11-897-124 n1_556858_581696 n1_579050_581696 3.96286
R11-897-125 n1_579050_581696 n1_601546_581696 4.0171399999999995
R11-897-126 n1_601546_581696 n1_623064_581696 3.8425
R11-897-127 n1_623064_581696 n1_625064_581696 0.357143
R11-898-100 n1_623064_581696 n1_625064_581696 0.333333
R11-898-101 n1_625064_581696 n1_627064_581696 0.357143
R11-899-100 n1_625064_581696 n1_627064_581696 0.333333
R11-900-100 n1_44000_585040 n1_46000_585040 0.333333
R11-901-100 n1_44000_585040 n1_46000_585040 0.357143
R11-901-101 n1_46000_585040 n1_48000_585040 0.333333
R11-902-100 n1_46000_585040 n1_48000_585040 0.357143
R11-902-101 n1_48000_585040 n1_65594_585040 3.14179
R11-902-102 n1_65594_585040 n1_88090_585040 4.0171399999999995
R11-902-103 n1_88090_585040 n1_110282_585040 3.96286
R11-902-104 n1_110282_585040 n1_132778_585040 4.0171399999999995
R11-902-105 n1_132778_585040 n1_154970_585040 3.96286
R11-902-106 n1_154970_585040 n1_177466_585040 4.0171399999999995
R11-902-107 n1_177466_585040 n1_199658_585040 3.96286
R11-902-108 n1_199658_585040 n1_221850_585040 3.96286
R11-902-109 n1_221850_585040 n1_244346_585040 4.0171399999999995
R11-902-110 n1_244346_585040 n1_266538_585040 3.96286
R11-902-111 n1_266538_585040 n1_289034_585040 4.0171399999999995
R11-902-112 n1_289034_585040 n1_311226_585040 3.96286
R11-902-113 n1_311226_585040 n1_333722_585040 4.0171399999999995
R11-902-114 n1_333722_585040 n1_355914_585040 3.96286
R11-902-115 n1_355914_585040 n1_378410_585040 4.0171399999999995
R11-902-116 n1_378410_585040 n1_400602_585040 3.96286
R11-902-117 n1_400602_585040 n1_422794_585040 3.96286
R11-902-118 n1_422794_585040 n1_445290_585040 4.0171399999999995
R11-902-119 n1_445290_585040 n1_467482_585040 3.96286
R11-902-120 n1_467482_585040 n1_489978_585040 4.0171399999999995
R11-902-121 n1_489978_585040 n1_512170_585040 3.96286
R11-902-122 n1_512170_585040 n1_534666_585040 4.0171399999999995
R11-902-123 n1_534666_585040 n1_556858_585040 3.96286
R11-902-124 n1_556858_585040 n1_579050_585040 3.96286
R11-902-125 n1_579050_585040 n1_601546_585040 4.0171399999999995
R11-902-126 n1_601546_585040 n1_623064_585040 3.8425
R11-902-127 n1_623064_585040 n1_625064_585040 0.357143
R11-903-100 n1_623064_585040 n1_625064_585040 0.333333
R11-903-101 n1_625064_585040 n1_627064_585040 0.357143
R11-904-100 n1_625064_585040 n1_627064_585040 0.333333
R11-905-100 n1_44000_588384 n1_46000_588384 0.333333
R11-906-100 n1_44000_588384 n1_46000_588384 0.357143
R11-906-101 n1_46000_588384 n1_48000_588384 0.333333
R11-907-100 n1_46000_588384 n1_48000_588384 0.357143
R11-907-101 n1_48000_588384 n1_65594_588384 3.14179
R11-907-102 n1_65594_588384 n1_88090_588384 4.0171399999999995
R11-907-103 n1_88090_588384 n1_110282_588384 3.96286
R11-907-104 n1_110282_588384 n1_132778_588384 4.0171399999999995
R11-907-105 n1_132778_588384 n1_154970_588384 3.96286
R11-907-106 n1_154970_588384 n1_177466_588384 4.0171399999999995
R11-907-107 n1_177466_588384 n1_199658_588384 3.96286
R11-907-108 n1_199658_588384 n1_221850_588384 3.96286
R11-907-109 n1_221850_588384 n1_244346_588384 4.0171399999999995
R11-907-110 n1_244346_588384 n1_266538_588384 3.96286
R11-907-111 n1_266538_588384 n1_289034_588384 4.0171399999999995
R11-907-112 n1_289034_588384 n1_311226_588384 3.96286
R11-907-113 n1_311226_588384 n1_333722_588384 4.0171399999999995
R11-907-114 n1_333722_588384 n1_355914_588384 3.96286
R11-907-115 n1_355914_588384 n1_378410_588384 4.0171399999999995
R11-907-116 n1_378410_588384 n1_400602_588384 3.96286
R11-907-117 n1_400602_588384 n1_422794_588384 3.96286
R11-907-118 n1_422794_588384 n1_445290_588384 4.0171399999999995
R11-907-119 n1_445290_588384 n1_467482_588384 3.96286
R11-907-120 n1_467482_588384 n1_489978_588384 4.0171399999999995
R11-907-121 n1_489978_588384 n1_512170_588384 3.96286
R11-907-122 n1_512170_588384 n1_534666_588384 4.0171399999999995
R11-907-123 n1_534666_588384 n1_556858_588384 3.96286
R11-907-124 n1_556858_588384 n1_579050_588384 3.96286
R11-907-125 n1_579050_588384 n1_601546_588384 4.0171399999999995
R11-907-126 n1_601546_588384 n1_623064_588384 3.8425
R11-907-127 n1_623064_588384 n1_625064_588384 0.357143
R11-908-100 n1_623064_588384 n1_625064_588384 0.333333
R11-908-101 n1_625064_588384 n1_627064_588384 0.357143
R11-909-100 n1_625064_588384 n1_627064_588384 0.333333
R11-910-100 n1_44000_591728 n1_46000_591728 0.333333
R11-911-100 n1_44000_591728 n1_46000_591728 0.357143
R11-911-101 n1_46000_591728 n1_48000_591728 0.333333
R11-912-100 n1_46000_591728 n1_48000_591728 0.357143
R11-912-101 n1_48000_591728 n1_65594_591728 3.14179
R11-912-102 n1_65594_591728 n1_88090_591728 4.0171399999999995
R11-912-103 n1_88090_591728 n1_110282_591728 3.96286
R11-912-104 n1_110282_591728 n1_132778_591728 4.0171399999999995
R11-912-105 n1_132778_591728 n1_154970_591728 3.96286
R11-912-106 n1_154970_591728 n1_177466_591728 4.0171399999999995
R11-912-107 n1_177466_591728 n1_199658_591728 3.96286
R11-912-108 n1_199658_591728 n1_221850_591728 3.96286
R11-912-109 n1_221850_591728 n1_244346_591728 4.0171399999999995
R11-912-110 n1_244346_591728 n1_266538_591728 3.96286
R11-912-111 n1_266538_591728 n1_289034_591728 4.0171399999999995
R11-912-112 n1_289034_591728 n1_311226_591728 3.96286
R11-912-113 n1_311226_591728 n1_333722_591728 4.0171399999999995
R11-912-114 n1_333722_591728 n1_355914_591728 3.96286
R11-912-115 n1_355914_591728 n1_378410_591728 4.0171399999999995
R11-912-116 n1_378410_591728 n1_400602_591728 3.96286
R11-912-117 n1_400602_591728 n1_422794_591728 3.96286
R11-912-118 n1_422794_591728 n1_445290_591728 4.0171399999999995
R11-912-119 n1_445290_591728 n1_467482_591728 3.96286
R11-912-120 n1_467482_591728 n1_489978_591728 4.0171399999999995
R11-912-121 n1_489978_591728 n1_512170_591728 3.96286
R11-912-122 n1_512170_591728 n1_534666_591728 4.0171399999999995
R11-912-123 n1_534666_591728 n1_556858_591728 3.96286
R11-912-124 n1_556858_591728 n1_579050_591728 3.96286
R11-912-125 n1_579050_591728 n1_601546_591728 4.0171399999999995
R11-912-126 n1_601546_591728 n1_623064_591728 3.8425
R11-912-127 n1_623064_591728 n1_625064_591728 0.357143
R11-913-100 n1_623064_591728 n1_625064_591728 0.333333
R11-913-101 n1_625064_591728 n1_627064_591728 0.357143
R11-914-100 n1_625064_591728 n1_627064_591728 0.333333
R11-915-100 n1_44000_595072 n1_46000_595072 0.333333
R11-916-100 n1_44000_595072 n1_46000_595072 0.357143
R11-916-101 n1_46000_595072 n1_48000_595072 0.333333
R11-917-100 n1_46000_595072 n1_48000_595072 0.357143
R11-917-101 n1_48000_595072 n1_65594_595072 3.14179
R11-917-102 n1_65594_595072 n1_88090_595072 4.0171399999999995
R11-917-103 n1_88090_595072 n1_110282_595072 3.96286
R11-917-104 n1_110282_595072 n1_132778_595072 4.0171399999999995
R11-917-105 n1_132778_595072 n1_154970_595072 3.96286
R11-917-106 n1_154970_595072 n1_177466_595072 4.0171399999999995
R11-917-107 n1_177466_595072 n1_199658_595072 3.96286
R11-917-108 n1_199658_595072 n1_221850_595072 3.96286
R11-917-109 n1_221850_595072 n1_244346_595072 4.0171399999999995
R11-917-110 n1_244346_595072 n1_266538_595072 3.96286
R11-917-111 n1_266538_595072 n1_289034_595072 4.0171399999999995
R11-917-112 n1_289034_595072 n1_311226_595072 3.96286
R11-917-113 n1_311226_595072 n1_333722_595072 4.0171399999999995
R11-917-114 n1_333722_595072 n1_355914_595072 3.96286
R11-917-115 n1_355914_595072 n1_378410_595072 4.0171399999999995
R11-917-116 n1_378410_595072 n1_400602_595072 3.96286
R11-917-117 n1_400602_595072 n1_422794_595072 3.96286
R11-917-118 n1_422794_595072 n1_445290_595072 4.0171399999999995
R11-917-119 n1_445290_595072 n1_467482_595072 3.96286
R11-917-120 n1_467482_595072 n1_489978_595072 4.0171399999999995
R11-917-121 n1_489978_595072 n1_512170_595072 3.96286
R11-917-122 n1_512170_595072 n1_534666_595072 4.0171399999999995
R11-917-123 n1_534666_595072 n1_556858_595072 3.96286
R11-917-124 n1_556858_595072 n1_579050_595072 3.96286
R11-917-125 n1_579050_595072 n1_601546_595072 4.0171399999999995
R11-917-126 n1_601546_595072 n1_623064_595072 3.8425
R11-917-127 n1_623064_595072 n1_625064_595072 0.357143
R11-918-100 n1_623064_595072 n1_625064_595072 0.333333
R11-918-101 n1_625064_595072 n1_627064_595072 0.357143
R11-919-100 n1_625064_595072 n1_627064_595072 0.333333
R11-920-100 n1_44000_598416 n1_46000_598416 0.333333
R11-921-100 n1_44000_598416 n1_46000_598416 0.357143
R11-921-101 n1_46000_598416 n1_48000_598416 0.333333
R11-922-100 n1_46000_598416 n1_48000_598416 0.357143
R11-922-101 n1_48000_598416 n1_65594_598416 3.14179
R11-922-102 n1_65594_598416 n1_88090_598416 4.0171399999999995
R11-922-103 n1_88090_598416 n1_110282_598416 3.96286
R11-922-104 n1_110282_598416 n1_132778_598416 4.0171399999999995
R11-922-105 n1_132778_598416 n1_154970_598416 3.96286
R11-922-106 n1_154970_598416 n1_177466_598416 4.0171399999999995
R11-922-107 n1_177466_598416 n1_199658_598416 3.96286
R11-922-108 n1_199658_598416 n1_221850_598416 3.96286
R11-922-109 n1_221850_598416 n1_244346_598416 4.0171399999999995
R11-922-110 n1_244346_598416 n1_266538_598416 3.96286
R11-922-111 n1_266538_598416 n1_289034_598416 4.0171399999999995
R11-922-112 n1_289034_598416 n1_311226_598416 3.96286
R11-922-113 n1_311226_598416 n1_333722_598416 4.0171399999999995
R11-922-114 n1_333722_598416 n1_355914_598416 3.96286
R11-922-115 n1_355914_598416 n1_378410_598416 4.0171399999999995
R11-922-116 n1_378410_598416 n1_400602_598416 3.96286
R11-922-117 n1_400602_598416 n1_422794_598416 3.96286
R11-922-118 n1_422794_598416 n1_445290_598416 4.0171399999999995
R11-922-119 n1_445290_598416 n1_467482_598416 3.96286
R11-922-120 n1_467482_598416 n1_489978_598416 4.0171399999999995
R11-922-121 n1_489978_598416 n1_512170_598416 3.96286
R11-922-122 n1_512170_598416 n1_534666_598416 4.0171399999999995
R11-922-123 n1_534666_598416 n1_556858_598416 3.96286
R11-922-124 n1_556858_598416 n1_579050_598416 3.96286
R11-922-125 n1_579050_598416 n1_601546_598416 4.0171399999999995
R11-922-126 n1_601546_598416 n1_623064_598416 3.8425
R11-922-127 n1_623064_598416 n1_625064_598416 0.357143
R11-923-100 n1_623064_598416 n1_625064_598416 0.333333
R11-923-101 n1_625064_598416 n1_627064_598416 0.357143
R11-924-100 n1_625064_598416 n1_627064_598416 0.333333
R11-925-100 n1_44000_601760 n1_46000_601760 0.333333
R11-926-100 n1_44000_601760 n1_46000_601760 0.357143
R11-926-101 n1_46000_601760 n1_48000_601760 0.333333
R11-927-100 n1_46000_601760 n1_48000_601760 0.357143
R11-927-101 n1_48000_601760 n1_65594_601760 3.14179
R11-927-102 n1_65594_601760 n1_88090_601760 4.0171399999999995
R11-927-103 n1_88090_601760 n1_110282_601760 3.96286
R11-927-104 n1_110282_601760 n1_132778_601760 4.0171399999999995
R11-927-105 n1_132778_601760 n1_154970_601760 3.96286
R11-927-106 n1_154970_601760 n1_177466_601760 4.0171399999999995
R11-927-107 n1_177466_601760 n1_199658_601760 3.96286
R11-927-108 n1_199658_601760 n1_221850_601760 3.96286
R11-927-109 n1_221850_601760 n1_244346_601760 4.0171399999999995
R11-927-110 n1_244346_601760 n1_266538_601760 3.96286
R11-927-111 n1_266538_601760 n1_289034_601760 4.0171399999999995
R11-927-112 n1_289034_601760 n1_311226_601760 3.96286
R11-927-113 n1_311226_601760 n1_333722_601760 4.0171399999999995
R11-927-114 n1_333722_601760 n1_355914_601760 3.96286
R11-927-115 n1_355914_601760 n1_378410_601760 4.0171399999999995
R11-927-116 n1_378410_601760 n1_400602_601760 3.96286
R11-927-117 n1_400602_601760 n1_422794_601760 3.96286
R11-927-118 n1_422794_601760 n1_445290_601760 4.0171399999999995
R11-927-119 n1_445290_601760 n1_467482_601760 3.96286
R11-927-120 n1_467482_601760 n1_489978_601760 4.0171399999999995
R11-927-121 n1_489978_601760 n1_512170_601760 3.96286
R11-927-122 n1_512170_601760 n1_534666_601760 4.0171399999999995
R11-927-123 n1_534666_601760 n1_556858_601760 3.96286
R11-927-124 n1_556858_601760 n1_579050_601760 3.96286
R11-927-125 n1_579050_601760 n1_601546_601760 4.0171399999999995
R11-927-126 n1_601546_601760 n1_623064_601760 3.8425
R11-927-127 n1_623064_601760 n1_625064_601760 0.333333
R11-928-100 n1_623064_601760 n1_625064_601760 0.357143
R11-928-101 n1_625064_601760 n1_627064_601760 0.333333
R11-929-100 n1_625064_601760 n1_627064_601760 0.357143
R11-930-100 n1_44000_605104 n1_46000_605104 0.333333
R11-931-100 n1_44000_605104 n1_46000_605104 0.357143
R11-931-101 n1_46000_605104 n1_48000_605104 0.333333
R11-932-100 n1_46000_605104 n1_48000_605104 0.357143
R11-932-101 n1_48000_605104 n1_65594_605104 3.14179
R11-932-102 n1_65594_605104 n1_88090_605104 4.0171399999999995
R11-932-103 n1_88090_605104 n1_110282_605104 3.96286
R11-932-104 n1_110282_605104 n1_132778_605104 4.0171399999999995
R11-932-105 n1_132778_605104 n1_154970_605104 3.96286
R11-932-106 n1_154970_605104 n1_177466_605104 4.0171399999999995
R11-932-107 n1_177466_605104 n1_199658_605104 3.96286
R11-932-108 n1_199658_605104 n1_221850_605104 3.96286
R11-932-109 n1_221850_605104 n1_244346_605104 4.0171399999999995
R11-932-110 n1_244346_605104 n1_266538_605104 3.96286
R11-932-111 n1_266538_605104 n1_289034_605104 4.0171399999999995
R11-932-112 n1_289034_605104 n1_311226_605104 3.96286
R11-932-113 n1_311226_605104 n1_333722_605104 4.0171399999999995
R11-932-114 n1_333722_605104 n1_355914_605104 3.96286
R11-932-115 n1_355914_605104 n1_378410_605104 4.0171399999999995
R11-932-116 n1_378410_605104 n1_400602_605104 3.96286
R11-932-117 n1_400602_605104 n1_422794_605104 3.96286
R11-932-118 n1_422794_605104 n1_445290_605104 4.0171399999999995
R11-932-119 n1_445290_605104 n1_467482_605104 3.96286
R11-932-120 n1_467482_605104 n1_489978_605104 4.0171399999999995
R11-932-121 n1_489978_605104 n1_512170_605104 3.96286
R11-932-122 n1_512170_605104 n1_534666_605104 4.0171399999999995
R11-932-123 n1_534666_605104 n1_556858_605104 3.96286
R11-932-124 n1_556858_605104 n1_579050_605104 3.96286
R11-932-125 n1_579050_605104 n1_601546_605104 4.0171399999999995
R11-932-126 n1_601546_605104 n1_623064_605104 3.8425
R11-932-127 n1_623064_605104 n1_625064_605104 0.357143
R11-933-100 n1_623064_605104 n1_625064_605104 0.333333
R11-933-101 n1_625064_605104 n1_627064_605104 0.357143
R11-934-100 n1_625064_605104 n1_627064_605104 0.333333
R11-935-100 n1_44000_608448 n1_46000_608448 0.333333
R11-936-100 n1_44000_608448 n1_46000_608448 0.357143
R11-936-101 n1_46000_608448 n1_48000_608448 0.333333
R11-937-100 n1_46000_608448 n1_48000_608448 0.357143
R11-937-101 n1_48000_608448 n1_65594_608448 3.14179
R11-937-102 n1_65594_608448 n1_88090_608448 4.0171399999999995
R11-937-103 n1_88090_608448 n1_110282_608448 3.96286
R11-937-104 n1_110282_608448 n1_132778_608448 4.0171399999999995
R11-937-105 n1_132778_608448 n1_154970_608448 3.96286
R11-937-106 n1_154970_608448 n1_177466_608448 4.0171399999999995
R11-937-107 n1_177466_608448 n1_199658_608448 3.96286
R11-937-108 n1_199658_608448 n1_221850_608448 3.96286
R11-937-109 n1_221850_608448 n1_244346_608448 4.0171399999999995
R11-937-110 n1_244346_608448 n1_266538_608448 3.96286
R11-937-111 n1_266538_608448 n1_289034_608448 4.0171399999999995
R11-937-112 n1_289034_608448 n1_311226_608448 3.96286
R11-937-113 n1_311226_608448 n1_333722_608448 4.0171399999999995
R11-937-114 n1_333722_608448 n1_355914_608448 3.96286
R11-937-115 n1_355914_608448 n1_378410_608448 4.0171399999999995
R11-937-116 n1_378410_608448 n1_400602_608448 3.96286
R11-937-117 n1_400602_608448 n1_422794_608448 3.96286
R11-937-118 n1_422794_608448 n1_445290_608448 4.0171399999999995
R11-937-119 n1_445290_608448 n1_467482_608448 3.96286
R11-937-120 n1_467482_608448 n1_489978_608448 4.0171399999999995
R11-937-121 n1_489978_608448 n1_512170_608448 3.96286
R11-937-122 n1_512170_608448 n1_534666_608448 4.0171399999999995
R11-937-123 n1_534666_608448 n1_556858_608448 3.96286
R11-937-124 n1_556858_608448 n1_579050_608448 3.96286
R11-937-125 n1_579050_608448 n1_601546_608448 4.0171399999999995
R11-937-126 n1_601546_608448 n1_623064_608448 3.8425
R11-937-127 n1_623064_608448 n1_625064_608448 0.357143
R11-938-100 n1_623064_608448 n1_625064_608448 0.333333
R11-938-101 n1_625064_608448 n1_627064_608448 0.357143
R11-939-100 n1_625064_608448 n1_627064_608448 0.333333
R11-940-100 n1_44000_611792 n1_46000_611792 0.333333
R11-941-100 n1_44000_611792 n1_46000_611792 0.357143
R11-941-101 n1_46000_611792 n1_48000_611792 0.333333
R11-942-100 n1_46000_611792 n1_48000_611792 0.357143
R11-942-101 n1_48000_611792 n1_65594_611792 3.14179
R11-942-102 n1_65594_611792 n1_88090_611792 4.0171399999999995
R11-942-103 n1_88090_611792 n1_110282_611792 3.96286
R11-942-104 n1_110282_611792 n1_132778_611792 4.0171399999999995
R11-942-105 n1_132778_611792 n1_154970_611792 3.96286
R11-942-106 n1_154970_611792 n1_177466_611792 4.0171399999999995
R11-942-107 n1_177466_611792 n1_199658_611792 3.96286
R11-942-108 n1_199658_611792 n1_221850_611792 3.96286
R11-942-109 n1_221850_611792 n1_244346_611792 4.0171399999999995
R11-942-110 n1_244346_611792 n1_266538_611792 3.96286
R11-942-111 n1_266538_611792 n1_289034_611792 4.0171399999999995
R11-942-112 n1_289034_611792 n1_311226_611792 3.96286
R11-942-113 n1_311226_611792 n1_333722_611792 4.0171399999999995
R11-942-114 n1_333722_611792 n1_355914_611792 3.96286
R11-942-115 n1_355914_611792 n1_378410_611792 4.0171399999999995
R11-942-116 n1_378410_611792 n1_400602_611792 3.96286
R11-942-117 n1_400602_611792 n1_422794_611792 3.96286
R11-942-118 n1_422794_611792 n1_445290_611792 4.0171399999999995
R11-942-119 n1_445290_611792 n1_467482_611792 3.96286
R11-942-120 n1_467482_611792 n1_489978_611792 4.0171399999999995
R11-942-121 n1_489978_611792 n1_512170_611792 3.96286
R11-942-122 n1_512170_611792 n1_534666_611792 4.0171399999999995
R11-942-123 n1_534666_611792 n1_556858_611792 3.96286
R11-942-124 n1_556858_611792 n1_579050_611792 3.96286
R11-942-125 n1_579050_611792 n1_601546_611792 4.0171399999999995
R11-942-126 n1_601546_611792 n1_623064_611792 3.8425
R11-942-127 n1_623064_611792 n1_625064_611792 0.357143
R11-943-100 n1_623064_611792 n1_625064_611792 0.333333
R11-943-101 n1_625064_611792 n1_627064_611792 0.357143
R11-944-100 n1_625064_611792 n1_627064_611792 0.333333
R11-945-100 n1_44000_615136 n1_46000_615136 0.333333
R11-946-100 n1_44000_615136 n1_46000_615136 0.357143
R11-946-101 n1_46000_615136 n1_48000_615136 0.333333
R11-947-100 n1_46000_615136 n1_48000_615136 0.357143
R11-947-101 n1_48000_615136 n1_65594_615136 3.14179
R11-947-102 n1_65594_615136 n1_88090_615136 4.0171399999999995
R11-947-103 n1_88090_615136 n1_110282_615136 3.96286
R11-947-104 n1_110282_615136 n1_132778_615136 4.0171399999999995
R11-947-105 n1_132778_615136 n1_154970_615136 3.96286
R11-947-106 n1_154970_615136 n1_177466_615136 4.0171399999999995
R11-947-107 n1_177466_615136 n1_199658_615136 3.96286
R11-947-108 n1_199658_615136 n1_221850_615136 3.96286
R11-947-109 n1_221850_615136 n1_244346_615136 4.0171399999999995
R11-947-110 n1_244346_615136 n1_266538_615136 3.96286
R11-947-111 n1_266538_615136 n1_289034_615136 4.0171399999999995
R11-947-112 n1_289034_615136 n1_311226_615136 3.96286
R11-947-113 n1_311226_615136 n1_333722_615136 4.0171399999999995
R11-947-114 n1_333722_615136 n1_355914_615136 3.96286
R11-947-115 n1_355914_615136 n1_378410_615136 4.0171399999999995
R11-947-116 n1_378410_615136 n1_400602_615136 3.96286
R11-947-117 n1_400602_615136 n1_422794_615136 3.96286
R11-947-118 n1_422794_615136 n1_445290_615136 4.0171399999999995
R11-947-119 n1_445290_615136 n1_467482_615136 3.96286
R11-947-120 n1_467482_615136 n1_489978_615136 4.0171399999999995
R11-947-121 n1_489978_615136 n1_512170_615136 3.96286
R11-947-122 n1_512170_615136 n1_534666_615136 4.0171399999999995
R11-947-123 n1_534666_615136 n1_556858_615136 3.96286
R11-947-124 n1_556858_615136 n1_579050_615136 3.96286
R11-947-125 n1_579050_615136 n1_601546_615136 4.0171399999999995
R11-947-126 n1_601546_615136 n1_623064_615136 3.8425
R11-947-127 n1_623064_615136 n1_625064_615136 0.333333
R11-948-100 n1_623064_615136 n1_625064_615136 0.357143
R11-948-101 n1_625064_615136 n1_627064_615136 0.333333
R11-949-100 n1_625064_615136 n1_627064_615136 0.357143
R11-950-100 n1_44000_618480 n1_46000_618480 0.333333
R11-951-100 n1_44000_618480 n1_46000_618480 0.357143
R11-951-101 n1_46000_618480 n1_48000_618480 0.333333
R11-952-100 n1_46000_618480 n1_48000_618480 0.357143
R11-952-101 n1_48000_618480 n1_65594_618480 3.14179
R11-952-102 n1_65594_618480 n1_88090_618480 4.0171399999999995
R11-952-103 n1_88090_618480 n1_110282_618480 3.96286
R11-952-104 n1_110282_618480 n1_132778_618480 4.0171399999999995
R11-952-105 n1_132778_618480 n1_154970_618480 3.96286
R11-952-106 n1_154970_618480 n1_177466_618480 4.0171399999999995
R11-952-107 n1_177466_618480 n1_199658_618480 3.96286
R11-952-108 n1_199658_618480 n1_221850_618480 3.96286
R11-952-109 n1_221850_618480 n1_244346_618480 4.0171399999999995
R11-952-110 n1_244346_618480 n1_266538_618480 3.96286
R11-952-111 n1_266538_618480 n1_289034_618480 4.0171399999999995
R11-952-112 n1_289034_618480 n1_311226_618480 3.96286
R11-952-113 n1_311226_618480 n1_333722_618480 4.0171399999999995
R11-952-114 n1_333722_618480 n1_355914_618480 3.96286
R11-952-115 n1_355914_618480 n1_378410_618480 4.0171399999999995
R11-952-116 n1_378410_618480 n1_400602_618480 3.96286
R11-952-117 n1_400602_618480 n1_422794_618480 3.96286
R11-952-118 n1_422794_618480 n1_445290_618480 4.0171399999999995
R11-952-119 n1_445290_618480 n1_467482_618480 3.96286
R11-952-120 n1_467482_618480 n1_489978_618480 4.0171399999999995
R11-952-121 n1_489978_618480 n1_512170_618480 3.96286
R11-952-122 n1_512170_618480 n1_534666_618480 4.0171399999999995
R11-952-123 n1_534666_618480 n1_556858_618480 3.96286
R11-952-124 n1_556858_618480 n1_579050_618480 3.96286
R11-952-125 n1_579050_618480 n1_601546_618480 4.0171399999999995
R11-952-126 n1_601546_618480 n1_623064_618480 3.8425
R11-952-127 n1_623064_618480 n1_625064_618480 0.357143
R11-953-100 n1_623064_618480 n1_625064_618480 0.333333
R11-953-101 n1_625064_618480 n1_627064_618480 0.357143
R11-954-100 n1_625064_618480 n1_627064_618480 0.333333
iB00_0_v n1_625064_28 0 9.99999999907325e-06
iB00_1_v n1_625064_0 0 -5.7315
iB00_2_v n1_625064_46000 0 -1.6977450000000005
iB00_3_v n1_625064_50000 0 2.100000000966834e-06
iB00_4_v n1_671036_46000 0 -4.467164999999922
iB00_5_v n1_601546_46000 0 -9.999999973486079e-06
iB00_6_v n1_625064_48000 0 0.0
iB00_7_v n1_671064_46000 0 -7.7443e-14
iB00_8_v n1_579050_46000 0 2.63678e-14
iB00_9_v n1_601546_44000 0 -2.63678e-14
iB00_10_v n1_601546_50000 0 8.5000000026275e-07
iB00_11_v n1_601546_53344 0 1.5499999999186954e-06
iB00_12_v n1_623064_50000 0 -1.0000000000021927e-07
iB00_13_v n1_579050_50000 0 -2.5000000002019934e-06
iB00_14_v n1_556858_50000 0 3.8000000001032e-06
iB00_15_v n1_579050_53344 0 2.8500000001451626e-06
iB00_16_v n1_579050_56688 0 4.999999999333337e-07
iB00_17_v n1_556858_53344 0 -8.999999999816446e-07
iB00_18_v n1_534666_53344 0 2.0000000001399107e-07
iB00_19_v n1_556858_56688 0 -1.0000000010525136e-07
iB00_20_v n1_556858_60032 0 -2.299999999815308e-06
iB00_21_v n1_534666_56688 0 -5.0000000017050295e-08
iB00_22_v n1_512170_56688 0 1.4999999999694077e-07
iB00_23_v n1_534666_60032 0 -1.9999999999027415e-07
iB00_24_v n1_534666_63376 0 1.999999999530047e-07
iB00_25_v n1_512170_60032 0 -3.9999999997377203e-07
iB00_26_v n1_489978_60032 0 5.0000000017050295e-08
iB00_27_v n1_512170_63376 0 4.9999999962840186e-08
iB00_28_v n1_512170_66720 0 5.0000000037379085e-08
iB00_29_v n1_489978_63376 0 -2.0000000001399107e-07
iB00_30_v n1_467482_63376 0 9.999999999005488e-08
iB00_31_v n1_489978_66720 0 2.000000000326258e-07
iB00_32_v n1_489978_67278 0 0.08436050000000007
iB00_33_v n1_467482_66720 0 -5.000000004415535e-08
iB00_34_v n1_445290_66720 0 1.0000000000699553e-07
iB00_35_v n1_467482_67278 0 0.08868249999999993
iB00_36_v n1_467482_70064 0 -3.499999999770505e-07
iB00_37_v n1_445290_67278 0 0.08356299999999998
iB00_38_v n1_422794_67278 0 0.08573350000000003
iB00_39_v n1_445290_70064 0 -3.5000000001093184e-07
iB00_40_v n1_445290_73408 0 1.5000000000371704e-07
iB00_41_v n1_422794_70064 0 1.0000000000699553e-07
iB00_42_v n1_400602_70064 0 -3.499999996856712e-08
iB00_43_v n1_422794_73408 0 -2.999999999947286e-07
iB00_44_v n1_422794_76752 0 1.9999999998180382e-07
iB00_45_v n1_400602_73408 0 -1.1499999997416355e-07
iB00_46_v n1_378410_73408 0 -1.1499999998941014e-07
iB00_47_v n1_400602_76752 0 2.0999999998758557e-07
iB00_48_v n1_400602_80096 0 -1.3000000000062387e-07
iB00_49_v n1_378410_76752 0 -2.999999998854613e-08
iB00_50_v n1_355914_76752 0 2.900000000067345e-07
iB00_51_v n1_378410_80096 0 -2.999999998854613e-08
iB00_52_v n1_378410_83440 0 -1.0499999997515806e-07
iB00_53_v n1_355914_80096 0 -1.7000000002544494e-07
iB00_54_v n1_333722_80096 0 -6.000000000419732e-08
iB00_55_v n1_355914_83440 0 2.5000000000785384e-07
iB00_56_v n1_355914_86784 0 6.500000000115897e-08
iB00_57_v n1_333722_83440 0 -1.6499999999121384e-07
iB00_58_v n1_311226_83440 0 3.349999999895537e-07
iB00_59_v n1_333722_86784 0 1.4499999998621484e-07
iB00_60_v n1_333722_89166 0 0.08179170000000002
iB00_61_v n1_311226_86784 0 -1.9999999974294053e-08
iB00_62_v n1_289034_86784 0 -5.500000000892974e-08
iB00_63_v n1_311226_89166 0 0.08150750000000001
iB00_64_v n1_311226_90128 0 1.0000000001546586e-08
iB00_65_v n1_289034_89166 0 0.08078250000000001
iB00_66_v n1_266538_89166 0 0.08169099999999997
iB00_67_v n1_289034_90128 0 2.2500000000557556e-07
iB00_68_v n1_289034_93472 0 -1.2000000000288893e-07
iB00_69_v n1_266538_90128 0 -1.5999999995698275e-07
iB00_70_v n1_244346_90128 0 1.4999999999694077e-07
iB00_71_v n1_266538_93472 0 -5.0000000025520624e-08
iB00_72_v n1_266538_96816 0 -5.500000000808271e-08
iB00_73_v n1_244346_93472 0 -2.9999999999388155e-07
iB00_74_v n1_221850_93472 0 2.9999999999388155e-07
iB00_75_v n1_244346_96816 0 1.499999999901645e-07
iB00_76_v n1_244346_100160 0 5.000000000773293e-08
iB00_77_v n1_221850_96816 0 -3.9999999997377203e-07
iB00_78_v n1_199658_96816 0 3.499999999973793e-07
iB00_79_v n1_221850_100160 0 3.500000000075437e-07
iB00_80_v n1_221850_103504 0 -2.999999999769409e-07
iB00_81_v n1_199658_100160 0 -1.0000000003410059e-07
iB00_82_v n1_177466_100160 0 -2.0000000006820118e-07
iB00_83_v n1_199658_103504 0 -2.999999999769409e-07
iB00_84_v n1_199658_106848 0 3.4999999996519207e-07
iB00_85_v n1_177466_103504 0 -4.999999990863008e-08
iB00_86_v n1_154970_103504 0 1.0999999999414256e-06
iB00_87_v n1_177466_106848 0 -5.0000000028908756e-08
iB00_88_v n1_177466_110192 0 2.0000000003940206e-07
iB00_89_v n1_154970_106848 0 -1.95000000001444e-06
iB00_90_v n1_132778_106848 0 -3.649999999943629e-06
iB00_91_v n1_154970_110192 0 3.000000000497857e-07
iB00_92_v n1_154970_111662 0 0.06440500000000002
iB00_93_v n1_132778_110192 0 2.0000000006820118e-07
iB00_94_v n1_110282_110192 0 2.2500000002116096e-06
iB00_95_v n1_132778_111662 0 0.06440000000000004
iB00_96_v n1_132778_113536 0 1.349999999970773e-06
iB00_97_v n1_110282_111662 0 0.06439999999999983
iB00_98_v n1_88090_111662 0 0.0644049999999998
iB00_99_v n1_110282_113536 0 -2.999999999871053e-07
iB00_100_v n1_110282_116880 0 6.500000000912108e-07
iB00_101_v n1_88090_113536 0 6.500000002216538e-07
iB00_102_v n1_65594_113536 0 -6.500000000048134e-07
iB00_103_v n1_88090_116880 0 7.000000001218136e-07
iB00_104_v n1_88090_120224 0 1.8499999999837277e-06
iB00_105_v n1_65594_116880 0 4.600000000050744e-06
iB00_106_v n1_48000_116880 0 -5.000000000349777e-09
iB00_107_v n1_65594_120224 0 -9.499999998750281e-07
iB00_108_v n1_65594_123568 0 -2.7500000000704045e-06
iB00_109_v n1_48000_120224 0 2.5000000000054818e-08
iB00_110_v n1_46000_120224 0 2.774999999753669e-06
iB00_111_v n1_44000_120224 0 0.0
iB00_112_v n1_46000_116880 0 1.405000000067794e-06
iB00_113_v n1_46000_123568 0 5.549999997821742e-07
iB00_114_v n1_46000_126912 0 -4.309999999691644e-06
iB00_115_v n1_48000_123568 0 -5.000000000349777e-09
iB00_116_v n1_44000_123568 0 0.0
iB00_117_v n1_88090_123568 0 -1.3000000002264672e-06
iB00_118_v n1_65594_126912 0 3.599999999935049e-06
iB00_119_v n1_65594_130256 0 -2.3000000001337922e-06
iB00_120_v n1_88090_126912 0 1.100000000027823e-06
iB00_121_v n1_48000_126912 0 9.99999999985252e-09
iB00_122_v n1_44000_126912 0 0.0
iB00_123_v n1_46000_130256 0 4.10499999960107e-06
iB00_124_v n1_46000_133550 0 2.667137344314341e-14
iB00_125_v n1_48000_130256 0 -5.000000000349777e-09
iB00_126_v n1_44000_130256 0 0.0
iB00_127_v n1_88090_130256 0 -1.2499999999925765e-06
iB00_128_v n1_65594_133550 0 0.07387000000000019
iB00_129_v n1_65594_133600 0 -1.7999999999632893e-06
iB00_130_v n1_88090_133550 0 0.06440500000000013
iB00_131_v n1_44000_133550 0 -2.63678e-14
iB00_132_v n1_46000_133600 0 -1.0500000001306278e-06
iB00_133_v n1_46000_136944 0 -3.2950000000610963e-06
iB00_134_v n1_48000_133600 0 8.470329472543003e-19
iB00_135_v n1_44000_133600 0 0.0
iB00_136_v n1_88090_133600 0 -2.700000000053354e-06
iB00_137_v n1_65594_136944 0 1.7000000000825017e-06
iB00_138_v n1_65594_140288 0 1.8999999999973899e-06
iB00_139_v n1_88090_136944 0 1.450000000297947e-06
iB00_140_v n1_48000_136944 0 -4.999999999502744e-09
iB00_141_v n1_44000_136944 0 0.0
iB00_142_v n1_46000_140288 0 -1.1499999976875806e-07
iB00_143_v n1_46000_143632 0 3.964999999985994e-06
iB00_144_v n1_48000_140288 0 1.5000000000202297e-08
iB00_145_v n1_44000_140288 0 0.0
iB00_146_v n1_88090_140288 0 3.0000000010230177e-07
iB00_147_v n1_65594_143632 0 -1.2499999999714007e-06
iB00_148_v n1_65594_146976 0 1.8499999997634992e-06
iB00_149_v n1_88090_143632 0 -1.400000000060668e-06
iB00_150_v n1_48000_143632 0 -1.499999999977878e-08
iB00_151_v n1_44000_143632 0 0.0
iB00_152_v n1_46000_146976 0 -6.349999998326634e-07
iB00_153_v n1_46000_150320 0 1.4699999999808616e-06
iB00_154_v n1_48000_146976 0 -1.5000000000202297e-08
iB00_155_v n1_44000_146976 0 0.0
iB00_156_v n1_88090_146976 0 1.500000000077828e-06
iB00_157_v n1_65594_150320 0 -3.849999999877152e-06
iB00_158_v n1_65594_153664 0 1.5999999998950881e-06
iB00_159_v n1_88090_150320 0 -1.1999999998484713e-06
iB00_160_v n1_48000_150320 0 -2.0000000000128558e-08
iB00_161_v n1_44000_150320 0 0.0
iB00_162_v n1_46000_153664 0 -4.385000000074244e-06
iB00_163_v n1_46000_156046 0 -4.999999734991295e-07
iB00_164_v n1_48000_153664 0 -1.5000000000202297e-08
iB00_165_v n1_44000_153664 0 0.0
iB00_166_v n1_88090_153664 0 3.999999999195619e-07
iB00_167_v n1_65594_156046 0 0.07376800000000004
iB00_168_v n1_65594_157008 0 3.5000000000008982e-06
iB00_169_v n1_88090_156046 0 0.0644014999999998
iB00_170_v n1_44000_156046 0 -2.63678e-14
iB00_171_v n1_46000_157008 0 1.5749999998929157e-06
iB00_172_v n1_46000_160352 0 -6.799999996680989e-07
iB00_173_v n1_48000_157008 0 -2.5000000001748884e-08
iB00_174_v n1_44000_157008 0 0.0
iB00_175_v n1_88090_157008 0 1.300000000118047e-06
iB00_176_v n1_65594_160352 0 -2.250000000016792e-06
iB00_177_v n1_65594_163696 0 -2.0499999999401206e-06
iB00_178_v n1_88090_160352 0 -1.1499999999974394e-06
iB00_179_v n1_48000_160352 0 -2.000000000097559e-08
iB00_180_v n1_44000_160352 0 0.0
iB00_181_v n1_46000_163696 0 -4.5000000176789745e-08
iB00_182_v n1_46000_167040 0 3.699999999960679e-06
iB00_183_v n1_48000_163696 0 -4.999999999502744e-09
iB00_184_v n1_44000_163696 0 0.0
iB00_185_v n1_88090_163696 0 4.999999999536625e-07
iB00_186_v n1_65594_167040 0 3.855000000007098e-06
iB00_187_v n1_65594_170384 0 5.049999999336835e-07
iB00_188_v n1_88090_167040 0 1.3499999999267272e-06
iB00_189_v n1_48000_167040 0 -5.000000000349777e-09
iB00_190_v n1_44000_167040 0 0.0
iB00_191_v n1_46000_170384 0 -4.254999999960964e-06
iB00_192_v n1_46000_173728 0 1.2549999999725975e-06
iB00_193_v n1_48000_170384 0 0.0
iB00_194_v n1_44000_170384 0 0.0
iB00_195_v n1_88090_170384 0 -3.699999999960679e-06
iB00_196_v n1_65594_173728 0 -2.2100000000876857e-06
iB00_197_v n1_65594_177072 0 8.400000000045524e-07
iB00_198_v n1_88090_173728 0 4.4999999991204826e-07
iB00_199_v n1_48000_173728 0 5.000000000349777e-09
iB00_200_v n1_44000_173728 0 0.0
iB00_201_v n1_46000_177072 0 3.600000000476303e-07
iB00_202_v n1_46000_177934 0 1.500000026532361e-06
iB00_203_v n1_48000_177072 0 0.0
iB00_204_v n1_44000_177072 0 0.0
iB00_205_v n1_88090_177072 0 -1.4499999999523575e-06
iB00_206_v n1_65594_177934 0 0.07497249999999984
iB00_207_v n1_65594_180416 0 2.7350000001303415e-06
iB00_208_v n1_88090_177934 0 0.06440250000000003
iB00_209_v n1_44000_177934 0 -2.63678e-14
iB00_210_v n1_46000_180416 0 5.700000000114989e-07
iB00_211_v n1_46000_183760 0 -1.490000000117786e-06
iB00_212_v n1_48000_180416 0 -4.999999999502744e-09
iB00_213_v n1_44000_180416 0 0.0
iB00_214_v n1_88090_180416 0 -7.50000000038914e-07
iB00_215_v n1_65594_183760 0 -1.0149999999829133e-06
iB00_216_v n1_65594_187104 0 8.299999999360902e-07
iB00_217_v n1_88090_183760 0 1.9999999995723986e-07
iB00_218_v n1_48000_183760 0 4.999999999079227e-09
iB00_219_v n1_44000_183760 0 0.0
iB00_220_v n1_46000_187104 0 4.6499999997831913e-07
iB00_221_v n1_46000_190448 0 1.5700000000149622e-06
iB00_222_v n1_48000_187104 0 4.999999999502744e-09
iB00_223_v n1_44000_187104 0 0.0
iB00_224_v n1_88090_187104 0 2.5000000008525147e-07
iB00_225_v n1_65594_190448 0 -1.8699999999808917e-06
iB00_226_v n1_65594_193792 0 8.850000000415817e-07
iB00_227_v n1_88090_190448 0 -6.500000000632587e-07
iB00_228_v n1_48000_190448 0 -4.2351647362715017e-19
iB00_229_v n1_44000_190448 0 0.0
iB00_230_v n1_46000_193792 0 -3.08499999995662e-06
iB00_231_v n1_46000_197136 0 1.5750000002118236e-06
iB00_232_v n1_48000_193792 0 0.0
iB00_233_v n1_44000_193792 0 0.0
iB00_234_v n1_88090_193792 0 2.5500000001106235e-06
iB00_235_v n1_65594_197136 0 -9.350000000768432e-07
iB00_236_v n1_65594_200430 0 0.07423199999999992
iB00_237_v n1_88090_197136 0 -1.400000000521454e-07
iB00_238_v n1_48000_197136 0 2.1175823681357508e-19
iB00_239_v n1_44000_197136 0 0.0
iB00_240_v n1_46000_200430 0 -1.9999999473230955e-06
iB00_241_v n1_46000_200480 0 5.549999999507338e-07
iB00_242_v n1_44000_200430 0 -5.27355e-14
iB00_243_v n1_88090_200430 0 0.06439949999999998
iB00_244_v n1_65594_200480 0 1.9550000000143664e-06
iB00_245_v n1_65594_203824 0 -1.2299999999640723e-06
iB00_246_v n1_88090_200480 0 1.1900000000425893e-06
iB00_247_v n1_48000_200480 0 0.0
iB00_248_v n1_44000_200480 0 0.0
iB00_249_v n1_46000_203824 0 1.3049999999223087e-06
iB00_250_v n1_46000_207168 0 1.5650000000349412e-06
iB00_251_v n1_48000_203824 0 4.99999999992626e-09
iB00_252_v n1_44000_203824 0 0.0
iB00_253_v n1_88090_203824 0 1.320000000038131e-06
iB00_254_v n1_65594_207168 0 1.0449999999363075e-06
iB00_255_v n1_65594_210512 0 -1.3249999999097317e-06
iB00_256_v n1_88090_207168 0 5.399999999166502e-07
iB00_257_v n1_48000_207168 0 2.1175823681357508e-19
iB00_258_v n1_44000_207168 0 0.0
iB00_259_v n1_46000_210512 0 -3.5700000000439116e-06
iB00_260_v n1_46000_213856 0 9.800000000956613e-07
iB00_261_v n1_48000_210512 0 0.0
iB00_262_v n1_44000_210512 0 0.0
iB00_263_v n1_88090_210512 0 -1.1549999999384969e-06
iB00_264_v n1_65594_213856 0 1.6199999999778024e-06
iB00_265_v n1_65594_217200 0 -1.3500000011108793e-07
iB00_266_v n1_88090_213856 0 1.2999999999732044e-06
iB00_267_v n1_48000_213856 0 -2.1175823681357508e-19
iB00_268_v n1_44000_213856 0 0.0
iB00_269_v n1_46000_217200 0 2.600000000287763e-07
iB00_270_v n1_46000_220544 0 -7.150000001787671e-07
iB00_271_v n1_48000_217200 0 0.0
iB00_272_v n1_44000_217200 0 0.0
iB00_273_v n1_88090_217200 0 -2.105000000045612e-06
iB00_274_v n1_65594_220544 0 -1.5350000000489362e-06
iB00_275_v n1_65594_222318 0 0.07478900000000013
iB00_276_v n1_88090_220544 0 -1.374999999874266e-06
iB00_277_v n1_48000_220544 0 0.0
iB00_278_v n1_44000_220544 0 0.0
iB00_279_v n1_46000_222318 0 5.27355e-14
iB00_280_v n1_46000_223888 0 2.5900000000592116e-06
iB00_281_v n1_44000_222318 0 -5.27355e-14
iB00_282_v n1_88090_222318 0 0.064404
iB00_283_v n1_65594_223888 0 1.0000000000403092e-07
iB00_284_v n1_65594_227232 0 -2.1500000000826414e-07
iB00_285_v n1_88090_223888 0 -1.0500000002428597e-07
iB00_286_v n1_48000_223888 0 5.000000000349777e-09
iB00_287_v n1_44000_223888 0 0.0
iB00_288_v n1_46000_227232 0 8.299999999644658e-07
iB00_289_v n1_46000_230576 0 -1.0649999998644383e-06
iB00_290_v n1_48000_227232 0 -5.000000000349777e-09
iB00_291_v n1_44000_227232 0 0.0
iB00_292_v n1_88090_227232 0 2.1500000000826414e-07
iB00_293_v n1_65594_230576 0 2.7500000002559047e-07
iB00_294_v n1_65594_233920 0 -9.999999960041972e-09
iB00_295_v n1_88090_230576 0 1.849999999400969e-07
iB00_296_v n1_48000_230576 0 -4.99999999992626e-09
iB00_297_v n1_44000_230576 0 0.0
iB00_298_v n1_46000_233920 0 -3.0150000000031805e-06
iB00_299_v n1_46000_237264 0 3.9999999948588105e-08
iB00_300_v n1_48000_233920 0 5.000000000349777e-09
iB00_301_v n1_44000_233920 0 0.0
iB00_302_v n1_88090_233920 0 -1.5499999992275165e-07
iB00_303_v n1_65594_237264 0 -1.0500000002047432e-07
iB00_304_v n1_65594_240608 0 0.0
iB00_305_v n1_88090_237264 0 -2.8500000003264277e-07
iB00_306_v n1_48000_237264 0 5.0000000001380185e-09
iB00_307_v n1_44000_237264 0 0.0
iB00_308_v n1_46000_240608 0 3.115000000067986e-06
iB00_309_v n1_46000_243952 0 -3.815000000151683e-06
iB00_310_v n1_48000_240608 0 4.2351647362715017e-19
iB00_311_v n1_44000_240608 0 0.0
iB00_312_v n1_88090_240608 0 3.0000000004809166e-07
iB00_313_v n1_65594_243952 0 -1.4000000000937023e-07
iB00_314_v n1_65594_244814 0 0.0740475
iB00_315_v n1_88090_243952 0 7.500000001032885e-08
iB00_316_v n1_48000_243952 0 0.0
iB00_317_v n1_44000_243952 0 0.0
iB00_318_v n1_46000_244814 0 3.5000000527906084e-06
iB00_319_v n1_46000_247296 0 -2.999999998854613e-08
iB00_320_v n1_44000_244814 0 -5.27355e-14
iB00_321_v n1_88090_244814 0 0.06440100000000001
iB00_322_v n1_65594_247296 0 -1.5000000036624714e-08
iB00_323_v n1_65594_250640 0 -6.999999988292413e-08
iB00_324_v n1_88090_247296 0 -2.699999999926299e-07
iB00_325_v n1_48000_247296 0 5.0000000001380185e-09
iB00_326_v n1_44000_247296 0 0.0
iB00_327_v n1_46000_250640 0 -2.4850000000273023e-06
iB00_328_v n1_46000_253984 0 1.5500000003117187e-07
iB00_329_v n1_48000_250640 0 0.0
iB00_330_v n1_44000_250640 0 0.0
iB00_331_v n1_88090_250640 0 -2.000000002850416e-08
iB00_332_v n1_65594_253984 0 7.000000000404984e-08
iB00_333_v n1_65594_257328 0 3.5499999999095283e-07
iB00_334_v n1_88090_253984 0 4.649999999414732e-07
iB00_335_v n1_48000_253984 0 -5.000000000349777e-09
iB00_336_v n1_44000_253984 0 0.0
iB00_337_v n1_46000_257328 0 2.9249999999250985e-06
iB00_338_v n1_46000_260672 0 -4.155000000094153e-06
iB00_339_v n1_48000_257328 0 0.0
iB00_340_v n1_44000_257328 0 0.0
iB00_341_v n1_88090_257328 0 -3.0499999997390254e-07
iB00_342_v n1_65594_260672 0 -2.0500000001645843e-07
iB00_343_v n1_65594_264016 0 -8.499999998561741e-08
iB00_344_v n1_88090_260672 0 1.849999999888013e-07
iB00_345_v n1_48000_260672 0 4.2351647362715017e-19
iB00_346_v n1_44000_260672 0 0.0
iB00_347_v n1_46000_264016 0 3.90500000011351e-06
iB00_348_v n1_46000_266702 0 -1.499999947222972e-06
iB00_349_v n1_48000_264016 0 0.0
iB00_350_v n1_44000_264016 0 0.0
iB00_351_v n1_88090_264016 0 -7.500000002557544e-08
iB00_352_v n1_65594_266702 0 0.0743455
iB00_353_v n1_65594_267360 0 -1.2000000006260475e-07
iB00_354_v n1_88090_266702 0 0.06440149999999999
iB00_355_v n1_44000_266702 0 -5.27355e-14
iB00_356_v n1_46000_267360 0 -7.50000000166816e-08
iB00_357_v n1_46000_270704 0 -2.4499999999681027e-07
iB00_358_v n1_48000_267360 0 4.99999999992626e-09
iB00_359_v n1_44000_267360 0 0.0
iB00_360_v n1_88090_267360 0 6.000000008551248e-08
iB00_361_v n1_65594_270704 0 3.5999999997732656e-07
iB00_362_v n1_65594_274048 0 -4.249999999822972e-07
iB00_363_v n1_88090_270704 0 9.499999996725873e-08
iB00_364_v n1_48000_270704 0 -2.1175823681357508e-19
iB00_365_v n1_44000_270704 0 0.0
iB00_366_v n1_46000_274048 0 2.1500000003092227e-07
iB00_367_v n1_46000_277392 0 -1.6000000001119286e-07
iB00_368_v n1_48000_274048 0 -5.000000000349777e-09
iB00_369_v n1_44000_274048 0 0.0
iB00_370_v n1_88090_274048 0 -1.3000000002264672e-07
iB00_371_v n1_65594_277392 0 -3.499999998169613e-08
iB00_372_v n1_65594_280736 0 1.9999999974294053e-08
iB00_373_v n1_88090_277392 0 -7.499999997771808e-08
iB00_374_v n1_48000_277392 0 2.1175823681357508e-19
iB00_375_v n1_44000_277392 0 0.0
iB00_376_v n1_46000_280736 0 1.5499999999813758e-07
iB00_377_v n1_46000_284080 0 1.399999999826887e-07
iB00_378_v n1_48000_280736 0 0.0
iB00_379_v n1_44000_280736 0 0.0
iB00_380_v n1_88090_280736 0 2.700000000595455e-07
iB00_381_v n1_65594_284080 0 2.600000000164943e-07
iB00_382_v n1_65594_287424 0 -2.400000000709994e-07
iB00_383_v n1_88090_284080 0 -1.0000000006247619e-07
iB00_384_v n1_48000_284080 0 2.1175823681357508e-19
iB00_385_v n1_44000_284080 0 0.0
iB00_386_v n1_46000_287424 0 -2.449999999521293e-07
iB00_387_v n1_46000_288590 0 5.274643569141979e-14
iB00_388_v n1_48000_287424 0 -4.2351647362715017e-19
iB00_389_v n1_44000_287424 0 0.0
iB00_390_v n1_88090_287424 0 -1.9999999995978096e-07
iB00_391_v n1_65594_288590 0 0.07532600000000005
iB00_392_v n1_65594_290768 0 4.999999980020986e-09
iB00_393_v n1_88090_288590 0 0.06440149999999999
iB00_394_v n1_44000_288590 0 -5.27355e-14
iB00_395_v n1_46000_290768 0 -2.3500000001305137e-07
iB00_396_v n1_46000_294112 0 -9.500000002697455e-08
iB00_397_v n1_48000_290768 0 0.0
iB00_398_v n1_44000_290768 0 0.0
iB00_399_v n1_88090_290768 0 1.150000000012686e-07
iB00_400_v n1_65594_294112 0 1.0999999998906036e-07
iB00_401_v n1_65594_297456 0 -1.4999999967168012e-08
iB00_402_v n1_88090_294112 0 1.2500000000493277e-07
iB00_403_v n1_48000_294112 0 4.999999999714502e-09
iB00_404_v n1_44000_294112 0 0.0
iB00_405_v n1_46000_297456 0 1.6000000001987494e-07
iB00_406_v n1_46000_300800 0 3.000000001565119e-08
iB00_407_v n1_48000_297456 0 0.0
iB00_408_v n1_44000_297456 0 0.0
iB00_409_v n1_88090_297456 0 -4.5000000009924254e-08
iB00_410_v n1_65594_300800 0 -4.1000000000200015e-07
iB00_411_v n1_65594_304144 0 4.3499999999654926e-07
iB00_412_v n1_88090_300800 0 1.4000000000894672e-07
iB00_413_v n1_48000_300800 0 -2.1175823681357508e-19
iB00_414_v n1_44000_300800 0 0.0
iB00_415_v n1_46000_304144 0 4.9999999723976895e-09
iB00_416_v n1_46000_307488 0 3.000000001565119e-08
iB00_417_v n1_48000_304144 0 -4.99999999992626e-09
iB00_418_v n1_44000_304144 0 0.0
iB00_419_v n1_88090_304144 0 -2.900000000338396e-07
iB00_420_v n1_65594_307488 0 -4.3499999999062003e-07
iB00_421_v n1_65594_310832 0 8.499999998561741e-08
iB00_422_v n1_88090_307488 0 1.7500000002452416e-07
iB00_423_v n1_48000_307488 0 -5.0000000001380185e-09
iB00_424_v n1_44000_307488 0 0.0
iB00_425_v n1_46000_310832 0 2.999999999638119e-08
iB00_426_v n1_46000_311086 0 5.271933063710765e-14
iB00_427_v n1_48000_310832 0 0.0
iB00_428_v n1_44000_310832 0 0.0
iB00_429_v n1_88090_310832 0 2.000000002850416e-08
iB00_430_v n1_65594_311086 0 0.0813365
iB00_431_v n1_65594_314176 0 1.549999999905143e-07
iB00_432_v n1_88090_311086 0 0.07493549999999999
iB00_433_v n1_44000_311086 0 -5.27355e-14
iB00_434_v n1_46000_314176 0 2.4000000000133093e-07
iB00_435_v n1_46000_317520 0 -4.649999999986479e-07
iB00_436_v n1_48000_314176 0 -4.99999999992626e-09
iB00_437_v n1_44000_314176 0 0.0
iB00_438_v n1_88090_314176 0 5.00000000712604e-09
iB00_439_v n1_65594_317520 0 -4.599999999915219e-07
iB00_440_v n1_65594_320864 0 2.849999999996085e-07
iB00_441_v n1_88090_317520 0 3.000000000031989e-07
iB00_442_v n1_48000_317520 0 -5.000000000349777e-09
iB00_443_v n1_44000_317520 0 0.0
iB00_444_v n1_46000_320864 0 2.9000000000101705e-07
iB00_445_v n1_46000_324208 0 2.499999999497262e-08
iB00_446_v n1_48000_320864 0 0.0
iB00_447_v n1_44000_320864 0 0.0
iB00_448_v n1_88090_320864 0 -4.599999999915219e-07
iB00_449_v n1_65594_324208 0 -1.4000000000555858e-07
iB00_450_v n1_65594_327552 0 2.89999999993182e-07
iB00_451_v n1_88090_324208 0 2.550000000144505e-07
iB00_452_v n1_48000_324208 0 -5.000000000349777e-09
iB00_453_v n1_44000_324208 0 0.0
iB00_454_v n1_46000_327552 0 -2.9499999999056716e-07
iB00_455_v n1_46000_330896 0 2.7999999999248244e-07
iB00_456_v n1_48000_327552 0 -5.000000000349777e-09
iB00_457_v n1_44000_327552 0 0.0
iB00_458_v n1_88090_327552 0 -4.500000002347678e-08
iB00_459_v n1_65594_330896 0 -3.749999999868462e-07
iB00_460_v n1_65594_332974 0 0.08484325000000001
iB00_461_v n1_88090_330896 0 1.3999999999878232e-07
iB00_462_v n1_48000_330896 0 -2.1175823681357508e-19
iB00_463_v n1_44000_330896 0 0.0
iB00_464_v n1_46000_332974 0 -1.9999994725138602e-07
iB00_465_v n1_46000_334240 0 2.0999999999436183e-07
iB00_466_v n1_44000_332974 0 -5.27355e-14
iB00_467_v n1_88090_332974 0 0.08178329999999998
iB00_468_v n1_65594_334240 0 -9.999999999429004e-09
iB00_469_v n1_65594_337584 0 -1.500000000104933e-08
iB00_470_v n1_88090_334240 0 -1.999999999504636e-08
iB00_471_v n1_48000_334240 0 -2.1175823681357508e-19
iB00_472_v n1_44000_334240 0 0.0
iB00_473_v n1_46000_337584 0 -4.150000000015029e-07
iB00_474_v n1_46000_340928 0 2.0000000001399107e-08
iB00_475_v n1_48000_337584 0 4.99999999992626e-09
iB00_476_v n1_44000_337584 0 0.0
iB00_477_v n1_88090_337584 0 6.776263578034403e-18
iB00_478_v n1_65594_340928 0 9.999999997311422e-09
iB00_479_v n1_65594_344272 0 5.000000000349777e-09
iB00_480_v n1_88090_340928 0 1.49999999951201e-08
iB00_481_v n1_48000_340928 0 -2.1175823681357508e-19
iB00_482_v n1_44000_340928 0 0.0
iB00_483_v n1_46000_344272 0 3.5000000000119097e-07
iB00_484_v n1_46000_347616 0 7.499999999847039e-08
iB00_485_v n1_48000_344272 0 -4.99999999992626e-09
iB00_486_v n1_44000_344272 0 0.0
iB00_487_v n1_88090_344272 0 -1.4999999987496803e-08
iB00_488_v n1_65594_347616 0 -3.0000000000404595e-08
iB00_489_v n1_65594_350960 0 9.99999999392329e-09
iB00_490_v n1_88090_347616 0 2.999999999489888e-08
iB00_491_v n1_48000_347616 0 0.0
iB00_492_v n1_44000_347616 0 0.0
iB00_493_v n1_46000_350960 0 -3.1500000000170714e-07
iB00_494_v n1_46000_354304 0 1.2500000001552068e-07
iB00_495_v n1_48000_350960 0 -4.2351647362715017e-19
iB00_496_v n1_44000_350960 0 0.0
iB00_497_v n1_88090_350960 0 -4.0000000002798214e-08
iB00_498_v n1_65594_354304 0 1.0000000005358235e-08
iB00_499_v n1_65594_355470 0 0.08624084999999998
iB00_500_v n1_88090_354304 0 1.500000000570801e-08
iB00_501_v n1_48000_354304 0 0.0
iB00_502_v n1_44000_354304 0 0.0
iB00_503_v n1_46000_355470 0 5.27355e-14
iB00_504_v n1_46000_357648 0 -3.3999999999667976e-07
iB00_505_v n1_44000_355470 0 -5.27355e-14
iB00_506_v n1_88090_355470 0 0.0791486
iB00_507_v n1_65594_357648 0 6.500000002360534e-08
iB00_508_v n1_65594_360992 0 1.4499999996270968e-07
iB00_509_v n1_88090_357648 0 1.1499999996865783e-07
iB00_510_v n1_48000_357648 0 4.99999999992626e-09
iB00_511_v n1_44000_357648 0 0.0
iB00_512_v n1_46000_360992 0 2.650000000138795e-07
iB00_513_v n1_46000_364336 0 -2.3999999998968423e-07
iB00_514_v n1_48000_360992 0 -4.2351647362715017e-19
iB00_515_v n1_44000_360992 0 0.0
iB00_516_v n1_88090_360992 0 -1.9000000002684404e-07
iB00_517_v n1_65594_364336 0 2.3000000002201896e-07
iB00_518_v n1_65594_367680 0 -2.7000000003244047e-07
iB00_519_v n1_88090_364336 0 3.0999999999542814e-07
iB00_520_v n1_48000_364336 0 2.1175823681357508e-19
iB00_521_v n1_44000_364336 0 0.0
iB00_522_v n1_46000_367680 0 2.1999999998468523e-07
iB00_523_v n1_46000_371024 0 -3.1999999999528066e-07
iB00_524_v n1_48000_367680 0 0.0
iB00_525_v n1_44000_367680 0 0.0
iB00_526_v n1_88090_367680 0 1.2500000004262574e-07
iB00_527_v n1_65594_371024 0 1.0000000002690081e-07
iB00_528_v n1_65594_374368 0 -1.7000000002544494e-07
iB00_529_v n1_88090_371024 0 -2.3500000001262786e-07
iB00_530_v n1_48000_371024 0 -2.1175823681357508e-19
iB00_531_v n1_44000_371024 0 0.0
iB00_532_v n1_46000_374368 0 1.599999999997579e-07
iB00_533_v n1_46000_377358 0 5.274643569141979e-14
iB00_534_v n1_48000_374368 0 0.0
iB00_535_v n1_44000_374368 0 0.0
iB00_536_v n1_88090_374368 0 2.1499999998115908e-07
iB00_537_v n1_65594_377358 0 0.0762615
iB00_538_v n1_65594_377712 0 -4.3500000005075937e-07
iB00_539_v n1_88090_377358 0 0.0665345
iB00_540_v n1_44000_377358 0 -5.27355e-14
iB00_541_v n1_46000_377712 0 -7.000000002797852e-08
iB00_542_v n1_46000_381056 0 -2.0499999999401206e-07
iB00_543_v n1_48000_377712 0 -5.000000000349777e-09
iB00_544_v n1_44000_377712 0 0.0
iB00_545_v n1_88090_377712 0 2.999999996144108e-08
iB00_546_v n1_65594_381056 0 3.00000000018022e-07
iB00_547_v n1_65594_384400 0 -1.0999999993993245e-07
iB00_548_v n1_88090_381056 0 -2.049999999872358e-07
iB00_549_v n1_48000_381056 0 -2.1175823681357508e-19
iB00_550_v n1_44000_381056 0 0.0
iB00_551_v n1_46000_384400 0 2.050000000130703e-07
iB00_552_v n1_46000_387744 0 -2.849999999996085e-07
iB00_553_v n1_48000_384400 0 0.0
iB00_554_v n1_44000_384400 0 0.0
iB00_555_v n1_88090_384400 0 3.399999999695747e-07
iB00_556_v n1_65594_387744 0 2.49999999957773e-07
iB00_557_v n1_65594_391088 0 -1.4499999996270968e-07
iB00_558_v n1_88090_387744 0 -3.2999999996336944e-07
iB00_559_v n1_48000_387744 0 4.2351647362715017e-19
iB00_560_v n1_44000_387744 0 0.0
iB00_561_v n1_46000_391088 0 3.450000000357813e-07
iB00_562_v n1_46000_394432 0 -4.150000000222552e-07
iB00_563_v n1_48000_391088 0 0.0
iB00_564_v n1_44000_391088 0 0.0
iB00_565_v n1_88090_391088 0 2.849999999453984e-07
iB00_566_v n1_65594_394432 0 -2.800000000073055e-07
iB00_567_v n1_65594_397776 0 3.9000000001373006e-07
iB00_568_v n1_88090_394432 0 -3.3499999995440186e-07
iB00_569_v n1_48000_394432 0 4.2351647362715017e-19
iB00_570_v n1_44000_394432 0 0.0
iB00_571_v n1_46000_397776 0 4.0499999998661554e-07
iB00_572_v n1_46000_399854 0 5.274643569141979e-14
iB00_573_v n1_48000_397776 0 4.99999999992626e-09
iB00_574_v n1_44000_397776 0 0.0
iB00_575_v n1_88090_397776 0 2.7999999999248244e-07
iB00_576_v n1_65594_399854 0 0.07614350000000002
iB00_577_v n1_65594_401120 0 -9.999999960041972e-09
iB00_578_v n1_88090_399854 0 0.06440199999999989
iB00_579_v n1_44000_399854 0 -5.27355e-14
iB00_580_v n1_46000_401120 0 -2.7500000001500256e-07
iB00_581_v n1_46000_404464 0 4.949999999736415e-07
iB00_582_v n1_48000_401120 0 0.0
iB00_583_v n1_44000_401120 0 0.0
iB00_584_v n1_88090_401120 0 -3.650000000052049e-07
iB00_585_v n1_65594_404464 0 -3.000000000336921e-08
iB00_586_v n1_65594_407808 0 2.849999999996085e-07
iB00_587_v n1_88090_404464 0 4.0500000001647345e-07
iB00_588_v n1_48000_404464 0 -4.99999999992626e-09
iB00_589_v n1_44000_404464 0 0.0
iB00_590_v n1_46000_407808 0 -1.8999999995781086e-07
iB00_591_v n1_46000_411152 0 -2.849999999996085e-07
iB00_592_v n1_48000_407808 0 -4.2351647362715017e-19
iB00_593_v n1_44000_407808 0 0.0
iB00_594_v n1_88090_407808 0 -1.399999999826887e-07
iB00_595_v n1_65594_411152 0 -1.3500000002934925e-07
iB00_596_v n1_65594_414496 0 -3.0499999997390254e-07
iB00_597_v n1_88090_411152 0 3.5000000065128875e-08
iB00_598_v n1_48000_411152 0 2.1175823681357508e-19
iB00_599_v n1_44000_411152 0 0.0
iB00_600_v n1_46000_414496 0 2.0000000003453162e-07
iB00_601_v n1_46000_417840 0 2.6000000004529344e-07
iB00_602_v n1_48000_414496 0 5.000000000349777e-09
iB00_603_v n1_44000_414496 0 0.0
iB00_604_v n1_88090_414496 0 -7.500000002557544e-08
iB00_605_v n1_65594_417840 0 2.8500000000172607e-07
iB00_606_v n1_65594_421184 0 -2.799999999653774e-07
iB00_607_v n1_88090_417840 0 2.5000000013607345e-08
iB00_608_v n1_48000_417840 0 2.1175823681357508e-19
iB00_609_v n1_44000_417840 0 0.0
iB00_610_v n1_46000_421184 0 -1.799999999992512e-07
iB00_611_v n1_46000_421742 0 1.5000000525532131e-06
iB00_612_v n1_48000_421184 0 -4.99999999992626e-09
iB00_613_v n1_44000_421184 0 0.0
iB00_614_v n1_88090_421184 0 -2.0000000006820118e-07
iB00_615_v n1_65594_421742 0 0.07481149999999996
iB00_616_v n1_65594_424528 0 2.000000002850416e-08
iB00_617_v n1_88090_421742 0 0.06440149999999999
iB00_618_v n1_44000_421742 0 -5.27355e-14
iB00_619_v n1_46000_424528 0 -1.154999999881534e-06
iB00_620_v n1_46000_427872 0 2.350000000367683e-07
iB00_621_v n1_48000_424528 0 0.0
iB00_622_v n1_44000_424528 0 0.0
iB00_623_v n1_88090_424528 0 9.999999960041972e-09
iB00_624_v n1_65594_427872 0 -3.299999999853923e-07
iB00_625_v n1_65594_431216 0 1.1500000002837366e-07
iB00_626_v n1_88090_427872 0 3.3000000004595515e-07
iB00_627_v n1_48000_427872 0 0.0
iB00_628_v n1_44000_427872 0 0.0
iB00_629_v n1_46000_431216 0 1.6049999999388483e-06
iB00_630_v n1_46000_434560 0 -2.0549999999201415e-06
iB00_631_v n1_48000_431216 0 4.2351647362715017e-19
iB00_632_v n1_44000_431216 0 0.0
iB00_633_v n1_88090_431216 0 -1.7000000007965504e-07
iB00_634_v n1_65594_434560 0 3.349999999916713e-07
iB00_635_v n1_65594_437904 0 -1.6499999999121384e-07
iB00_636_v n1_88090_434560 0 5.000000045242523e-09
iB00_637_v n1_48000_434560 0 -2.1175823681357508e-19
iB00_638_v n1_44000_434560 0 0.0
iB00_639_v n1_46000_437904 0 -7.650000000043879e-07
iB00_640_v n1_46000_441248 0 4.050000000080031e-07
iB00_641_v n1_48000_437904 0 0.0
iB00_642_v n1_44000_437904 0 0.0
iB00_643_v n1_88090_437904 0 -1.4999999994273067e-07
iB00_644_v n1_65594_441248 0 1.799999999469469e-07
iB00_645_v n1_65594_444238 0 0.07562150000000006
iB00_646_v n1_88090_441248 0 3.4000000000938526e-07
iB00_647_v n1_48000_441248 0 -4.99999999992626e-09
iB00_648_v n1_44000_441248 0 0.0
iB00_649_v n1_46000_444238 0 -1.4999999473694332e-06
iB00_650_v n1_46000_444592 0 2.465000000016586e-06
iB00_651_v n1_44000_444238 0 -5.27355e-14
iB00_652_v n1_88090_444238 0 0.06440249999999988
iB00_653_v n1_65594_444592 0 -1.5999999990997242e-07
iB00_654_v n1_65594_447936 0 6.24999999887868e-07
iB00_655_v n1_88090_444592 0 9.199999999982903e-07
iB00_656_v n1_48000_444592 0 2.1175823681357508e-19
iB00_657_v n1_44000_444592 0 0.0
iB00_658_v n1_46000_447936 0 -1.4399999999893509e-06
iB00_659_v n1_46000_451280 0 -6.300000000847295e-07
iB00_660_v n1_48000_447936 0 0.0
iB00_661_v n1_44000_447936 0 0.0
iB00_662_v n1_88090_447936 0 -3.880000000000376e-06
iB00_663_v n1_65594_451280 0 1.8750000001171902e-06
iB00_664_v n1_65594_454624 0 -1.4650000000008406e-06
iB00_665_v n1_88090_451280 0 4.000000000034182e-07
iB00_666_v n1_48000_451280 0 4.99999999992626e-09
iB00_667_v n1_44000_451280 0 0.0
iB00_668_v n1_46000_454624 0 -9.499999992342477e-08
iB00_669_v n1_46000_457968 0 1.1500000008258376e-07
iB00_670_v n1_48000_454624 0 -4.99999999992626e-09
iB00_671_v n1_44000_454624 0 0.0
iB00_672_v n1_88090_454624 0 3.7649999999177924e-06
iB00_673_v n1_65594_457968 0 5.899999999671583e-07
iB00_674_v n1_65594_461312 0 -1.934999999965957e-06
iB00_675_v n1_88090_457968 0 -3.7499999999243664e-06
iB00_676_v n1_48000_457968 0 -4.999999999714502e-09
iB00_677_v n1_44000_457968 0 0.0
iB00_678_v n1_46000_461312 0 -5.500000008495095e-08
iB00_679_v n1_46000_464656 0 -6.900000000618217e-07
iB00_680_v n1_48000_461312 0 0.0
iB00_681_v n1_44000_461312 0 0.0
iB00_682_v n1_88090_461312 0 2.8399999998192024e-06
iB00_683_v n1_65594_464656 0 1.044999999936731e-06
iB00_684_v n1_65594_466126 0 0.07580499999999997
iB00_685_v n1_88090_464656 0 -1.499999999870305e-06
iB00_686_v n1_48000_464656 0 -5.0000000001380185e-09
iB00_687_v n1_44000_464656 0 0.0
iB00_688_v n1_46000_466126 0 1.0000000528054552e-06
iB00_689_v n1_46000_468000 0 3.1749999998900713e-06
iB00_690_v n1_44000_466126 0 -5.27355e-14
iB00_691_v n1_88090_466126 0 0.06440099999999985
iB00_692_v n1_65594_468000 0 -9.149999999272133e-07
iB00_693_v n1_65594_471344 0 -1.2350000000525135e-06
iB00_694_v n1_88090_468000 0 -1.5049999999113123e-06
iB00_695_v n1_48000_468000 0 -5.0000000001380185e-09
iB00_696_v n1_44000_468000 0 0.0
iB00_697_v n1_46000_471344 0 -3.5399999999539333e-06
iB00_698_v n1_46000_474688 0 -9.099999998332664e-07
iB00_699_v n1_48000_471344 0 4.99999999992626e-09
iB00_700_v n1_44000_471344 0 0.0
iB00_701_v n1_88090_471344 0 2.8200000000075387e-06
iB00_702_v n1_65594_474688 0 -1.0100000000778547e-06
iB00_703_v n1_65594_478032 0 -3.0500000008232275e-07
iB00_704_v n1_88090_474688 0 1.1700000000335669e-06
iB00_705_v n1_48000_474688 0 4.2351647362715017e-19
iB00_706_v n1_44000_474688 0 0.0
iB00_707_v n1_46000_478032 0 1.0049999998534647e-06
iB00_708_v n1_46000_481376 0 2.134999999925738e-06
iB00_709_v n1_48000_478032 0 0.0
iB00_710_v n1_44000_478032 0 0.0
iB00_711_v n1_88090_478032 0 -1.4000000000437274e-06
iB00_712_v n1_65594_481376 0 9.149999999979406e-07
iB00_713_v n1_65594_484720 0 2.6750000001532492e-06
iB00_714_v n1_88090_481376 0 1.0000000003155949e-07
iB00_715_v n1_48000_481376 0 -4.2351647362715017e-19
iB00_716_v n1_44000_481376 0 0.0
iB00_717_v n1_46000_484720 0 -2.624999999994321e-06
iB00_718_v n1_46000_488064 0 1.5800000001918446e-06
iB00_719_v n1_48000_484720 0 -8.470329472543003e-19
iB00_720_v n1_44000_484720 0 0.0
iB00_721_v n1_88090_484720 0 6.500000000048134e-07
iB00_722_v n1_65594_488064 0 6.999999989732369e-08
iB00_723_v n1_65594_488622 0 0.07477949999999993
iB00_724_v n1_88090_488064 0 2.499999999471851e-07
iB00_725_v n1_48000_488064 0 -4.2351647362715017e-19
iB00_726_v n1_44000_488064 0 0.0
iB00_727_v n1_46000_488622 0 2.5000000262716376e-06
iB00_728_v n1_46000_491408 0 -4.0099999998061825e-06
iB00_729_v n1_44000_488622 0 -2.63678e-14
iB00_730_v n1_88090_488622 0 0.06440249999999992
iB00_731_v n1_65594_491408 0 -1.5399999999569594e-06
iB00_732_v n1_65594_494752 0 -2.3850000000109894e-06
iB00_733_v n1_88090_491408 0 -3.399999999900729e-06
iB00_734_v n1_48000_491408 0 4.2351647362715017e-19
iB00_735_v n1_44000_491408 0 0.0
iB00_736_v n1_46000_494752 0 3.7999999977755535e-07
iB00_737_v n1_46000_498096 0 3.3700000004119324e-06
iB00_738_v n1_48000_494752 0 4.999999999502744e-09
iB00_739_v n1_44000_494752 0 0.0
iB00_740_v n1_88090_494752 0 2.4999999998767328e-06
iB00_741_v n1_65594_498096 0 2.4800000000574457e-06
iB00_742_v n1_65594_501440 0 -1.9650000000629234e-06
iB00_743_v n1_88090_498096 0 -2.549999999997121e-06
iB00_744_v n1_48000_498096 0 8.470329472543003e-19
iB00_745_v n1_44000_498096 0 0.0
iB00_746_v n1_46000_501440 0 -1.850000000735046e-07
iB00_747_v n1_46000_504784 0 -4.600000001134946e-07
iB00_748_v n1_48000_501440 0 8.470329472543003e-19
iB00_749_v n1_44000_501440 0 0.0
iB00_750_v n1_88090_501440 0 1.4999999999694077e-06
iB00_751_v n1_65594_504784 0 -6.999999999659595e-07
iB00_752_v n1_65594_508128 0 1.4999999999694077e-06
iB00_753_v n1_88090_504784 0 -2.4999999994125587e-07
iB00_754_v n1_48000_504784 0 1.0000000000276037e-08
iB00_755_v n1_44000_504784 0 0.0
iB00_756_v n1_46000_508128 0 -2.6550000000726525e-06
iB00_757_v n1_46000_510510 0 -4.999999734991295e-07
iB00_758_v n1_48000_508128 0 4.999999999502744e-09
iB00_759_v n1_44000_508128 0 0.0
iB00_760_v n1_88090_508128 0 2.0000000001399107e-06
iB00_761_v n1_65594_510510 0 0.07462149999999998
iB00_762_v n1_65594_511472 0 2.4999999986841104e-07
iB00_763_v n1_88090_510510 0 0.06439849999999991
iB00_764_v n1_44000_510510 0 -2.63678e-14
iB00_765_v n1_46000_511472 0 4.139999999922003e-06
iB00_766_v n1_46000_514816 0 -3.1150000001298195e-06
iB00_767_v n1_48000_511472 0 1.0000000000699553e-08
iB00_768_v n1_44000_511472 0 0.0
iB00_769_v n1_88090_511472 0 2.849999999996085e-06
iB00_770_v n1_65594_514816 0 -2.9999999999413566e-06
iB00_771_v n1_65594_518160 0 0.0
iB00_772_v n1_88090_514816 0 -1.0499999999260694e-06
iB00_773_v n1_48000_514816 0 1.5000000000202297e-08
iB00_774_v n1_44000_514816 0 0.0
iB00_775_v n1_46000_518160 0 1.9199999999674488e-06
iB00_776_v n1_46000_521504 0 -1.0499999999243753e-06
iB00_777_v n1_48000_518160 0 -1.999999999970504e-08
iB00_778_v n1_44000_518160 0 0.0
iB00_779_v n1_88090_518160 0 -8.499999999645944e-07
iB00_780_v n1_65594_521504 0 4.100000000180938e-06
iB00_781_v n1_65594_524848 0 -4.5000000015345265e-07
iB00_782_v n1_88090_521504 0 -1.2999999999316998e-06
iB00_783_v n1_48000_521504 0 0.0
iB00_784_v n1_44000_521504 0 0.0
iB00_785_v n1_46000_524848 0 -2.3699999997308428e-06
iB00_786_v n1_46000_528192 0 2.5749999999023082e-06
iB00_787_v n1_48000_524848 0 1.999999999970504e-08
iB00_788_v n1_44000_524848 0 0.0
iB00_789_v n1_88090_524848 0 2.599999999802413e-06
iB00_790_v n1_65594_528192 0 -3.4499999998940624e-06
iB00_791_v n1_65594_531536 0 1.5000000005115088e-07
iB00_792_v n1_88090_528192 0 -4.100000000103858e-06
iB00_793_v n1_48000_528192 0 -2.5000000000478334e-08
iB00_794_v n1_44000_528192 0 0.0
iB00_795_v n1_46000_531536 0 -1.6500000001010268e-06
iB00_796_v n1_46000_532398 0 2.6454533008646308e-14
iB00_797_v n1_48000_531536 0 0.0
iB00_798_v n1_44000_531536 0 0.0
iB00_799_v n1_88090_531536 0 3.75000000019457e-06
iB00_800_v n1_65594_532398 0 0.07599499999999998
iB00_801_v n1_65594_534880 0 -1.5500000003117187e-06
iB00_802_v n1_88090_532398 0 0.06440500000000013
iB00_803_v n1_44000_532398 0 -2.63678e-14
iB00_804_v n1_46000_534880 0 4.6499999967084617e-07
iB00_805_v n1_46000_538224 0 9.55000000520817e-07
iB00_806_v n1_48000_534880 0 -1.4999999999355264e-08
iB00_807_v n1_44000_534880 0 0.0
iB00_808_v n1_88090_534880 0 -2.499999999985153e-06
iB00_809_v n1_65594_538224 0 7.500000000168911e-07
iB00_810_v n1_65594_541568 0 6.500000000048134e-07
iB00_811_v n1_88090_538224 0 4.0000000010252104e-07
iB00_812_v n1_48000_538224 0 -4.999999999502744e-09
iB00_813_v n1_44000_538224 0 0.0
iB00_814_v n1_46000_541568 0 4.14999999863013e-07
iB00_815_v n1_46000_544912 0 -1.955000000428142e-06
iB00_816_v n1_48000_541568 0 -1.500000000104933e-08
iB00_817_v n1_44000_541568 0 0.0
iB00_818_v n1_88090_541568 0 -1.7999999997464489e-06
iB00_819_v n1_65594_544912 0 -1.7000000000681021e-06
iB00_820_v n1_65594_548256 0 4.2500000001482324e-06
iB00_821_v n1_88090_544912 0 1.2999999998554668e-06
iB00_822_v n1_48000_544912 0 4.999999998655711e-09
iB00_823_v n1_44000_544912 0 0.0
iB00_824_v n1_46000_548256 0 3.0000000001912313e-06
iB00_825_v n1_46000_551600 0 -6.250000001047085e-07
iB00_826_v n1_48000_548256 0 1.6940658945086007e-18
iB00_827_v n1_44000_548256 0 0.0
iB00_828_v n1_88090_548256 0 -1.0000000025094102e-07
iB00_829_v n1_65594_551600 0 -1.0499999999751973e-06
iB00_830_v n1_65594_554894 0 0.07407500000000006
iB00_831_v n1_88090_551600 0 -8.49999999979841e-07
iB00_832_v n1_48000_551600 0 2.5000000000054818e-08
iB00_833_v n1_44000_551600 0 0.0
iB00_834_v n1_46000_554894 0 2.63678e-14
iB00_835_v n1_46000_554944 0 -1.5000000026799132e-07
iB00_836_v n1_44000_554894 0 -2.63678e-14
iB00_837_v n1_88090_554894 0 0.06440500000000024
iB00_838_v n1_65594_554944 0 -1.7999999999463486e-06
iB00_839_v n1_65594_558288 0 5.000000023389073e-08
iB00_840_v n1_88090_554944 0 -3.250000000149428e-06
iB00_841_v n1_48000_554944 0 0.0
iB00_842_v n1_44000_554944 0 0.0
iB00_843_v n1_46000_558288 0 -3.500000000048332e-06
iB00_844_v n1_46000_561632 0 3.0000000053598264e-07
iB00_845_v n1_48000_558288 0 1.6940658945086007e-18
iB00_846_v n1_44000_558288 0 0.0
iB00_847_v n1_88090_558288 0 2.5500000000022033e-06
iB00_848_v n1_65594_561632 0 -1.6500000002204584e-06
iB00_849_v n1_65594_564976 0 -3.4999999990251163e-07
iB00_850_v n1_88090_561632 0 4.999999997639271e-08
iB00_851_v n1_48000_561632 0 8.470329472543003e-19
iB00_852_v n1_44000_561632 0 0.0
iB00_853_v n1_46000_564976 0 3.9999999994869985e-06
iB00_854_v n1_46000_568320 0 2.0000000093556292e-07
iB00_855_v n1_48000_564976 0 0.0
iB00_856_v n1_44000_564976 0 0.0
iB00_857_v n1_88090_564976 0 -4.999999980020986e-08
iB00_858_v n1_65594_568320 0 6.000000000267266e-07
iB00_859_v n1_65594_571664 0 3.099999999972916e-06
iB00_860_v n1_88090_568320 0 -2.1000000000825317e-06
iB00_861_v n1_48000_568320 0 1.6940658945086007e-18
iB00_862_v n1_44000_568320 0 0.0
iB00_863_v n1_46000_571664 0 -3.7000000001233095e-06
iB00_864_v n1_46000_575008 0 -1.5000000026799132e-07
iB00_865_v n1_48000_571664 0 5.0000000000109636e-08
iB00_866_v n1_44000_571664 0 0.0
iB00_867_v n1_88090_571664 0 -5.499999999707128e-07
iB00_868_v n1_65594_575008 0 -8.999999997478636e-07
iB00_869_v n1_65594_576782 0 0.07484999999999957
iB00_870_v n1_88090_575008 0 1.0000000002054806e-07
iB00_871_v n1_48000_575008 0 -1.6940658945086007e-18
iB00_872_v n1_44000_575008 0 0.0
iB00_873_v n1_46000_576782 0 5.000000026338106e-06
iB00_874_v n1_46000_578352 0 -3.3999999998583774e-06
iB00_875_v n1_44000_576782 0 -2.63678e-14
iB00_876_v n1_88090_576782 0 0.0644049999999998
iB00_877_v n1_65594_578352 0 -5.499999996251234e-07
iB00_878_v n1_65594_581696 0 3.349999999190806e-06
iB00_879_v n1_88090_578352 0 -3.150000000132268e-06
iB00_880_v n1_48000_578352 0 -4.999999999841557e-08
iB00_881_v n1_44000_578352 0 0.0
iB00_882_v n1_46000_581696 0 3.44999999947224e-06
iB00_883_v n1_46000_585040 0 -2.6999999996196733e-06
iB00_884_v n1_48000_581696 0 0.0
iB00_885_v n1_44000_581696 0 0.0
iB00_886_v n1_88090_581696 0 1.6000000001119286e-06
iB00_887_v n1_65594_585040 0 -2.499999997159451e-07
iB00_888_v n1_65594_588384 0 1.1500000001753163e-06
iB00_889_v n1_88090_585040 0 -2.4500000001883313e-06
iB00_890_v n1_48000_585040 0 1.6940658945086007e-18
iB00_891_v n1_44000_585040 0 0.0
iB00_892_v n1_46000_588384 0 1.0000000004087685e-07
iB00_893_v n1_46000_591728 0 -1.1500000001753163e-06
iB00_894_v n1_48000_588384 0 5.0000000000109636e-08
iB00_895_v n1_44000_588384 0 0.0
iB00_896_v n1_88090_588384 0 8.000000000559643e-07
iB00_897_v n1_65594_591728 0 -4.400000000124844e-06
iB00_898_v n1_65594_595072 0 1.3500000006771984e-06
iB00_899_v n1_88090_591728 0 1.9000000000312712e-06
iB00_900_v n1_48000_591728 0 4.999999999841557e-08
iB00_901_v n1_44000_591728 0 0.0
iB00_902_v n1_46000_595072 0 1.0000000004934718e-07
iB00_903_v n1_46000_598416 0 -4.999999936652899e-08
iB00_904_v n1_48000_595072 0 6.776263578034403e-18
iB00_905_v n1_44000_595072 0 0.0
iB00_906_v n1_88090_595072 0 -3.3000000000411173e-06
iB00_907_v n1_65594_598416 0 2.2999999998627417e-06
iB00_908_v n1_65594_599278 0 0.07975499999999949
iB00_909_v n1_88090_598416 0 6.999999999032791e-07
iB00_910_v n1_48000_598416 0 3.3881317890172014e-18
iB00_911_v n1_44000_598416 0 0.0
iB00_912_v n1_46000_599278 0 1.0000000026525253e-05
iB00_913_v n1_46000_601760 0 8.499999983382911e-07
iB00_914_v n1_44000_599278 0 -2.63678e-14
iB00_915_v n1_88090_599278 0 0.06685500000000022
iB00_916_v n1_65594_601760 0 1.1999999997248044e-06
iB00_917_v n1_65594_605104 0 -1.4499999994102564e-06
iB00_918_v n1_88090_601760 0 1.0000000000767316e-06
iB00_919_v n1_48000_601760 0 -6.776263578034403e-18
iB00_920_v n1_44000_601760 0 0.0
iB00_921_v n1_46000_605104 0 -1.2049999998847352e-05
iB00_922_v n1_46000_608448 0 -1.520000000084648e-05
iB00_923_v n1_48000_605104 0 5.000000000349777e-08
iB00_924_v n1_44000_605104 0 0.0
iB00_925_v n1_88090_605104 0 5.999999997709227e-07
iB00_926_v n1_65594_608448 0 1.4999999995763845e-06
iB00_927_v n1_65594_611792 0 -9.99999999907325e-07
iB00_928_v n1_88090_608448 0 -2.149999999892906e-06
iB00_929_v n1_48000_608448 0 2.0000000000382667e-07
iB00_930_v n1_44000_608448 0 0.0
iB00_931_v n1_46000_611792 0 1.0250000000679773e-05
iB00_932_v n1_46000_615136 0 3.219999999970469e-05
iB00_933_v n1_48000_611792 0 -2.499999999903838e-07
iB00_934_v n1_44000_611792 0 0.0
iB00_935_v n1_88090_611792 0 3.250000000024067e-06
iB00_936_v n1_65594_615136 0 -4.999999997503746e-07
iB00_937_v n1_65594_618480 0 -5.000000001705029e-07
iB00_938_v n1_88090_615136 0 -3.099999999972916e-06
iB00_939_v n1_48000_615136 0 -2.000000000072148e-07
iB00_940_v n1_44000_615136 0 0.0
iB00_941_v n1_46000_618480 0 -3.259999999904149e-05
iB00_942_v n1_46000_624152 0 -1.7001500000000016
iB00_943_v n1_48000_618480 0 1.0000000000699553e-07
iB00_944_v n1_44000_618480 0 0.0
iB00_945_v n1_88090_618480 0 3.2499999998275553e-06
iB00_946_v n1_65594_624152 0 2.688821387764051e-14
iB00_947_v n1_65594_626152 0 -2.63678e-14
iB00_948_v n1_88090_624152 0 -4.999999973819346e-06
iB00_949_v n1_28_624152 0 -4.473544999999922
iB00_950_v n1_46000_670124 0 -4.999999999970306e-06
iB00_951_v n1_46000_670152 0 -5.73935
iB00_952_v n1_46000_622152 0 0.0
iB00_953_v n1_0_624152 0 -7.7443e-14
iB00_954_v n1_110282_624152 0 5.000000026424839e-06
iB00_955_v n1_88090_626152 0 -2.63678e-14
iB00_956_v n1_110282_618480 0 -3.449999999983848e-06
iB00_957_v n1_132778_618480 0 9.99999999392329e-08
iB00_958_v n1_110282_615136 0 8.500000000730146e-07
iB00_959_v n1_110282_626152 0 -2.63678e-14
iB00_960_v n1_132778_624152 0 -4.999999736400726e-07
iB00_961_v n1_154970_624152 0 5.00000026625036e-07
iB00_962_v n1_132778_626152 0 -2.63678e-14
iB00_963_v n1_132778_615136 0 3.3881317890172014e-18
iB00_964_v n1_154970_618480 0 -2.4999999997683126e-07
iB00_965_v n1_177466_618480 0 2.4999999996666686e-07
iB00_966_v n1_154970_615136 0 0.0
iB00_967_v n1_154970_626152 0 -2.63678e-14
iB00_968_v n1_177466_624152 0 -3.999999973803601e-06
iB00_969_v n1_199658_624152 0 2.5000000527857988e-06
iB00_970_v n1_177466_626152 0 -2.63678e-14
iB00_971_v n1_177466_615136 0 -1.499999999664476e-07
iB00_972_v n1_199658_618480 0 -3.000000000209866e-07
iB00_973_v n1_221850_618480 0 0.0
iB00_974_v n1_199658_615136 0 2.9999999999388155e-07
iB00_975_v n1_199658_626152 0 -5.27355e-14
iB00_976_v n1_221850_624152 0 1.000000052697035e-06
iB00_977_v n1_244346_624152 0 -2.499999947184507e-06
iB00_978_v n1_221850_626152 0 -5.27355e-14
iB00_979_v n1_221850_615136 0 9.999999998497268e-08
iB00_980_v n1_244346_618480 0 1.9999999998688602e-07
iB00_981_v n1_266538_618480 0 4.500000000001397e-07
iB00_982_v n1_244346_615136 0 -2.9999999999388155e-07
iB00_983_v n1_244346_626152 0 -5.27355e-14
iB00_984_v n1_266538_624152 0 1.000000052697035e-06
iB00_985_v n1_289034_624152 0 5.277354074573193e-14
iB00_986_v n1_266538_626152 0 -5.27355e-14
iB00_987_v n1_266538_615136 0 -1.1499999998178684e-07
iB00_988_v n1_289034_618480 0 -9.999999997989048e-08
iB00_989_v n1_311226_618480 0 4.800000000009678e-07
iB00_990_v n1_289034_615136 0 3.1499999996104956e-07
iB00_991_v n1_289034_626152 0 -5.27355e-14
iB00_992_v n1_311226_624152 0 5.27355e-14
iB00_993_v n1_333722_624152 0 5.271255437352962e-14
iB00_994_v n1_311226_626152 0 -5.27355e-14
iB00_995_v n1_311226_615136 0 -1.4000000001741705e-07
iB00_996_v n1_333722_618480 0 -5.999999997709227e-08
iB00_997_v n1_355914_618480 0 -3.9500000001746797e-07
iB00_998_v n1_333722_615136 0 -1.599999999840878e-07
iB00_999_v n1_333722_626152 0 -5.27355e-14
iB00_1000_v n1_355914_624152 0 5.276260505431214e-14
iB00_1001_v n1_378410_624152 0 5.274643569141979e-14
iB00_1002_v n1_355914_626152 0 -5.27355e-14
iB00_1003_v n1_355914_615136 0 2.8999999998132354e-07
iB00_1004_v n1_378410_618480 0 1.7500000000546592e-07
iB00_1005_v n1_400602_618480 0 -1.4999999999863484e-07
iB00_1006_v n1_378410_615136 0 -1.6499999999121384e-07
iB00_1007_v n1_378410_626152 0 -5.27355e-14
iB00_1008_v n1_400602_624152 0 5.27355e-14
iB00_1009_v n1_422794_624152 0 -4.999999473698571e-07
iB00_1010_v n1_400602_626152 0 -5.27355e-14
iB00_1011_v n1_400602_615136 0 1.2499999999942706e-07
iB00_1012_v n1_422794_618480 0 2.999999999667765e-07
iB00_1013_v n1_445290_618480 0 -9.999999999005488e-08
iB00_1014_v n1_422794_615136 0 -9.999999997989048e-08
iB00_1015_v n1_422794_626152 0 -5.27355e-14
iB00_1016_v n1_445290_624152 0 5.000000527975827e-07
iB00_1017_v n1_467482_624152 0 -9.999999472150994e-07
iB00_1018_v n1_445290_626152 0 -5.27355e-14
iB00_1019_v n1_445290_615136 0 -2.0000000000382667e-07
iB00_1020_v n1_467482_618480 0 1.9999999998688602e-07
iB00_1021_v n1_489978_618480 0 4.500000000111511e-07
iB00_1022_v n1_467482_615136 0 1.5000000002404583e-07
iB00_1023_v n1_467482_626152 0 -5.27355e-14
iB00_1024_v n1_489978_624152 0 2.0000000265077105e-06
iB00_1025_v n1_512170_624152 0 -2.4999999737474604e-06
iB00_1026_v n1_489978_626152 0 -2.63678e-14
iB00_1027_v n1_489978_615136 0 -2.499999999598906e-07
iB00_1028_v n1_512170_618480 0 0.0
iB00_1029_v n1_534666_618480 0 -3.499999999770505e-07
iB00_1030_v n1_512170_615136 0 9.999999997989048e-08
iB00_1031_v n1_512170_626152 0 -2.63678e-14
iB00_1032_v n1_534666_624152 0 3.500000026260278e-06
iB00_1033_v n1_556858_624152 0 -4.999999973082092e-06
iB00_1034_v n1_534666_626152 0 -2.63678e-14
iB00_1035_v n1_534666_615136 0 -1.0000000004087685e-07
iB00_1036_v n1_556858_618480 0 1.95000000001444e-06
iB00_1037_v n1_579050_618480 0 3.250000000071501e-06
iB00_1038_v n1_556858_615136 0 3.5000000011935206e-07
iB00_1039_v n1_556858_626152 0 -2.63678e-14
iB00_1040_v n1_579050_624152 0 2.61509595655029e-14
iB00_1041_v n1_601546_624152 0 -4.9999999748168156e-06
iB00_1042_v n1_579050_626152 0 -2.63678e-14
iB00_1043_v n1_579050_615136 0 -2.200000000052258e-06
iB00_1044_v n1_601546_618480 0 -9.000000003069053e-07
iB00_1045_v n1_623064_618480 0 -5.000000001027403e-08
iB00_1046_v n1_601546_615136 0 -1.0999999999414256e-06
iB00_1047_v n1_601546_626152 0 -2.63678e-14
iB00_1048_v n1_625064_624152 0 -1.671104999999999
iB00_1049_v n1_671036_624152 0 -4.397099999999923
iB00_1050_v n1_625064_618480 0 2.754999999949459e-05
iB00_1051_v n1_625064_670124 0 4.999999999970306e-06
iB00_1052_v n1_625064_670152 0 -5.64145
iB00_1053_v n1_625064_622152 0 0.0
iB00_1054_v n1_671064_624152 0 -7.7443e-14
iB00_1055_v n1_625064_615136 0 -1.54999999972896e-06
iB00_1056_v n1_627064_618480 0 0.0
iB00_1057_v n1_625064_611792 0 -1.6649999999264015e-05
iB00_1058_v n1_627064_615136 0 0.0
iB00_1059_v n1_623064_615136 0 5.000000000349777e-08
iB00_1060_v n1_601546_611792 0 7.000000004690971e-07
iB00_1061_v n1_601546_608448 0 -2.150000000739939e-06
iB00_1062_v n1_623064_611792 0 1.4999999999355264e-07
iB00_1063_v n1_579050_611792 0 1.4499999998439372e-06
iB00_1064_v n1_556858_611792 0 -5.000000000857997e-07
iB00_1065_v n1_579050_608448 0 -8.999999998732244e-07
iB00_1066_v n1_556858_608448 0 8.50000000059462e-07
iB00_1067_v n1_534666_611792 0 3.0000000004809166e-07
iB00_1068_v n1_512170_611792 0 1.9999999994622843e-07
iB00_1069_v n1_534666_608448 0 -2.0000000006820118e-07
iB00_1070_v n1_512170_608448 0 -1.499999999562832e-07
iB00_1071_v n1_489978_611792 0 4.9999999962840186e-08
iB00_1072_v n1_467482_611792 0 -3.500000000278725e-07
iB00_1073_v n1_489978_608448 0 9.999999997989048e-08
iB00_1074_v n1_467482_608448 0 1.4999999998169418e-07
iB00_1075_v n1_445290_611792 0 3.5000000001093184e-07
iB00_1076_v n1_422794_611792 0 2.5000000001325367e-07
iB00_1077_v n1_445290_608448 0 -4.000000000008771e-07
iB00_1078_v n1_422794_608448 0 -1.500000000003289e-07
iB00_1079_v n1_400602_611792 0 2.450000000239153e-07
iB00_1080_v n1_378410_611792 0 -8.50000000034051e-08
iB00_1081_v n1_400602_608448 0 -2.5500000001106235e-07
iB00_1082_v n1_378410_608448 0 -5.999999999911512e-08
iB00_1083_v n1_355914_611792 0 -2.300000000025372e-07
iB00_1084_v n1_333722_611792 0 1.8000000000518042e-07
iB00_1085_v n1_355914_608448 0 3.4999999995672174e-08
iB00_1086_v n1_333722_608448 0 -2.99999999927813e-08
iB00_1087_v n1_311226_611792 0 9.999999997989048e-08
iB00_1088_v n1_289034_611792 0 -3.5000000000076745e-07
iB00_1089_v n1_311226_608448 0 -3.199999999681756e-07
iB00_1090_v n1_289034_608448 0 3.9500000002678533e-07
iB00_1091_v n1_266538_611792 0 -3.5999999999807887e-07
iB00_1092_v n1_244346_611792 0 -4.9999999996721504e-08
iB00_1093_v n1_266538_608448 0 1.3500000002977276e-07
iB00_1094_v n1_244346_608448 0 5.00000000018037e-08
iB00_1095_v n1_221850_611792 0 -2.0000000001399107e-07
iB00_1096_v n1_199658_611792 0 1.000000000036074e-07
iB00_1097_v n1_221850_608448 0 2.500000000039363e-07
iB00_1098_v n1_199658_608448 0 -4.4999999997557573e-07
iB00_1099_v n1_177466_611792 0 1.4999999999694077e-07
iB00_1100_v n1_154970_611792 0 1.9999999999027415e-07
iB00_1101_v n1_177466_608448 0 -2.0000000001399107e-07
iB00_1102_v n1_154970_608448 0 -4.9999999996721504e-08
iB00_1103_v n1_132778_611792 0 5.421010862427522e-17
iB00_1104_v n1_110282_611792 0 5.999999999809868e-07
iB00_1105_v n1_132778_608448 0 9.999999994262103e-08
iB00_1106_v n1_110282_608448 0 2.3999999999510524e-06
iB00_1107_v n1_110282_605104 0 -2.1499999999267873e-06
iB00_1108_v n1_110282_601760 0 -1.4500000001691979e-06
iB00_1109_v n1_132778_605104 0 -1.4999999999694077e-07
iB00_1110_v n1_132778_601760 0 -9.999999999683114e-08
iB00_1111_v n1_110282_599278 0 0.067
iB00_1112_v n1_110282_598416 0 2.499999999985153e-06
iB00_1113_v n1_132778_599278 0 0.06699649999999994
iB00_1114_v n1_132778_598416 0 1.0999999998872155e-06
iB00_1115_v n1_110282_595072 0 -7.500000000321377e-07
iB00_1116_v n1_110282_591728 0 -9.499999998902747e-07
iB00_1117_v n1_132778_595072 0 -2.349999999934002e-06
iB00_1118_v n1_132778_591728 0 -3.0000000005825605e-07
iB00_1119_v n1_110282_588384 0 1.9999999999230703e-06
iB00_1120_v n1_110282_585040 0 -1.6499999999121384e-06
iB00_1121_v n1_132778_588384 0 2.4499999999681027e-06
iB00_1122_v n1_132778_585040 0 9.500000000088593e-07
iB00_1123_v n1_110282_581696 0 -1.9499999999974995e-06
iB00_1124_v n1_110282_578352 0 1.2499999999925765e-06
iB00_1125_v n1_132778_581696 0 -4.550000000033694e-06
iB00_1126_v n1_132778_578352 0 1.1500000000228504e-06
iB00_1127_v n1_110282_576782 0 0.06440500000000002
iB00_1128_v n1_110282_575008 0 2.9000000001215553e-06
iB00_1129_v n1_132778_576782 0 0.06439999999999983
iB00_1130_v n1_132778_575008 0 -1.0000000000021927e-07
iB00_1131_v n1_110282_571664 0 -4.249999999904287e-06
iB00_1132_v n1_110282_568320 0 1.95000000001444e-06
iB00_1133_v n1_132778_571664 0 2.0000000000314905e-06
iB00_1134_v n1_132778_568320 0 4.500000000619731e-07
iB00_1135_v n1_110282_564976 0 1.1999999999518093e-06
iB00_1136_v n1_110282_561632 0 -1.700000000037609e-06
iB00_1137_v n1_132778_564976 0 3.4999999990251163e-07
iB00_1138_v n1_132778_561632 0 -3.449999999912697e-06
iB00_1139_v n1_110282_558288 0 3.0000000000133544e-06
iB00_1140_v n1_110282_554944 0 1.5000000005115088e-07
iB00_1141_v n1_132778_558288 0 4.150000000005712e-06
iB00_1142_v n1_132778_554944 0 -1.899999999946568e-06
iB00_1143_v n1_110282_554894 0 0.06439499999999997
iB00_1144_v n1_110282_551600 0 3.649999999943629e-06
iB00_1145_v n1_132778_554894 0 0.06440500000000002
iB00_1146_v n1_132778_551600 0 -1.399999999982741e-06
iB00_1147_v n1_110282_548256 0 9.999999999225716e-07
iB00_1148_v n1_110282_544912 0 -4.800000000010525e-06
iB00_1149_v n1_132778_548256 0 1.4499999999523575e-06
iB00_1150_v n1_132778_544912 0 4.499999999416944e-07
iB00_1151_v n1_110282_541568 0 1.0499999999260694e-06
iB00_1152_v n1_110282_538224 0 3.450000000092268e-06
iB00_1153_v n1_132778_541568 0 -4.399999999982543e-06
iB00_1154_v n1_132778_538224 0 1.7499999999276043e-06
iB00_1155_v n1_110282_534880 0 -2.8000000000078337e-06
iB00_1156_v n1_110282_532398 0 0.06440000000000004
iB00_1157_v n1_132778_534880 0 -1.0999999999414256e-06
iB00_1158_v n1_132778_532398 0 0.0644049999999999
iB00_1159_v n1_110282_531536 0 -2.5999999999430206e-06
iB00_1160_v n1_110282_528192 0 2.7999999998706143e-06
iB00_1161_v n1_132778_531536 0 -9.499999998902747e-07
iB00_1162_v n1_132778_528192 0 -2.499999999056805e-07
iB00_1163_v n1_110282_524848 0 -9.500000000342703e-07
iB00_1164_v n1_110282_521504 0 1.2000000000839464e-06
iB00_1165_v n1_132778_524848 0 1.3000000000096268e-06
iB00_1166_v n1_132778_521504 0 -1.5000000000185357e-06
iB00_1167_v n1_110282_518160 0 -9.00000000093453e-07
iB00_1168_v n1_110282_514816 0 2.650000000036304e-06
iB00_1169_v n1_132778_518160 0 1.3999999999353072e-06
iB00_1170_v n1_132778_514816 0 -5.0000000033990953e-08
iB00_1171_v n1_110282_511472 0 -3.199999999908761e-06
iB00_1172_v n1_110282_510510 0 0.06440049999999978
iB00_1173_v n1_132778_511472 0 -9.000000000900649e-07
iB00_1174_v n1_132778_510510 0 0.06440000000000004
iB00_1175_v n1_110282_508128 0 -4.9999999996721504e-08
iB00_1176_v n1_110282_504784 0 9.499999999986949e-07
iB00_1177_v n1_132778_508128 0 3.3000000001495375e-06
iB00_1178_v n1_132778_504784 0 -4.050000000041068e-06
iB00_1179_v n1_110282_501440 0 2.450000000051112e-06
iB00_1180_v n1_110282_498096 0 -7.999999999475441e-07
iB00_1181_v n1_132778_501440 0 3.950000000045931e-06
iB00_1182_v n1_132778_498096 0 -2.6000000000497468e-06
iB00_1183_v n1_110282_494752 0 -3.7500000000548095e-06
iB00_1184_v n1_110282_491408 0 3.5999999999265786e-06
iB00_1185_v n1_132778_494752 0 1.2499999999925765e-06
iB00_1186_v n1_132778_491408 0 3.499999999685802e-07
iB00_1187_v n1_110282_488622 0 0.06440200000000003
iB00_1188_v n1_110282_488064 0 -2.1500000000826414e-06
iB00_1189_v n1_132778_488622 0 0.0644005
iB00_1190_v n1_132778_488064 0 2.250000000089637e-06
iB00_1191_v n1_110282_484720 0 6.000000000521376e-07
iB00_1192_v n1_110282_481376 0 -1.4999999999694077e-06
iB00_1193_v n1_132778_484720 0 -3.200000000115437e-06
iB00_1194_v n1_132778_481376 0 1.5999999999730152e-06
iB00_1195_v n1_110282_478032 0 1.5499999999237776e-06
iB00_1196_v n1_110282_474688 0 -2.9999999999388155e-07
iB00_1197_v n1_132778_478032 0 1.6000000000035083e-06
iB00_1198_v n1_132778_474688 0 -3.1999999999536536e-06
iB00_1199_v n1_110282_471344 0 -2.099999999957171e-06
iB00_1200_v n1_110282_468000 0 1.2500000001009967e-06
iB00_1201_v n1_132778_471344 0 2.2500000000083217e-06
iB00_1202_v n1_132778_468000 0 -2.2499999999778285e-06
iB00_1203_v n1_110282_466126 0 0.06440299999999988
iB00_1204_v n1_110282_464656 0 8.499999999645944e-07
iB00_1205_v n1_132778_466126 0 0.06440249999999992
iB00_1206_v n1_132778_464656 0 1.4999999992409594e-07
iB00_1207_v n1_110282_461312 0 -2.7499999999958656e-06
iB00_1208_v n1_110282_457968 0 -1.350000000026677e-06
iB00_1209_v n1_132778_461312 0 -2.9999999993967144e-07
iB00_1210_v n1_132778_457968 0 -1.0000000003325356e-07
iB00_1211_v n1_110282_454624 0 1.5246593050577406e-17
iB00_1212_v n1_110282_451280 0 1.4000000000437274e-06
iB00_1213_v n1_132778_454624 0 2.0000000001399107e-07
iB00_1214_v n1_132778_451280 0 9.999999999174894e-08
iB00_1215_v n1_110282_447936 0 2.7950000000244245e-06
iB00_1216_v n1_110282_444592 0 -8.249999999560692e-07
iB00_1217_v n1_132778_447936 0 5.0000000017050295e-08
iB00_1218_v n1_132778_444592 0 9.999999998243158e-08
iB00_1219_v n1_110282_444238 0 0.06440049999999994
iB00_1220_v n1_110282_441248 0 8.000000005980654e-08
iB00_1221_v n1_132778_444238 0 0.06440100000000001
iB00_1222_v n1_132778_441248 0 -1.4999999998847045e-07
iB00_1223_v n1_110282_437904 0 -5.5000000015706005e-08
iB00_1224_v n1_110282_434560 0 3.0499999997390254e-07
iB00_1225_v n1_132778_437904 0 8.500000003982752e-08
iB00_1226_v n1_132778_434560 0 -1.4000000005807463e-07
iB00_1227_v n1_110282_431216 0 1.3500000006450111e-07
iB00_1228_v n1_110282_427872 0 -6.000000003130238e-08
iB00_1229_v n1_132778_431216 0 1.6500000004542395e-07
iB00_1230_v n1_132778_427872 0 2.499999994584471e-08
iB00_1231_v n1_110282_424528 0 -2.8499999997250343e-07
iB00_1232_v n1_110282_421742 0 0.06440149999999996
iB00_1233_v n1_132778_424528 0 -9.499999994565939e-08
iB00_1234_v n1_132778_421742 0 0.06440150000000001
iB00_1235_v n1_110282_421184 0 -2.2999999998390248e-07
iB00_1236_v n1_110282_417840 0 -1.7000000002544494e-07
iB00_1237_v n1_132778_421184 0 7.499999997136533e-08
iB00_1238_v n1_132778_417840 0 7.99999999869617e-08
iB00_1239_v n1_110282_414496 0 3.600000000887114e-07
iB00_1240_v n1_110282_411152 0 -1.50000000105361e-07
iB00_1241_v n1_132778_414496 0 1.0500000001412158e-07
iB00_1242_v n1_132778_411152 0 1.5000000004268055e-07
iB00_1243_v n1_110282_407808 0 -1.8999999996246954e-07
iB00_1244_v n1_110282_404464 0 2.349999999825582e-07
iB00_1245_v n1_132778_407808 0 -2.900000000880497e-07
iB00_1246_v n1_132778_404464 0 2.8500000003010167e-07
iB00_1247_v n1_110282_401120 0 1.3500000000055013e-07
iB00_1248_v n1_110282_399854 0 0.06440100000000001
iB00_1249_v n1_132778_401120 0 -1.2499999998841563e-07
iB00_1250_v n1_132778_399854 0 0.06440149999999999
iB00_1251_v n1_110282_397776 0 -1.0500000001285103e-07
iB00_1252_v n1_110282_394432 0 2.6500000002531443e-07
iB00_1253_v n1_132778_397776 0 1.2499999998841563e-07
iB00_1254_v n1_132778_394432 0 2.7000000000364135e-07
iB00_1255_v n1_110282_391088 0 -3.99999999998336e-07
iB00_1256_v n1_110282_387744 0 3.94999999966646e-07
iB00_1257_v n1_132778_391088 0 -8.500000001272247e-08
iB00_1258_v n1_132778_387744 0 5.500000001147084e-08
iB00_1259_v n1_110282_384400 0 -3.500000000024615e-07
iB00_1260_v n1_110282_381056 0 3.6500000003230997e-07
iB00_1261_v n1_132778_384400 0 -3.200000000223857e-07
iB00_1262_v n1_132778_381056 0 2.9500000001555463e-07
iB00_1263_v n1_110282_377712 0 3.500000000075437e-08
iB00_1264_v n1_110282_377358 0 0.06603100000000003
iB00_1265_v n1_132778_377712 0 -1.2500000001552068e-07
iB00_1266_v n1_132778_377358 0 0.06607049999999998
iB00_1267_v n1_110282_374368 0 3.449999999830535e-07
iB00_1268_v n1_110282_371024 0 -4.200000000022762e-07
iB00_1269_v n1_132778_374368 0 1.9500000000686503e-07
iB00_1270_v n1_132778_371024 0 -6.000000000927952e-08
iB00_1271_v n1_110282_367680 0 2.849999999945263e-07
iB00_1272_v n1_110282_364336 0 -4.0000000002798214e-08
iB00_1273_v n1_132778_367680 0 1.200000000354997e-07
iB00_1274_v n1_132778_364336 0 -2.799999999861297e-07
iB00_1275_v n1_110282_360992 0 1.1499999997882223e-07
iB00_1276_v n1_110282_357648 0 -2.449999999697052e-07
iB00_1277_v n1_132778_360992 0 2.249999999683061e-07
iB00_1278_v n1_132778_357648 0 1.0999999997423729e-07
iB00_1279_v n1_110282_355470 0 0.08159939999999999
iB00_1280_v n1_110282_354304 0 0.0
iB00_1281_v n1_132778_355470 0 0.08117815
iB00_1282_v n1_132778_354304 0 9.999999997311422e-09
iB00_1283_v n1_110282_350960 0 2.0000000004363722e-08
iB00_1284_v n1_110282_347616 0 -3.0000000008874924e-08
iB00_1285_v n1_132778_350960 0 5.000000000349777e-09
iB00_1286_v n1_132778_347616 0 -9.999999999005488e-09
iB00_1287_v n1_110282_344272 0 2.5000000004289983e-08
iB00_1288_v n1_110282_340928 0 4.999999993573513e-09
iB00_1289_v n1_132778_344272 0 -5.000000000349777e-09
iB00_1290_v n1_132778_340928 0 1.2705494208814505e-18
iB00_1291_v n1_110282_337584 0 -4.999999998655711e-09
iB00_1292_v n1_110282_334240 0 -1.4999999994273067e-08
iB00_1293_v n1_132778_337584 0 3.000000000209866e-08
iB00_1294_v n1_132778_334240 0 1.0000000003664169e-08
iB00_1295_v n1_110282_332974 0 0.08064220000000001
iB00_1296_v n1_110282_330896 0 -3.4999999999060305e-07
iB00_1297_v n1_132778_332974 0 0.08045654999999997
iB00_1298_v n1_132778_330896 0 -6.499999999861787e-08
iB00_1299_v n1_110282_327552 0 4.999999999375689e-08
iB00_1300_v n1_110282_324208 0 3.1000000000813363e-07
iB00_1301_v n1_132778_327552 0 -1.8999999999296273e-07
iB00_1302_v n1_132778_324208 0 2.249999999941406e-07
iB00_1303_v n1_110282_320864 0 -6.500000000031193e-08
iB00_1304_v n1_110282_317520 0 -6.499999999777083e-08
iB00_1305_v n1_132778_320864 0 -3.300000000027565e-07
iB00_1306_v n1_132778_317520 0 1.500000000024465e-07
iB00_1307_v n1_110282_314176 0 -1.9500000000135931e-07
iB00_1308_v n1_110282_311086 0 0.0747035
iB00_1309_v n1_132778_314176 0 1.6999999999833988e-07
iB00_1310_v n1_132778_311086 0 0.07653399999999998
iB00_1311_v n1_110282_310832 0 -6.00000000113971e-08
iB00_1312_v n1_110282_307488 0 3.250000000024067e-07
iB00_1313_v n1_132778_310832 0 -6.999999999134435e-08
iB00_1314_v n1_132778_307488 0 5.999999999022128e-08
iB00_1315_v n1_110282_304144 0 8.999999999613159e-08
iB00_1316_v n1_110282_300800 0 -2.549999999839573e-07
iB00_1317_v n1_132778_304144 0 2.3000000002964226e-07
iB00_1318_v n1_132778_300800 0 -7.000000000997907e-08
iB00_1319_v n1_110282_297456 0 -1.9000000002387943e-07
iB00_1320_v n1_110282_294112 0 2.999999999667765e-07
iB00_1321_v n1_132778_297456 0 1.5500000003117187e-07
iB00_1322_v n1_132778_294112 0 -1.0000000002181861e-07
iB00_1323_v n1_110282_290768 0 -2.79999999981471e-07
iB00_1324_v n1_110282_288590 0 0.064402
iB00_1325_v n1_132778_290768 0 -3.250000000024067e-07
iB00_1326_v n1_132778_288590 0 0.06440149999999996
iB00_1327_v n1_110282_287424 0 -4.7500000000697077e-07
iB00_1328_v n1_110282_284080 0 2.1500000000826414e-07
iB00_1329_v n1_132778_287424 0 3.7499999993814183e-07
iB00_1330_v n1_132778_284080 0 -1.3000000000824716e-07
iB00_1331_v n1_110282_280736 0 -1.3999999998353573e-07
iB00_1332_v n1_110282_277392 0 -3.500000002277723e-08
iB00_1333_v n1_132778_280736 0 -1.2000000000839464e-07
iB00_1334_v n1_132778_277392 0 -8.999999997156763e-08
iB00_1335_v n1_110282_274048 0 3.5000000013459865e-08
iB00_1336_v n1_110282_270704 0 5.4999999969966226e-08
iB00_1337_v n1_132778_274048 0 -5.499999999707128e-08
iB00_1338_v n1_132778_270704 0 -4.9999999723976895e-09
iB00_1339_v n1_110282_267360 0 5.0000000009427e-08
iB00_1340_v n1_110282_266702 0 0.06440150000000001
iB00_1341_v n1_132778_267360 0 5.999999997709227e-08
iB00_1342_v n1_132778_266702 0 0.06440199999999995
iB00_1343_v n1_110282_264016 0 -4.500000000314799e-08
iB00_1344_v n1_110282_260672 0 6.000000003130238e-08
iB00_1345_v n1_132778_264016 0 -1.000000001425208e-08
iB00_1346_v n1_132778_260672 0 -3.449999999902533e-07
iB00_1347_v n1_110282_257328 0 1.3499999998657408e-07
iB00_1348_v n1_110282_253984 0 -3.3499999996244867e-07
iB00_1349_v n1_132778_257328 0 3.250000000024067e-07
iB00_1350_v n1_132778_253984 0 1.9999999989540646e-08
iB00_1351_v n1_110282_250640 0 1.6999999997631703e-07
iB00_1352_v n1_110282_247296 0 1.3500000005687782e-07
iB00_1353_v n1_132778_250640 0 -2.699999999511253e-07
iB00_1354_v n1_132778_247296 0 -3.500000007529327e-08
iB00_1355_v n1_110282_244814 0 0.06440149999999996
iB00_1356_v n1_110282_243952 0 -2.1999999998828512e-07
iB00_1357_v n1_132778_244814 0 0.06440200000000008
iB00_1358_v n1_132778_243952 0 1.999999999377581e-07
iB00_1359_v n1_110282_240608 0 5.499999993015568e-08
iB00_1360_v n1_110282_237264 0 -1.9499999992554987e-07
iB00_1361_v n1_132778_240608 0 -1.5999999990277264e-07
iB00_1362_v n1_132778_237264 0 3.999999999602195e-08
iB00_1363_v n1_110282_233920 0 2.5000000012760312e-08
iB00_1364_v n1_110282_230576 0 2.249999999683061e-07
iB00_1365_v n1_132778_233920 0 -2.5000000003104136e-07
iB00_1366_v n1_132778_230576 0 -1.500000001544889e-08
iB00_1367_v n1_110282_227232 0 -1.2500000001128552e-07
iB00_1368_v n1_110282_223888 0 5.999999997709227e-08
iB00_1369_v n1_132778_227232 0 2.9999999999388155e-07
iB00_1370_v n1_132778_223888 0 1.000000000756052e-07
iB00_1371_v n1_110282_222318 0 0.06440200000000003
iB00_1372_v n1_110282_220544 0 2.2500000007672633e-07
iB00_1373_v n1_132778_222318 0 0.06440100000000001
iB00_1374_v n1_132778_220544 0 -1.0000000000445444e-07
iB00_1375_v n1_110282_217200 0 -1.020000000034932e-06
iB00_1376_v n1_110282_213856 0 2.699999999944934e-06
iB00_1377_v n1_132778_217200 0 2.9999999993967144e-07
iB00_1378_v n1_132778_213856 0 -1.4999999995713023e-07
iB00_1379_v n1_110282_210512 0 -3.600000000045163e-06
iB00_1380_v n1_110282_207168 0 1.5000000005115088e-07
iB00_1381_v n1_132778_210512 0 0.0
iB00_1382_v n1_132778_207168 0 1.9999999991488821e-07
iB00_1383_v n1_110282_203824 0 -1.0500000000844645e-06
iB00_1384_v n1_110282_200480 0 2.7500000000704045e-06
iB00_1385_v n1_132778_203824 0 5.0000000017050295e-08
iB00_1386_v n1_132778_200480 0 6.013933925505532e-17
iB00_1387_v n1_110282_200430 0 0.0644
iB00_1388_v n1_110282_197136 0 -2.4999999997683126e-07
iB00_1389_v n1_132778_200430 0 0.0644
iB00_1390_v n1_132778_197136 0 3.900000000040739e-06
iB00_1391_v n1_110282_193792 0 1.8999999999541912e-06
iB00_1392_v n1_110282_190448 0 -8.500000000730146e-07
iB00_1393_v n1_132778_193792 0 -4.499999999366122e-07
iB00_1394_v n1_132778_190448 0 3.999999999915597e-07
iB00_1395_v n1_110282_187104 0 1.4500000000819535e-06
iB00_1396_v n1_110282_183760 0 -9.99999999907325e-07
iB00_1397_v n1_132778_187104 0 -3.5499999999095283e-06
iB00_1398_v n1_132778_183760 0 2.649999999910943e-06
iB00_1399_v n1_110282_180416 0 1.599999999992497e-06
iB00_1400_v n1_110282_177934 0 0.06439849999999997
iB00_1401_v n1_132778_180416 0 -7.999999998391238e-07
iB00_1402_v n1_132778_177934 0 0.06440299999999982
iB00_1403_v n1_110282_177072 0 2.2999999999635386e-06
iB00_1404_v n1_110282_173728 0 -3.450000000092268e-06
iB00_1405_v n1_132778_177072 0 -1.0842021724855044e-16
iB00_1406_v n1_132778_173728 0 -2.299999999925422e-06
iB00_1407_v n1_110282_170384 0 1.100000000131161e-06
iB00_1408_v n1_110282_167040 0 9.499999999986949e-07
iB00_1409_v n1_132778_170384 0 7.499999999304938e-07
iB00_1410_v n1_132778_167040 0 -9.000000001679919e-07
iB00_1411_v n1_110282_163696 0 1.0999999999736129e-06
iB00_1412_v n1_110282_160352 0 -3.299999999932697e-06
iB00_1413_v n1_132778_163696 0 2.900000000013135e-06
iB00_1414_v n1_132778_160352 0 -2.8999999999470666e-06
iB00_1415_v n1_110282_157008 0 2.6499999999228015e-06
iB00_1416_v n1_110282_156046 0 0.06440099999999996
iB00_1417_v n1_132778_157008 0 1.8499999999803396e-06
iB00_1418_v n1_132778_156046 0 0.06439500000000008
iB00_1419_v n1_110282_153664 0 -6.500000000065075e-07
iB00_1420_v n1_110282_150320 0 -2.9999999999388155e-07
iB00_1421_v n1_132778_153664 0 2.7500000001788247e-06
iB00_1422_v n1_132778_150320 0 -2.400000000018815e-06
iB00_1423_v n1_110282_146976 0 7.000000000845441e-07
iB00_1424_v n1_110282_143632 0 2.499999999985153e-06
iB00_1425_v n1_132778_146976 0 3.099999999972916e-06
iB00_1426_v n1_132778_143632 0 -7.000000000997907e-07
iB00_1427_v n1_110282_140288 0 1.4999999998677638e-07
iB00_1428_v n1_110282_136944 0 -1.1999999999755262e-06
iB00_1429_v n1_132778_140288 0 1.1999999999755262e-06
iB00_1430_v n1_132778_136944 0 -1.0999999998584164e-06
iB00_1431_v n1_110282_133600 0 -1.5500000000796317e-06
iB00_1432_v n1_110282_133550 0 0.06440000000000004
iB00_1433_v n1_132778_133600 0 -2.500000000093573e-06
iB00_1434_v n1_132778_133550 0 0.06440500000000013
iB00_1435_v n1_110282_130256 0 -1.9000000001075042e-06
iB00_1436_v n1_110282_126912 0 4.999999990863008e-08
iB00_1437_v n1_132778_130256 0 1.4999999998609875e-06
iB00_1438_v n1_132778_126912 0 -2.7499999999111623e-06
iB00_1439_v n1_110282_123568 0 3.5000000000568024e-06
iB00_1440_v n1_110282_120224 0 -1.4000000000437274e-06
iB00_1441_v n1_132778_123568 0 4.049999999971611e-06
iB00_1442_v n1_132778_120224 0 -3.049999999940619e-06
iB00_1443_v n1_132778_116880 0 1.049999999815955e-06
iB00_1444_v n1_154970_116880 0 2.2499999998999015e-06
iB00_1445_v n1_154970_120224 0 -1.5000000005115088e-07
iB00_1446_v n1_177466_120224 0 -5.000000003060282e-08
iB00_1447_v n1_154970_123568 0 -2.3999999999832397e-06
iB00_1448_v n1_154970_126912 0 6.000000000961833e-07
iB00_1449_v n1_177466_123568 0 2.0000000001399107e-07
iB00_1450_v n1_177466_126912 0 -4.9999999962840186e-08
iB00_1451_v n1_154970_130256 0 -1.250000000004435e-06
iB00_1452_v n1_154970_133550 0 0.06439999999999994
iB00_1453_v n1_177466_130256 0 2.0000000001399107e-07
iB00_1454_v n1_177466_133550 0 0.07593750000000005
iB00_1455_v n1_154970_133600 0 2.6000000000192536e-06
iB00_1456_v n1_154970_136944 0 -2.0500000000485408e-06
iB00_1457_v n1_177466_133600 0 1.4999999999694077e-07
iB00_1458_v n1_177466_136944 0 -2.4999999996666686e-07
iB00_1459_v n1_154970_140288 0 3.450000000007565e-06
iB00_1460_v n1_154970_143632 0 -1.0000000000157452e-06
iB00_1461_v n1_177466_140288 0 3.4999999995672174e-07
iB00_1462_v n1_177466_143632 0 -1.0164395367051604e-17
iB00_1463_v n1_154970_146976 0 -3.4999999997535646e-07
iB00_1464_v n1_154970_150320 0 2.9999999999388155e-07
iB00_1465_v n1_177466_146976 0 -3.4999999995672174e-07
iB00_1466_v n1_177466_150320 0 2.4999999999716005e-07
iB00_1467_v n1_154970_153664 0 9.000000000104438e-07
iB00_1468_v n1_154970_156046 0 0.06440500000000002
iB00_1469_v n1_177466_153664 0 -1.0000000003410059e-07
iB00_1470_v n1_177466_156046 0 0.07499949999999997
iB00_1471_v n1_154970_157008 0 -8.99999999990115e-07
iB00_1472_v n1_154970_160352 0 1.0499999999243753e-06
iB00_1473_v n1_177466_157008 0 -1.5000000005115088e-07
iB00_1474_v n1_177466_160352 0 2.0000000005126052e-07
iB00_1475_v n1_154970_163696 0 -2.050000000109527e-06
iB00_1476_v n1_154970_167040 0 -2.4999999986841104e-07
iB00_1477_v n1_177466_163696 0 -4.9999999962840186e-08
iB00_1478_v n1_177466_167040 0 1.4999999996475352e-07
iB00_1479_v n1_154970_170384 0 1.4500000000658599e-06
iB00_1480_v n1_154970_173728 0 -1.9500000001228604e-06
iB00_1481_v n1_177466_170384 0 -1.9999999995978096e-07
iB00_1482_v n1_177466_173728 0 -2.0000000007243634e-07
iB00_1483_v n1_154970_177072 0 -4.99999999838466e-07
iB00_1484_v n1_154970_177934 0 0.06440250000000003
iB00_1485_v n1_177466_177072 0 2.4999999997683126e-07
iB00_1486_v n1_177466_177934 0 0.07418450000000004
iB00_1487_v n1_154970_180416 0 1.9999999998180382e-07
iB00_1488_v n1_154970_183760 0 -2.0000000001399107e-07
iB00_1489_v n1_177466_180416 0 -2.4999999997683126e-07
iB00_1490_v n1_177466_183760 0 1.0000000003579465e-07
iB00_1491_v n1_154970_187104 0 1.5000000000879924e-07
iB00_1492_v n1_154970_190448 0 -2.0000000001399107e-07
iB00_1493_v n1_177466_187104 0 -2.0000000006820118e-07
iB00_1494_v n1_177466_190448 0 2.999999999955756e-07
iB00_1495_v n1_154970_193792 0 3.0000000005063276e-07
iB00_1496_v n1_154970_197136 0 4.9999999962840186e-08
iB00_1497_v n1_177466_193792 0 4.9999999962840186e-08
iB00_1498_v n1_177466_197136 0 -4.999999996029909e-08
iB00_1499_v n1_154970_200430 0 0.06440100000000001
iB00_1500_v n1_154970_200480 0 3.0000000004809166e-07
iB00_1501_v n1_177466_200430 0 0.07375699999999998
iB00_1502_v n1_177466_200480 0 2.4999999999207785e-07
iB00_1503_v n1_154970_203824 0 -4.500000000187744e-07
iB00_1504_v n1_154970_207168 0 9.999999997989048e-08
iB00_1505_v n1_177466_203824 0 -2.4999999992262115e-07
iB00_1506_v n1_177466_207168 0 -1.5000000000710517e-07
iB00_1507_v n1_154970_210512 0 3.5000000000076745e-07
iB00_1508_v n1_154970_213856 0 -1.0000000003410059e-07
iB00_1509_v n1_177466_210512 0 1.4999999999694077e-07
iB00_1510_v n1_177466_213856 0 5.000000003568502e-08
iB00_1511_v n1_154970_217200 0 -2.999999999854112e-07
iB00_1512_v n1_154970_220544 0 1.4999999999694077e-07
iB00_1513_v n1_177466_217200 0 4.9999999962840186e-08
iB00_1514_v n1_177466_220544 0 -2.9999999994560067e-07
iB00_1515_v n1_154970_222318 0 0.06440199999999992
iB00_1516_v n1_154970_223888 0 9.999999997989048e-08
iB00_1517_v n1_177466_222318 0 0.07283250000000001
iB00_1518_v n1_177466_223888 0 2.500000000428998e-07
iB00_1519_v n1_154970_227232 0 -1.500000000181166e-07
iB00_1520_v n1_154970_230576 0 -1.4999999999694077e-07
iB00_1521_v n1_177466_227232 0 9.999999997989048e-08
iB00_1522_v n1_177466_230576 0 -4.0000000001273555e-07
iB00_1523_v n1_154970_233920 0 -4.99999999992626e-08
iB00_1524_v n1_154970_237264 0 2.4999999997683126e-07
iB00_1525_v n1_177466_233920 0 2.9999999993967144e-07
iB00_1526_v n1_177466_237264 0 1.850000000425879e-07
iB00_1527_v n1_154970_240608 0 -2.599999999648253e-07
iB00_1528_v n1_154970_243952 0 2.8999999997962947e-07
iB00_1529_v n1_177466_240608 0 -2.800000000195875e-07
iB00_1530_v n1_177466_243952 0 3.218725199566341e-17
iB00_1531_v n1_154970_244814 0 0.06440099999999996
iB00_1532_v n1_154970_247296 0 2.1000000002824315e-07
iB00_1533_v n1_177466_244814 0 0.07518799999999996
iB00_1534_v n1_177466_247296 0 -8.499999996782972e-08
iB00_1535_v n1_154970_250640 0 5.99999999753982e-08
iB00_1536_v n1_154970_253984 0 5.421010862427522e-17
iB00_1537_v n1_177466_250640 0 -2.9500000001386056e-07
iB00_1538_v n1_177466_253984 0 2.3000000002371303e-07
iB00_1539_v n1_154970_257328 0 4.4999999961643376e-08
iB00_1540_v n1_154970_260672 0 -3.199999999681756e-07
iB00_1541_v n1_177466_257328 0 -2.000000002850416e-08
iB00_1542_v n1_177466_260672 0 -4.000000003413843e-08
iB00_1543_v n1_154970_264016 0 -9.00000000300129e-08
iB00_1544_v n1_154970_266702 0 0.06440149999999996
iB00_1545_v n1_177466_264016 0 1.7500000000546592e-07
iB00_1546_v n1_177466_266702 0 0.07501849999999997
iB00_1547_v n1_154970_267360 0 -1.8499999997990745e-07
iB00_1548_v n1_154970_270704 0 2.700000000053354e-07
iB00_1549_v n1_177466_267360 0 -1.4499999998981473e-07
iB00_1550_v n1_177466_270704 0 1.8000000001513306e-07
iB00_1551_v n1_154970_274048 0 -1.8499999999600108e-07
iB00_1552_v n1_154970_277392 0 -2.999999998854613e-08
iB00_1553_v n1_177466_274048 0 2.1500000000826414e-07
iB00_1554_v n1_177466_277392 0 -6.000000002283205e-08
iB00_1555_v n1_154970_280736 0 2.399999999913783e-07
iB00_1556_v n1_154970_284080 0 -3.650000000052049e-07
iB00_1557_v n1_177466_280736 0 -1.6000000001119286e-07
iB00_1558_v n1_177466_284080 0 -1.1500000004107915e-07
iB00_1559_v n1_154970_287424 0 1.6499999999460197e-07
iB00_1560_v n1_154970_288590 0 0.06440150000000004
iB00_1561_v n1_177466_287424 0 6.500000001132336e-08
iB00_1562_v n1_177466_288590 0 0.073824
iB00_1563_v n1_154970_290768 0 -3.899999999679903e-07
iB00_1564_v n1_154970_294112 0 2.300000000025372e-07
iB00_1565_v n1_177466_290768 0 3.1999999999528066e-07
iB00_1566_v n1_177466_294112 0 1.000000001679318e-08
iB00_1567_v n1_154970_297456 0 1.5000000002743396e-08
iB00_1568_v n1_154970_300800 0 -2.5000000008525147e-08
iB00_1569_v n1_177466_297456 0 -1.8000000001259196e-07
iB00_1570_v n1_177466_300800 0 -2.2000000001454314e-07
iB00_1571_v n1_154970_304144 0 1.3000000001502343e-07
iB00_1572_v n1_154970_307488 0 -4.999999980020986e-09
iB00_1573_v n1_177466_304144 0 3.800000000130305e-07
iB00_1574_v n1_177466_307488 0 -3.5499999999434096e-07
iB00_1575_v n1_154970_310832 0 6.499999999014754e-08
iB00_1576_v n1_154970_311086 0 0.076018
iB00_1577_v n1_177466_310832 0 9.500000001342202e-08
iB00_1578_v n1_177466_311086 0 0.08034089999999999
iB00_1579_v n1_154970_314176 0 -1.449999999940499e-07
iB00_1580_v n1_154970_317520 0 2.0999999998758557e-07
iB00_1581_v n1_177466_314176 0 1.4999999994273067e-08
iB00_1582_v n1_177466_317520 0 1.999999999843449e-08
iB00_1583_v n1_154970_320864 0 -2.1499999999259403e-07
iB00_1584_v n1_154970_324208 0 7.999999999882016e-08
iB00_1585_v n1_177466_320864 0 -1.9999999994622843e-08
iB00_1586_v n1_177466_324208 0 4.2351647362715017e-19
iB00_1587_v n1_154970_327552 0 1.450000000016732e-07
iB00_1588_v n1_154970_330896 0 -2.5000000008525147e-08
iB00_1589_v n1_177466_327552 0 -1.500000000104933e-08
iB00_1590_v n1_177466_330896 0 5.000000000349777e-09
iB00_1591_v n1_154970_332974 0 0.07741730000000002
iB00_1592_v n1_154970_334240 0 -5.000000000349777e-09
iB00_1593_v n1_177466_332974 0 0.08241694999999999
iB00_1594_v n1_177466_334240 0 1.4999999996814165e-08
iB00_1595_v n1_154970_337584 0 -4.999999998655711e-09
iB00_1596_v n1_154970_340928 0 5.000000000349777e-09
iB00_1597_v n1_177466_337584 0 -3.999999999602195e-08
iB00_1598_v n1_177466_340928 0 5.000000002467359e-09
iB00_1599_v n1_154970_344272 0 -3.000000000336921e-08
iB00_1600_v n1_154970_347616 0 4.500000000314799e-08
iB00_1601_v n1_177466_344272 0 1.0000000000699553e-08
iB00_1602_v n1_177466_347616 0 -1.4999999998084715e-08
iB00_1603_v n1_154970_350960 0 -2.541098841762901e-18
iB00_1604_v n1_154970_354304 0 -4.999999993573513e-09
iB00_1605_v n1_177466_350960 0 0.0
iB00_1606_v n1_177466_354304 0 2.499999999878427e-08
iB00_1607_v n1_154970_355470 0 0.08322625
iB00_1608_v n1_154970_357648 0 -1.000000001425208e-08
iB00_1609_v n1_177466_355470 0 0.08129475000000004
iB00_1610_v n1_177466_357648 0 -3.099999999941576e-07
iB00_1611_v n1_154970_360992 0 -8.000000000136126e-08
iB00_1612_v n1_154970_364336 0 2.9000000002028705e-07
iB00_1613_v n1_177466_360992 0 -7.499999999847039e-08
iB00_1614_v n1_177466_364336 0 1.6999999999156362e-07
iB00_1615_v n1_154970_367680 0 6.999999999642654e-08
iB00_1616_v n1_154970_371024 0 -2.7500000001246146e-07
iB00_1617_v n1_177466_367680 0 -6.500000001132336e-08
iB00_1618_v n1_177466_371024 0 2.25000000004305e-07
iB00_1619_v n1_154970_374368 0 2.2999999998898468e-07
iB00_1620_v n1_154970_377358 0 0.066592
iB00_1621_v n1_177466_374368 0 3.50000000092247e-08
iB00_1622_v n1_177466_377358 0 0.07304099999999995
iB00_1623_v n1_154970_377712 0 2.500000000344295e-08
iB00_1624_v n1_154970_381056 0 1.4000000000979375e-07
iB00_1625_v n1_177466_377712 0 -3.099999999810286e-07
iB00_1626_v n1_177466_381056 0 1.4999999984955704e-08
iB00_1627_v n1_154970_384400 0 2.999999997922877e-08
iB00_1628_v n1_154970_387744 0 1.6000000001119286e-07
iB00_1629_v n1_177466_384400 0 -1.2000000000839464e-07
iB00_1630_v n1_177466_387744 0 2.9000000000758156e-07
iB00_1631_v n1_154970_391088 0 2.500000002377174e-08
iB00_1632_v n1_154970_394432 0 -3.950000000208561e-07
iB00_1633_v n1_177466_391088 0 -2.5000000003104136e-07
iB00_1634_v n1_177466_394432 0 2.700000000078765e-07
iB00_1635_v n1_154970_397776 0 3.7500000001013963e-07
iB00_1636_v n1_154970_399854 0 0.06440149999999996
iB00_1637_v n1_177466_397776 0 -1.450000000169198e-07
iB00_1638_v n1_177466_399854 0 0.07415700000000004
iB00_1639_v n1_154970_401120 0 -3.700000000470593e-07
iB00_1640_v n1_154970_404464 0 1.6000000001119286e-07
iB00_1641_v n1_177466_401120 0 2.900000000067345e-07
iB00_1642_v n1_177466_404464 0 -2.449999999866459e-07
iB00_1643_v n1_154970_407808 0 -1.4999999999355264e-07
iB00_1644_v n1_154970_411152 0 2.0499999999401206e-07
iB00_1645_v n1_177466_407808 0 -1.9500000000686503e-07
iB00_1646_v n1_177466_411152 0 4.3999999996894695e-07
iB00_1647_v n1_154970_414496 0 -2.699999999790774e-07
iB00_1648_v n1_154970_417840 0 4.2499999992808707e-07
iB00_1649_v n1_177466_414496 0 -3.4499999997670075e-07
iB00_1650_v n1_177466_417840 0 -4.0000000025668103e-08
iB00_1651_v n1_154970_421184 0 -2.0999999999436183e-07
iB00_1652_v n1_154970_421742 0 0.06440150000000001
iB00_1653_v n1_177466_421184 0 3.550000000180579e-07
iB00_1654_v n1_177466_421742 0 0.07313649999999997
iB00_1655_v n1_154970_424528 0 -3.50000000117658e-08
iB00_1656_v n1_154970_427872 0 -2.4999999997683126e-07
iB00_1657_v n1_177466_424528 0 2.900000000338396e-07
iB00_1658_v n1_177466_427872 0 1.1999999997705442e-07
iB00_1659_v n1_154970_431216 0 1.9999999999366228e-07
iB00_1660_v n1_154970_434560 0 -1.4999999999694077e-07
iB00_1661_v n1_177466_431216 0 -4.150000000222552e-07
iB00_1662_v n1_177466_434560 0 1.4999999997576495e-07
iB00_1663_v n1_154970_437904 0 1.5000000001472847e-07
iB00_1664_v n1_154970_441248 0 1.4999999999694077e-07
iB00_1665_v n1_177466_437904 0 -9.999999997989048e-08
iB00_1666_v n1_177466_441248 0 3.0000000001929254e-07
iB00_1667_v n1_154970_444238 0 0.06440150000000001
iB00_1668_v n1_154970_444592 0 2.0000000001399107e-07
iB00_1669_v n1_177466_444238 0 0.07391699999999995
iB00_1670_v n1_177466_444592 0 1.9999999995385173e-07
iB00_1671_v n1_154970_447936 0 -2.00000000037708e-07
iB00_1672_v n1_154970_451280 0 5.0000000017050295e-08
iB00_1673_v n1_177466_447936 0 -5.0000000017050295e-08
iB00_1674_v n1_177466_451280 0 -5.00000000068859e-08
iB00_1675_v n1_154970_454624 0 9.99999999959841e-08
iB00_1676_v n1_154970_457968 0 -2.0000000001399107e-07
iB00_1677_v n1_177466_454624 0 1.0000000003410059e-07
iB00_1678_v n1_177466_457968 0 -5.000000000095667e-08
iB00_1679_v n1_154970_461312 0 -2.000000000173792e-07
iB00_1680_v n1_154970_464656 0 5.0000000017050295e-08
iB00_1681_v n1_177466_461312 0 -5.0000000017050295e-08
iB00_1682_v n1_177466_464656 0 1.000000000061485e-07
iB00_1683_v n1_154970_466126 0 0.06440200000000003
iB00_1684_v n1_154970_468000 0 4.9999999962840186e-08
iB00_1685_v n1_177466_466126 0 0.073136
iB00_1686_v n1_177466_468000 0 2.0000000001399107e-07
iB00_1687_v n1_154970_471344 0 1.0000000001038367e-07
iB00_1688_v n1_154970_474688 0 0.0
iB00_1689_v n1_177466_471344 0 5.0000000017050295e-08
iB00_1690_v n1_177466_474688 0 4.999999996114612e-08
iB00_1691_v n1_154970_478032 0 -3.5000000003973096e-07
iB00_1692_v n1_154970_481376 0 1.5000000005115088e-07
iB00_1693_v n1_177466_478032 0 -1.9999999995978096e-07
iB00_1694_v n1_177466_481376 0 2.00000000012297e-07
iB00_1695_v n1_154970_484720 0 -5.0000000011121064e-08
iB00_1696_v n1_154970_488064 0 1.0000000003410059e-07
iB00_1697_v n1_177466_484720 0 -1.0000000003410059e-07
iB00_1698_v n1_177466_488064 0 -1.500000000155755e-07
iB00_1699_v n1_154970_488622 0 0.06439949999999993
iB00_1700_v n1_154970_491408 0 2.700000000053354e-06
iB00_1701_v n1_177466_488622 0 0.07387100000000009
iB00_1702_v n1_177466_491408 0 5.0000000034837986e-08
iB00_1703_v n1_154970_494752 0 -4.500000001415942e-07
iB00_1704_v n1_154970_498096 0 1.4000000000437274e-06
iB00_1705_v n1_177466_494752 0 -1.0000000003410059e-07
iB00_1706_v n1_177466_498096 0 8.470329472543003e-18
iB00_1707_v n1_154970_501440 0 -1.849999999914271e-06
iB00_1708_v n1_154970_504784 0 -1.9999999995978096e-07
iB00_1709_v n1_177466_501440 0 -9.999999997989048e-08
iB00_1710_v n1_177466_504784 0 1.00000000018854e-07
iB00_1711_v n1_154970_508128 0 1.4499999999591337e-06
iB00_1712_v n1_154970_510510 0 0.064404
iB00_1713_v n1_177466_508128 0 1.4999999999694077e-07
iB00_1714_v n1_177466_510510 0 0.07369549999999998
iB00_1715_v n1_154970_511472 0 -4.549999999959155e-06
iB00_1716_v n1_154970_514816 0 2.5999999999108334e-06
iB00_1717_v n1_177466_511472 0 -5.0000000017050295e-08
iB00_1718_v n1_177466_514816 0 1.0000000003071246e-07
iB00_1719_v n1_154970_518160 0 -2.0000000000552074e-07
iB00_1720_v n1_154970_521504 0 2.099999999957171e-06
iB00_1721_v n1_177466_518160 0 9.999999992568037e-08
iB00_1722_v n1_177466_521504 0 -9.99999999290685e-08
iB00_1723_v n1_154970_524848 0 -5.000000000231192e-07
iB00_1724_v n1_154970_528192 0 -2.900000000013135e-06
iB00_1725_v n1_177466_524848 0 -5.421010862427522e-17
iB00_1726_v n1_177466_528192 0 -4.9999999922182604e-08
iB00_1727_v n1_154970_531536 0 -9.999999993245664e-08
iB00_1728_v n1_154970_532398 0 0.06439999999999983
iB00_1729_v n1_177466_531536 0 2.0000000001399107e-07
iB00_1730_v n1_177466_532398 0 0.07162749999999984
iB00_1731_v n1_154970_534880 0 2.050000000029906e-06
iB00_1732_v n1_154970_538224 0 -2.1500000001910616e-06
iB00_1733_v n1_177466_534880 0 -4.499999999908223e-07
iB00_1734_v n1_177466_538224 0 4.5000000000945705e-07
iB00_1735_v n1_154970_541568 0 -1.1499999998974895e-06
iB00_1736_v n1_154970_544912 0 2.0000000006820118e-07
iB00_1737_v n1_177466_541568 0 -2.5000000003104136e-07
iB00_1738_v n1_177466_544912 0 -1.4999999996814165e-07
iB00_1739_v n1_154970_548256 0 1.7499999999326865e-06
iB00_1740_v n1_154970_551600 0 -1.3499999999182569e-06
iB00_1741_v n1_177466_548256 0 2.9999999993967144e-07
iB00_1742_v n1_177466_551600 0 -3.99999999921256e-07
iB00_1743_v n1_154970_554894 0 0.0644049999999998
iB00_1744_v n1_154970_554944 0 -3.5999999998181584e-06
iB00_1745_v n1_177466_554894 0 0.07304100000000015
iB00_1746_v n1_177466_554944 0 5.082197683525802e-18
iB00_1747_v n1_154970_558288 0 3.4499999999414963e-06
iB00_1748_v n1_154970_561632 0 8.499999999645944e-07
iB00_1749_v n1_177466_558288 0 1.4999999999694077e-07
iB00_1750_v n1_177466_561632 0 -4.499999999213656e-07
iB00_1751_v n1_154970_564976 0 -1.6000000001356455e-06
iB00_1752_v n1_154970_568320 0 1.2000000001923666e-06
iB00_1753_v n1_177466_564976 0 3.4999999995672174e-07
iB00_1754_v n1_177466_568320 0 -5.000000002382656e-08
iB00_1755_v n1_154970_571664 0 -8.500000000154163e-07
iB00_1756_v n1_154970_575008 0 -2.699999999944934e-06
iB00_1757_v n1_177466_571664 0 -2.4999999992262115e-07
iB00_1758_v n1_177466_575008 0 2.4999999994803214e-07
iB00_1759_v n1_154970_576782 0 0.0644005
iB00_1760_v n1_154970_578352 0 5.000000000620827e-07
iB00_1761_v n1_177466_576782 0 0.07410299999999984
iB00_1762_v n1_177466_578352 0 5.0000000000109636e-08
iB00_1763_v n1_154970_581696 0 -1.0000000006120564e-07
iB00_1764_v n1_154970_585040 0 -2.4999999997683126e-07
iB00_1765_v n1_177466_581696 0 2.4999999997683126e-07
iB00_1766_v n1_177466_585040 0 2.879912020664621e-17
iB00_1767_v n1_154970_588384 0 -1.0000000003748872e-07
iB00_1768_v n1_154970_591728 0 2.0000000001399107e-07
iB00_1769_v n1_177466_588384 0 -2.9999999999388155e-07
iB00_1770_v n1_177466_591728 0 3.999999999957949e-07
iB00_1771_v n1_154970_595072 0 4.9999999962840186e-08
iB00_1772_v n1_154970_598416 0 -2.9999999999388155e-07
iB00_1773_v n1_177466_595072 0 -1.4999999999694077e-07
iB00_1774_v n1_177466_598416 0 1.5000000000879924e-07
iB00_1775_v n1_154970_599278 0 0.06700200000000003
iB00_1776_v n1_154970_601760 0 -9.999999997989048e-08
iB00_1777_v n1_177466_599278 0 0.07860699999999995
iB00_1778_v n1_177466_601760 0 3.5000000001093184e-07
iB00_1779_v n1_154970_605104 0 -5.000000002382656e-08
iB00_1780_v n1_177466_605104 0 -1.5000000000202297e-07
iB00_1781_v n1_199658_605104 0 2.9999999999388155e-07
iB00_1782_v n1_221850_605104 0 -1.0000000001038367e-07
iB00_1783_v n1_199658_601760 0 -5.0000000017050295e-08
iB00_1784_v n1_221850_601760 0 2.0000000002923766e-07
iB00_1785_v n1_244346_605104 0 -5.0000000017050295e-08
iB00_1786_v n1_266538_605104 0 -5.500000001740007e-08
iB00_1787_v n1_244346_601760 0 2.0000000001399107e-07
iB00_1788_v n1_266538_601760 0 6.500000002064072e-08
iB00_1789_v n1_289034_605104 0 7.499999999847039e-08
iB00_1790_v n1_311226_605104 0 9.999999997459652e-08
iB00_1791_v n1_289034_601760 0 -3.1000000000813363e-07
iB00_1792_v n1_311226_601760 0 -1.399999999928531e-07
iB00_1793_v n1_333722_605104 0 2.300000000025372e-07
iB00_1794_v n1_355914_605104 0 5.999999998429205e-08
iB00_1795_v n1_333722_601760 0 -2.50000000356302e-08
iB00_1796_v n1_355914_601760 0 -1.699999999759994e-07
iB00_1797_v n1_378410_605104 0 -7.499999999847039e-08
iB00_1798_v n1_400602_605104 0 6.499999997828908e-08
iB00_1799_v n1_378410_601760 0 3.89999999986625e-07
iB00_1800_v n1_400602_601760 0 2.399999999812139e-07
iB00_1801_v n1_422794_605104 0 -2.5000000003104136e-07
iB00_1802_v n1_445290_605104 0 5.00000000068859e-08
iB00_1803_v n1_422794_601760 0 2.710505431213761e-17
iB00_1804_v n1_445290_601760 0 1.5000000000879924e-07
iB00_1805_v n1_467482_605104 0 2.0000000001399107e-07
iB00_1806_v n1_489978_605104 0 4.999999998994524e-08
iB00_1807_v n1_467482_601760 0 -1.4999999999694077e-07
iB00_1808_v n1_489978_601760 0 1.8634724839594607e-17
iB00_1809_v n1_512170_605104 0 1.9999999995978096e-07
iB00_1810_v n1_534666_605104 0 -5.0000000091589194e-08
iB00_1811_v n1_512170_601760 0 -9.999999992568037e-08
iB00_1812_v n1_534666_601760 0 2.000000000817537e-07
iB00_1813_v n1_556858_605104 0 -4.099999999988661e-06
iB00_1814_v n1_579050_605104 0 1.9999999998688602e-07
iB00_1815_v n1_556858_601760 0 1.0000000001241655e-06
iB00_1816_v n1_579050_601760 0 -1.1500000001278825e-06
iB00_1817_v n1_601546_605104 0 -9.499999992397534e-07
iB00_1818_v n1_623064_605104 0 -3.3881317890172014e-18
iB00_1819_v n1_601546_601760 0 -1.500000007016722e-07
iB00_1820_v n1_623064_608448 0 -3.3881317890172014e-18
iB00_1821_v n1_625064_608448 0 6.999999998917594e-06
iB00_1822_v n1_627064_608448 0 0.0
iB00_1823_v n1_625064_605104 0 -6.549999999573905e-06
iB00_1824_v n1_627064_611792 0 0.0
iB00_1825_v n1_625064_601760 0 1.604999999995049e-05
iB00_1826_v n1_627064_605104 0 0.0
iB00_1827_v n1_625064_599278 0 -1.4999999973543116e-05
iB00_1828_v n1_627064_601760 0 0.0
iB00_1829_v n1_623064_601760 0 0.0
iB00_1830_v n1_601546_599278 0 0.06830000000000008
iB00_1831_v n1_601546_598416 0 2.100000000058815e-06
iB00_1832_v n1_579050_599278 0 0.06570000000000036
iB00_1833_v n1_556858_599278 0 0.06736999999999976
iB00_1834_v n1_579050_598416 0 -1.6999999999291887e-06
iB00_1835_v n1_556858_598416 0 2.3999999999781575e-06
iB00_1836_v n1_534666_599278 0 0.06783100000000024
iB00_1837_v n1_512170_599278 0 0.07174949999999981
iB00_1838_v n1_534666_598416 0 3.5000000001093184e-07
iB00_1839_v n1_512170_598416 0 -1.0000000000021927e-07
iB00_1840_v n1_489978_599278 0 0.09068749999999995
iB00_1841_v n1_467482_599278 0 0.08774650000000016
iB00_1842_v n1_489978_598416 0 1.0000000003410059e-07
iB00_1843_v n1_467482_598416 0 2.9999999994305957e-07
iB00_1844_v n1_445290_599278 0 0.08817399999999992
iB00_1845_v n1_422794_599278 0 0.08894050000000009
iB00_1846_v n1_445290_598416 0 -2.500000000039363e-07
iB00_1847_v n1_422794_598416 0 2.0000000000552074e-07
iB00_1848_v n1_400602_599278 0 0.08986750000000002
iB00_1849_v n1_378410_599278 0 0.09014549999999998
iB00_1850_v n1_400602_598416 0 1.6000000001119286e-07
iB00_1851_v n1_378410_598416 0 -2.6499999999736234e-07
iB00_1852_v n1_355914_599278 0 0.08634984999999998
iB00_1853_v n1_333722_599278 0 0.08896665000000004
iB00_1854_v n1_355914_598416 0 2.1500000000826414e-07
iB00_1855_v n1_333722_598416 0 -2.600000000177649e-07
iB00_1856_v n1_311226_599278 0 0.08832049999999997
iB00_1857_v n1_289034_599278 0 0.08973999999999999
iB00_1858_v n1_311226_598416 0 -1.3499999997556265e-07
iB00_1859_v n1_289034_598416 0 -6.49999999867594e-08
iB00_1860_v n1_266538_599278 0 0.08851199999999998
iB00_1861_v n1_244346_599278 0 0.08923950000000003
iB00_1862_v n1_266538_598416 0 -2.5000000003104136e-07
iB00_1863_v n1_244346_598416 0 -1.000000000061485e-07
iB00_1864_v n1_221850_599278 0 0.0885615
iB00_1865_v n1_199658_599278 0 0.08839449999999995
iB00_1866_v n1_221850_598416 0 1.5000000001388143e-07
iB00_1867_v n1_199658_598416 0 -2.4999999997683126e-07
iB00_1868_v n1_199658_595072 0 3.4999999997027426e-07
iB00_1869_v n1_199658_591728 0 5.421010862427522e-17
iB00_1870_v n1_221850_595072 0 1.5000000002404583e-07
iB00_1871_v n1_221850_591728 0 -1.5000000003759836e-07
iB00_1872_v n1_199658_588384 0 -2.5000000002765323e-07
iB00_1873_v n1_199658_585040 0 5.0000000017050295e-08
iB00_1874_v n1_221850_588384 0 -9.999999997989048e-08
iB00_1875_v n1_221850_585040 0 -2.500000000141007e-07
iB00_1876_v n1_199658_581696 0 -1.5246593050577406e-17
iB00_1877_v n1_199658_578352 0 1.4999999999694077e-07
iB00_1878_v n1_221850_581696 0 5.0000000017050295e-08
iB00_1879_v n1_221850_578352 0 1.9999999999874448e-07
iB00_1880_v n1_199658_576782 0 0.08110050000000003
iB00_1881_v n1_199658_575008 0 -4.9999999962840186e-08
iB00_1882_v n1_221850_576782 0 0.08193850000000005
iB00_1883_v n1_221850_575008 0 2.500000000428998e-07
iB00_1884_v n1_199658_571664 0 1.0000000001207773e-07
iB00_1885_v n1_199658_568320 0 0.0
iB00_1886_v n1_221850_571664 0 1.0000000003410059e-07
iB00_1887_v n1_221850_568320 0 -3.5575383784680614e-17
iB00_1888_v n1_199658_564976 0 2.5000000000224224e-07
iB00_1889_v n1_199658_561632 0 -1.4999999999694077e-07
iB00_1890_v n1_221850_564976 0 -1.4999999999694077e-07
iB00_1891_v n1_221850_561632 0 9.99999999341507e-08
iB00_1892_v n1_199658_558288 0 -1.9999999998688602e-07
iB00_1893_v n1_199658_554944 0 1.4999999999694077e-07
iB00_1894_v n1_221850_558288 0 -9.999999992568037e-08
iB00_1895_v n1_221850_554944 0 1.9999999991912338e-07
iB00_1896_v n1_199658_554894 0 0.08048150000000004
iB00_1897_v n1_199658_551600 0 -5.00000000712604e-08
iB00_1898_v n1_221850_554894 0 0.08155449999999996
iB00_1899_v n1_221850_551600 0 -1.4999999997576495e-07
iB00_1900_v n1_199658_548256 0 -1.499999999562832e-07
iB00_1901_v n1_199658_544912 0 1.4999999999694077e-07
iB00_1902_v n1_221850_548256 0 5.0000000017050295e-08
iB00_1903_v n1_221850_544912 0 -1.5000000004268055e-07
iB00_1904_v n1_199658_541568 0 -3.218725199566341e-17
iB00_1905_v n1_199658_538224 0 -1.9999999995978096e-07
iB00_1906_v n1_221850_541568 0 2.0000000001399107e-07
iB00_1907_v n1_221850_538224 0 9.999999999513707e-08
iB00_1908_v n1_199658_534880 0 9.999999996633795e-08
iB00_1909_v n1_199658_532398 0 0.08092600000000004
iB00_1910_v n1_221850_534880 0 -3.5000000001093184e-07
iB00_1911_v n1_221850_532398 0 0.0819385
iB00_1912_v n1_199658_531536 0 -1.500000000257399e-07
iB00_1913_v n1_199658_528192 0 4.9999999962840186e-08
iB00_1914_v n1_221850_531536 0 0.0
iB00_1915_v n1_221850_528192 0 2.4999999999970114e-07
iB00_1916_v n1_199658_524848 0 3.000000000209866e-07
iB00_1917_v n1_199658_521504 0 4.9999999962840186e-08
iB00_1918_v n1_221850_524848 0 -3.4999999995672174e-07
iB00_1919_v n1_221850_521504 0 2.4999999996412576e-07
iB00_1920_v n1_199658_518160 0 -1.0000000003071246e-07
iB00_1921_v n1_199658_514816 0 -2.4999999992262115e-07
iB00_1922_v n1_221850_518160 0 -9.999999997989048e-08
iB00_1923_v n1_221850_514816 0 2.4999999997429016e-07
iB00_1924_v n1_199658_511472 0 2.0000000000043854e-07
iB00_1925_v n1_199658_510510 0 0.08124949999999993
iB00_1926_v n1_221850_511472 0 -3.5000000001093184e-07
iB00_1927_v n1_221850_510510 0 0.08122249999999995
iB00_1928_v n1_199658_508128 0 -3.4999999997196833e-07
iB00_1929_v n1_199658_504784 0 3.4999999995672174e-07
iB00_1930_v n1_221850_508128 0 1.4999999999694077e-07
iB00_1931_v n1_221850_504784 0 2.500000000428998e-07
iB00_1932_v n1_199658_501440 0 9.999999999005488e-08
iB00_1933_v n1_199658_498096 0 -9.999999997989048e-08
iB00_1934_v n1_221850_501440 0 -1.5000000005115088e-07
iB00_1935_v n1_221850_498096 0 1.5000000005623308e-07
iB00_1936_v n1_199658_494752 0 -1.9999999998265085e-07
iB00_1937_v n1_199658_491408 0 2.0000000001399107e-07
iB00_1938_v n1_221850_494752 0 -1.000000000883107e-07
iB00_1939_v n1_221850_491408 0 2.4999999998953675e-07
iB00_1940_v n1_199658_488622 0 0.08204350000000002
iB00_1941_v n1_199658_488064 0 0.0
iB00_1942_v n1_221850_488622 0 0.08038400000000008
iB00_1943_v n1_221850_488064 0 -2.0000000002330843e-07
iB00_1944_v n1_199658_484720 0 -4.999999998062788e-08
iB00_1945_v n1_199658_481376 0 -1.0000000003410059e-07
iB00_1946_v n1_221850_484720 0 -2.0000000006820118e-07
iB00_1947_v n1_221850_481376 0 3.500000000947881e-07
iB00_1948_v n1_199658_478032 0 3.9999999997970126e-07
iB00_1949_v n1_199658_474688 0 -4.5000000004503243e-07
iB00_1950_v n1_221850_478032 0 -1.450000000711299e-07
iB00_1951_v n1_221850_474688 0 -2.199999999899792e-07
iB00_1952_v n1_199658_471344 0 2.0000000005464865e-07
iB00_1953_v n1_199658_468000 0 -5.0000000017050295e-08
iB00_1954_v n1_221850_471344 0 2.0500000004822216e-07
iB00_1955_v n1_221850_468000 0 6.999999993289907e-08
iB00_1956_v n1_199658_466126 0 0.0815975000000001
iB00_1957_v n1_199658_464656 0 5.0000000017050295e-08
iB00_1958_v n1_221850_466126 0 0.08002649999999997
iB00_1959_v n1_221850_464656 0 8.99999999529329e-08
iB00_1960_v n1_199658_461312 0 -1.499999999664476e-07
iB00_1961_v n1_199658_457968 0 1.4999999994273067e-07
iB00_1962_v n1_221850_461312 0 4.500000003702931e-08
iB00_1963_v n1_221850_457968 0 2.117582368135751e-17
iB00_1964_v n1_199658_454624 0 4.404571325722362e-17
iB00_1965_v n1_199658_451280 0 -2.1999999998828512e-07
iB00_1966_v n1_221850_454624 0 -7.500000002557544e-08
iB00_1967_v n1_221850_451280 0 -9.00000000350951e-08
iB00_1968_v n1_199658_447936 0 2.0000000024268997e-08
iB00_1969_v n1_199658_444592 0 1.4499999996270968e-07
iB00_1970_v n1_221850_447936 0 -5.499999999707128e-08
iB00_1971_v n1_221850_444592 0 8.000000005472434e-08
iB00_1972_v n1_199658_444238 0 0.08054900000000006
iB00_1973_v n1_199658_441248 0 -1.9999999995978096e-07
iB00_1974_v n1_221850_444238 0 0.0814834999999999
iB00_1975_v n1_221850_441248 0 -1.9499999999500657e-07
iB00_1976_v n1_199658_437904 0 -7.499999995611874e-08
iB00_1977_v n1_199658_434560 0 -5.500000005128139e-08
iB00_1978_v n1_221850_437904 0 2.100000000011381e-07
iB00_1979_v n1_221850_434560 0 2.1999999999929655e-07
iB00_1980_v n1_199658_431216 0 -1.2000000005836959e-07
iB00_1981_v n1_199658_427872 0 2.2000000009670534e-07
iB00_1982_v n1_221850_431216 0 -1.599999999840878e-07
iB00_1983_v n1_221850_427872 0 6.000000002113798e-08
iB00_1984_v n1_199658_424528 0 -1.0000000021875377e-08
iB00_1985_v n1_199658_421742 0 0.08163349999999998
iB00_1986_v n1_221850_424528 0 -1.4000000000979375e-07
iB00_1987_v n1_221850_421742 0 0.08149350000000001
iB00_1988_v n1_199658_421184 0 -3.199999999918925e-07
iB00_1989_v n1_199658_417840 0 3.3000000000953274e-07
iB00_1990_v n1_221850_421184 0 -2.0000000001399107e-08
iB00_1991_v n1_221850_417840 0 3.350000000200469e-07
iB00_1992_v n1_199658_414496 0 -1.0500000002089784e-07
iB00_1993_v n1_199658_411152 0 -1.199999999812896e-07
iB00_1994_v n1_221850_414496 0 -2.400000000167893e-07
iB00_1995_v n1_221850_411152 0 2.5000000000478334e-07
iB00_1996_v n1_199658_407808 0 -2.250000000013404e-07
iB00_1997_v n1_199658_404464 0 6.499999998421831e-08
iB00_1998_v n1_221850_407808 0 -1.9500000003397008e-07
iB00_1999_v n1_221850_404464 0 -6.999999998710918e-08
iB00_2000_v n1_199658_401120 0 2.550000000305441e-07
iB00_2001_v n1_199658_399854 0 0.08247849999999998
iB00_2002_v n1_221850_401120 0 1.0000000000699553e-07
iB00_2003_v n1_221850_399854 0 0.0818085
iB00_2004_v n1_199658_397776 0 2.5499999999835686e-07
iB00_2005_v n1_199658_394432 0 -1.2999999999554167e-07
iB00_2006_v n1_221850_397776 0 1.6000000001119286e-07
iB00_2007_v n1_221850_394432 0 -1.1000000001616542e-07
iB00_2008_v n1_199658_391088 0 -1.6999999999749285e-07
iB00_2009_v n1_199658_387744 0 1.150000000012686e-07
iB00_2010_v n1_221850_391088 0 1.85000000019718e-07
iB00_2011_v n1_221850_387744 0 5.000000000222722e-08
iB00_2012_v n1_199658_384400 0 1.9500000000178283e-07
iB00_2013_v n1_199658_381056 0 5.4999999969966226e-08
iB00_2014_v n1_221850_384400 0 0.0
iB00_2015_v n1_221850_381056 0 3.500000000837767e-08
iB00_2016_v n1_199658_377712 0 -3.300000000057211e-07
iB00_2017_v n1_199658_377358 0 0.07990600000000005
iB00_2018_v n1_221850_377712 0 -3.399999999695747e-07
iB00_2019_v n1_221850_377358 0 0.08219349999999997
iB00_2020_v n1_199658_374368 0 -5.500000000554161e-08
iB00_2021_v n1_199658_371024 0 -7.499999999847039e-08
iB00_2022_v n1_221850_374368 0 2.0000000001399107e-07
iB00_2023_v n1_221850_371024 0 -5.500000001485897e-08
iB00_2024_v n1_199658_367680 0 9.999999999344301e-08
iB00_2025_v n1_199658_364336 0 -3.999999998924569e-08
iB00_2026_v n1_221850_367680 0 2.650000000117619e-07
iB00_2027_v n1_221850_364336 0 -3.7000000000470765e-07
iB00_2028_v n1_199658_360992 0 -2.4999999996666686e-08
iB00_2029_v n1_199658_357648 0 1.4500000000336726e-07
iB00_2030_v n1_221850_360992 0 3.4999999995672174e-08
iB00_2031_v n1_221850_357648 0 -3.9999999995598434e-08
iB00_2032_v n1_199658_355470 0 0.08060189999999998
iB00_2033_v n1_199658_354304 0 -3.4999999999060305e-08
iB00_2034_v n1_221850_355470 0 0.0795042
iB00_2035_v n1_221850_354304 0 2.499999999751372e-08
iB00_2036_v n1_199658_350960 0 3.500000000075437e-08
iB00_2037_v n1_199658_347616 0 -2.0000000001399107e-08
iB00_2038_v n1_221850_350960 0 -2.0000000001399107e-08
iB00_2039_v n1_221850_347616 0 -1.500000000231988e-08
iB00_2040_v n1_199658_344272 0 -1.999999999970504e-08
iB00_2041_v n1_199658_340928 0 4.499999999637173e-08
iB00_2042_v n1_221850_344272 0 -4.999999996961645e-09
iB00_2043_v n1_221850_340928 0 4.999999999079227e-09
iB00_2044_v n1_199658_337584 0 -1.499999999977878e-08
iB00_2045_v n1_199658_334240 0 -2.0000000001399107e-08
iB00_2046_v n1_221850_337584 0 3.000000000209866e-08
iB00_2047_v n1_221850_334240 0 -8.470329472543003e-19
iB00_2048_v n1_199658_332974 0 0.08079500000000002
iB00_2049_v n1_199658_330896 0 -4.0000000002798214e-08
iB00_2050_v n1_221850_332974 0 0.08352214999999998
iB00_2051_v n1_221850_330896 0 3.000000000802789e-08
iB00_2052_v n1_199658_327552 0 3.8116482626443515e-18
iB00_2053_v n1_199658_324208 0 2.499999999497262e-08
iB00_2054_v n1_221850_327552 0 -1.5000000007825594e-08
iB00_2055_v n1_221850_324208 0 2.0000000001399107e-08
iB00_2056_v n1_199658_320864 0 8.046812998915853e-18
iB00_2057_v n1_199658_317520 0 -1.3552527156068805e-17
iB00_2058_v n1_221850_320864 0 -2.99999999953224e-08
iB00_2059_v n1_221850_317520 0 -5.000000000349777e-09
iB00_2060_v n1_199658_314176 0 -1.4999999994273067e-08
iB00_2061_v n1_199658_311086 0 0.08068815000000003
iB00_2062_v n1_221850_314176 0 3.000000000209866e-08
iB00_2063_v n1_221850_311086 0 0.08339369999999999
iB00_2064_v n1_199658_310832 0 2.4999999992855038e-08
iB00_2065_v n1_199658_307488 0 1.0000000000699553e-08
iB00_2066_v n1_221850_310832 0 -5.4999999983518753e-08
iB00_2067_v n1_221850_307488 0 1.1999999999526563e-07
iB00_2068_v n1_199658_304144 0 5.99999999855626e-08
iB00_2069_v n1_199658_300800 0 -2.5999999999108334e-07
iB00_2070_v n1_221850_304144 0 -7.000000000489687e-08
iB00_2071_v n1_221850_300800 0 -1.8499999999261295e-07
iB00_2072_v n1_199658_297456 0 1.0999999999710718e-07
iB00_2073_v n1_199658_294112 0 -2.9500000000030804e-07
iB00_2074_v n1_221850_297456 0 2.4499999999681027e-07
iB00_2075_v n1_221850_294112 0 -3.099999999861108e-07
iB00_2076_v n1_199658_290768 0 1.0000000000657202e-07
iB00_2077_v n1_199658_288590 0 0.08230699999999998
iB00_2078_v n1_221850_290768 0 9.499999998631697e-08
iB00_2079_v n1_221850_288590 0 0.08035150000000008
iB00_2080_v n1_199658_287424 0 1.3500000000605584e-07
iB00_2081_v n1_199658_284080 0 5.00000000712604e-09
iB00_2082_v n1_221850_287424 0 -1.000000001425208e-08
iB00_2083_v n1_221850_284080 0 -8.893845946170154e-18
iB00_2084_v n1_199658_280736 0 -2.750000000243199e-07
iB00_2085_v n1_199658_277392 0 3.0500000002811264e-07
iB00_2086_v n1_221850_280736 0 -4.0000000002798214e-08
iB00_2087_v n1_221850_277392 0 3.7999999999100765e-07
iB00_2088_v n1_199658_274048 0 -2.84999999986903e-07
iB00_2089_v n1_199658_270704 0 -4.999999998994524e-08
iB00_2090_v n1_221850_274048 0 -2.100000000011381e-07
iB00_2091_v n1_221850_270704 0 2.0999999999055018e-07
iB00_2092_v n1_199658_267360 0 -4.999999996114612e-09
iB00_2093_v n1_199658_266702 0 0.08029199999999999
iB00_2094_v n1_221850_267360 0 -3.200000000223857e-07
iB00_2095_v n1_221850_266702 0 0.08045950000000002
iB00_2096_v n1_199658_264016 0 1.2500000000620332e-07
iB00_2097_v n1_199658_260672 0 -4.999999980020986e-09
iB00_2098_v n1_221850_264016 0 -9.49999999998695e-08
iB00_2099_v n1_221850_260672 0 2.0752307207730358e-17
iB00_2100_v n1_199658_257328 0 1.6999999997885812e-07
iB00_2101_v n1_199658_253984 0 -3.399999999695747e-07
iB00_2102_v n1_221850_257328 0 1.849999999655079e-07
iB00_2103_v n1_221850_253984 0 -4.499999998747788e-08
iB00_2104_v n1_199658_250640 0 -3.5000000019389096e-08
iB00_2105_v n1_199658_247296 0 9.49999999998695e-08
iB00_2106_v n1_221850_250640 0 -1.7000000002544494e-07
iB00_2107_v n1_221850_247296 0 3.1500000000933044e-07
iB00_2108_v n1_199658_244814 0 0.0813335
iB00_2109_v n1_199658_243952 0 -8.99999999656384e-08
iB00_2110_v n1_221850_244814 0 0.08207249999999996
iB00_2111_v n1_221850_243952 0 -6.000000000589139e-08
iB00_2112_v n1_199658_240608 0 2.4999999967020533e-08
iB00_2113_v n1_199658_237264 0 5.000000034231095e-09
iB00_2114_v n1_221850_240608 0 1.9499999997975997e-07
iB00_2115_v n1_221850_237264 0 7.000000000447336e-08
iB00_2116_v n1_199658_233920 0 -1.1499999997077542e-07
iB00_2117_v n1_199658_230576 0 1.349999999484576e-07
iB00_2118_v n1_221850_233920 0 5.999999997709227e-08
iB00_2119_v n1_221850_230576 0 -3.29999999990898e-07
iB00_2120_v n1_199658_227232 0 -1.599999999866289e-07
iB00_2121_v n1_199658_223888 0 -4.49999999828192e-08
iB00_2122_v n1_221850_227232 0 -1.1500000002837366e-07
iB00_2123_v n1_221850_223888 0 2.0000000000128558e-07
iB00_2124_v n1_199658_222318 0 0.08163850000000004
iB00_2125_v n1_199658_220544 0 -1.000000001425208e-08
iB00_2126_v n1_221850_222318 0 0.08165399999999996
iB00_2127_v n1_221850_220544 0 4.2000000002684015e-07
iB00_2128_v n1_199658_217200 0 -2.9000000004654507e-07
iB00_2129_v n1_199658_213856 0 -4.999999990863008e-08
iB00_2130_v n1_221850_217200 0 -1.799999999854869e-07
iB00_2131_v n1_221850_213856 0 -2.0000000005973085e-07
iB00_2132_v n1_199658_210512 0 2.499999999497262e-07
iB00_2133_v n1_199658_207168 0 9.999999997989048e-08
iB00_2134_v n1_221850_210512 0 3.5500000004516294e-07
iB00_2135_v n1_221850_207168 0 -5.5000000061445785e-08
iB00_2136_v n1_199658_203824 0 6.183340514956392e-17
iB00_2137_v n1_199658_200480 0 0.0
iB00_2138_v n1_221850_203824 0 6.000000003130238e-08
iB00_2139_v n1_221850_200480 0 -2.6000000002242355e-07
iB00_2140_v n1_199658_200430 0 0.08436000000000002
iB00_2141_v n1_199658_197136 0 -5.421010862427522e-17
iB00_2142_v n1_221850_200430 0 0.08185850000000004
iB00_2143_v n1_221850_197136 0 -4.1000000000157664e-07
iB00_2144_v n1_199658_193792 0 -4.9999999954369856e-08
iB00_2145_v n1_199658_190448 0 4.9999999962840186e-08
iB00_2146_v n1_221850_193792 0 1.3999999992847859e-07
iB00_2147_v n1_221850_190448 0 2.1000000003247831e-07
iB00_2148_v n1_199658_187104 0 1.4999999997915308e-07
iB00_2149_v n1_199658_183760 0 -2.4999999997683126e-07
iB00_2150_v n1_221850_187104 0 -1.4999999999694077e-07
iB00_2151_v n1_221850_183760 0 5.0000000022979525e-08
iB00_2152_v n1_199658_180416 0 2.499999999903838e-07
iB00_2153_v n1_199658_177934 0 0.079835
iB00_2154_v n1_221850_180416 0 -9.999999997989048e-08
iB00_2155_v n1_221850_177934 0 0.08232249999999997
iB00_2156_v n1_199658_177072 0 -2.0000000002415546e-07
iB00_2157_v n1_199658_173728 0 1.0000000003410059e-07
iB00_2158_v n1_221850_177072 0 4.0000000002798214e-07
iB00_2159_v n1_221850_173728 0 9.999999997480828e-08
iB00_2160_v n1_199658_170384 0 2.500000000005482e-07
iB00_2161_v n1_199658_167040 0 -4.9999999962840186e-08
iB00_2162_v n1_221850_170384 0 -4.9999999962840186e-08
iB00_2163_v n1_221850_167040 0 -1.000000000086896e-07
iB00_2164_v n1_199658_163696 0 -1.1858461261560205e-17
iB00_2165_v n1_199658_160352 0 9.999999992568037e-08
iB00_2166_v n1_221850_163696 0 -5.421010862427522e-17
iB00_2167_v n1_221850_160352 0 1.5000000003505726e-07
iB00_2168_v n1_199658_157008 0 -2.999999999464477e-07
iB00_2169_v n1_199658_156046 0 0.08204899999999994
iB00_2170_v n1_221850_157008 0 -4.9999999962840186e-08
iB00_2171_v n1_221850_156046 0 0.0811225
iB00_2172_v n1_199658_153664 0 9.999999998836081e-08
iB00_2173_v n1_199658_150320 0 -9.999999997989048e-08
iB00_2174_v n1_221850_153664 0 2.9999999993967144e-07
iB00_2175_v n1_221850_150320 0 -1.4999999998423528e-07
iB00_2176_v n1_199658_146976 0 -2.999999999769409e-07
iB00_2177_v n1_199658_143632 0 5.000000000078726e-07
iB00_2178_v n1_221850_146976 0 -5.0000000017050295e-08
iB00_2179_v n1_221850_143632 0 1.9999999998773305e-07
iB00_2180_v n1_199658_140288 0 -2.5000000001579477e-07
iB00_2181_v n1_199658_136944 0 0.0
iB00_2182_v n1_221850_140288 0 9.999999997989048e-08
iB00_2183_v n1_221850_136944 0 -4.4999999989849573e-07
iB00_2184_v n1_199658_133600 0 1.999999999733335e-07
iB00_2185_v n1_199658_133550 0 0.08160549999999996
iB00_2186_v n1_221850_133600 0 9.999999997989048e-08
iB00_2187_v n1_221850_133550 0 0.08064750000000005
iB00_2188_v n1_199658_130256 0 5.0000000020438426e-08
iB00_2189_v n1_199658_126912 0 5.0000000017050295e-08
iB00_2190_v n1_221850_130256 0 9.999999997989048e-08
iB00_2191_v n1_221850_126912 0 -3.000000000286099e-07
iB00_2192_v n1_199658_123568 0 -4.9999999962840186e-08
iB00_2193_v n1_199658_120224 0 2.9999999999388155e-07
iB00_2194_v n1_221850_123568 0 -5.421010862427522e-17
iB00_2195_v n1_177466_116880 0 -3.0000000004809166e-07
iB00_2196_v n1_221850_120224 0 3.5000000000330855e-07
iB00_2197_v n1_199658_116880 0 -2.541098841762901e-17
iB00_2198_v n1_199658_113536 0 -3.5000000003973096e-07
iB00_2199_v n1_221850_116880 0 -1.4999999994273067e-07
iB00_2200_v n1_177466_113536 0 -1.4999999996475352e-07
iB00_2201_v n1_177466_111662 0 0.07355700000000003
iB00_2202_v n1_154970_113536 0 -5.0000000017050295e-08
iB00_2203_v n1_199658_111662 0 0.08091849999999987
iB00_2204_v n1_199658_110192 0 -1.4999999999694077e-07
iB00_2205_v n1_221850_110192 0 0.0
iB00_2206_v n1_221850_111662 0 0.08341149999999999
iB00_2207_v n1_244346_111662 0 0.08185050000000002
iB00_2208_v n1_221850_113536 0 -5.000000001366216e-08
iB00_2209_v n1_244346_113536 0 4.999999990863008e-08
iB00_2210_v n1_266538_113536 0 1.6500000001916593e-07
iB00_2211_v n1_244346_116880 0 -4.999999997808678e-08
iB00_2212_v n1_244346_120224 0 3.5000000001093184e-07
iB00_2213_v n1_266538_116880 0 -1.2000000000839464e-07
iB00_2214_v n1_266538_120224 0 1.4999999976485375e-08
iB00_2215_v n1_244346_123568 0 -2.4999999996666686e-07
iB00_2216_v n1_244346_126912 0 1.5000000005115088e-07
iB00_2217_v n1_266538_123568 0 1.0500000006833168e-07
iB00_2218_v n1_266538_126912 0 1.6499999994970923e-07
iB00_2219_v n1_244346_130256 0 9.999999994346806e-08
iB00_2220_v n1_244346_133550 0 0.08090149999999999
iB00_2221_v n1_266538_130256 0 -3.199999999681756e-07
iB00_2222_v n1_266538_133550 0 0.08095299999999998
iB00_2223_v n1_244346_133600 0 9.999999997650235e-08
iB00_2224_v n1_244346_136944 0 -1.4999999999694077e-07
iB00_2225_v n1_266538_133600 0 -2.400000000167893e-07
iB00_2226_v n1_266538_136944 0 9.999999996549092e-08
iB00_2227_v n1_244346_140288 0 9.999999996972609e-08
iB00_2228_v n1_244346_143632 0 0.0
iB00_2229_v n1_266538_140288 0 2.5000000008525147e-08
iB00_2230_v n1_266538_143632 0 -8.000000005514786e-08
iB00_2231_v n1_244346_146976 0 -9.999999998836081e-08
iB00_2232_v n1_244346_150320 0 3.3999999999667976e-07
iB00_2233_v n1_266538_146976 0 -1.2499999993420552e-07
iB00_2234_v n1_266538_150320 0 3.699999999805672e-07
iB00_2235_v n1_244346_153664 0 -9.999999994855026e-08
iB00_2236_v n1_244346_156046 0 0.080903
iB00_2237_v n1_266538_153664 0 -1.3000000002264672e-07
iB00_2238_v n1_266538_156046 0 0.08124250000000001
iB00_2239_v n1_244346_157008 0 3.9500000002000907e-07
iB00_2240_v n1_244346_160352 0 4.999999980020986e-09
iB00_2241_v n1_266538_157008 0 1.9999999995978096e-07
iB00_2242_v n1_266538_160352 0 7.000000002903731e-08
iB00_2243_v n1_244346_163696 0 -3.199999999961277e-07
iB00_2244_v n1_244346_167040 0 -1.9999999974294053e-08
iB00_2245_v n1_266538_163696 0 -3.499999996856712e-08
iB00_2246_v n1_266538_167040 0 -1.299999999781775e-07
iB00_2247_v n1_244346_170384 0 -5.5000000058904686e-08
iB00_2248_v n1_244346_173728 0 2.5000000062735256e-08
iB00_2249_v n1_266538_170384 0 2.900000000338396e-07
iB00_2250_v n1_266538_173728 0 -2.750000000569307e-07
iB00_2251_v n1_244346_177072 0 2.649999999778806e-07
iB00_2252_v n1_244346_177934 0 0.0839495
iB00_2253_v n1_266538_177072 0 1.7500000005967603e-07
iB00_2254_v n1_266538_177934 0 0.081852
iB00_2255_v n1_244346_180416 0 2.200000000238605e-07
iB00_2256_v n1_244346_183760 0 -3.3499999996244867e-07
iB00_2257_v n1_266538_180416 0 8.000000000559643e-08
iB00_2258_v n1_266538_183760 0 3.0000000041062176e-08
iB00_2259_v n1_244346_187104 0 2.4500000000612763e-07
iB00_2260_v n1_244346_190448 0 -1.4999999994273067e-08
iB00_2261_v n1_266538_187104 0 2.499999995431504e-08
iB00_2262_v n1_266538_190448 0 7.499999998788248e-08
iB00_2263_v n1_244346_193792 0 -1.400000000267344e-07
iB00_2264_v n1_244346_197136 0 3.649999999509948e-07
iB00_2265_v n1_266538_193792 0 2.0500000004822216e-07
iB00_2266_v n1_266538_197136 0 -7.500000001964621e-08
iB00_2267_v n1_244346_200430 0 0.08259050000000004
iB00_2268_v n1_244346_200480 0 4.9999999962840186e-08
iB00_2269_v n1_266538_200430 0 0.0826015
iB00_2270_v n1_266538_200480 0 -1.8000000000623922e-07
iB00_2271_v n1_244346_203824 0 -1.0499999998362839e-07
iB00_2272_v n1_244346_207168 0 -1.6999999997123483e-07
iB00_2273_v n1_266538_203824 0 3.9500000004796115e-07
iB00_2274_v n1_266538_207168 0 -3.900000000230474e-07
iB00_2275_v n1_244346_210512 0 3.2499999995751395e-07
iB00_2276_v n1_244346_213856 0 -1.349999999484576e-07
iB00_2277_v n1_266538_210512 0 -1.000000001425208e-08
iB00_2278_v n1_266538_213856 0 5.500000002629392e-08
iB00_2279_v n1_244346_217200 0 -7.500000000863478e-08
iB00_2280_v n1_244346_220544 0 -1.4999999940062958e-08
iB00_2281_v n1_266538_217200 0 3.299999999824277e-07
iB00_2282_v n1_266538_220544 0 -1.7499999998894878e-07
iB00_2283_v n1_244346_222318 0 0.08099699999999997
iB00_2284_v n1_244346_223888 0 -1.0499999998701652e-07
iB00_2285_v n1_266538_222318 0 0.08341300000000001
iB00_2286_v n1_266538_223888 0 -3.000000002708613e-08
iB00_2287_v n1_244346_227232 0 1.49999999951201e-08
iB00_2288_v n1_244346_230576 0 1.0499999998701652e-07
iB00_2289_v n1_266538_227232 0 5.499999999707128e-08
iB00_2290_v n1_266538_230576 0 -1.3500000001452617e-07
iB00_2291_v n1_244346_233920 0 1.7500000001139515e-07
iB00_2292_v n1_244346_237264 0 -2.849999999996085e-07
iB00_2293_v n1_266538_233920 0 -1.2999999999554167e-07
iB00_2294_v n1_266538_237264 0 5.0000000015779745e-08
iB00_2295_v n1_244346_240608 0 2.449999999997749e-07
iB00_2296_v n1_244346_243952 0 -2.3999999998968423e-07
iB00_2297_v n1_266538_240608 0 -1.2500000001552068e-07
iB00_2298_v n1_266538_243952 0 3.2499999998546604e-07
iB00_2299_v n1_244346_244814 0 0.081107
iB00_2300_v n1_244346_247296 0 -3.0499999997390254e-07
iB00_2301_v n1_266538_244814 0 0.08205100000000001
iB00_2302_v n1_266538_247296 0 1.249999999951919e-07
iB00_2303_v n1_244346_250640 0 3.09999999978911e-07
iB00_2304_v n1_244346_253984 0 -6.999999999134435e-08
iB00_2305_v n1_266538_250640 0 5.00000000712604e-09
iB00_2306_v n1_266538_253984 0 -2.499999997803196e-08
iB00_2307_v n1_244346_257328 0 5.000000000773293e-08
iB00_2308_v n1_244346_260672 0 -3.200000000223857e-07
iB00_2309_v n1_266538_257328 0 4.0000000002798214e-08
iB00_2310_v n1_266538_260672 0 2.049999999974002e-07
iB00_2311_v n1_244346_264016 0 3.149999999906957e-07
iB00_2312_v n1_244346_266702 0 0.07987000000000001
iB00_2313_v n1_266538_264016 0 -3.000000001565119e-08
iB00_2314_v n1_266538_266702 0 0.08090250000000002
iB00_2315_v n1_244346_267360 0 -5.000000014749337e-09
iB00_2316_v n1_244346_270704 0 4.3499999999654926e-07
iB00_2317_v n1_266538_267360 0 3.099999999810286e-07
iB00_2318_v n1_266538_270704 0 -2.749999999955208e-07
iB00_2319_v n1_244346_274048 0 -1.0500000001496861e-07
iB00_2320_v n1_244346_277392 0 -9.49999999998695e-08
iB00_2321_v n1_266538_274048 0 2.6000000000463586e-07
iB00_2322_v n1_266538_277392 0 -7.499999999063533e-08
iB00_2323_v n1_244346_280736 0 -2.999999998896965e-08
iB00_2324_v n1_244346_284080 0 1.0999999999414256e-07
iB00_2325_v n1_266538_280736 0 -2.6000000000463586e-07
iB00_2326_v n1_266538_284080 0 2.0999999999372656e-07
iB00_2327_v n1_244346_287424 0 -1.6999999999791637e-07
iB00_2328_v n1_244346_288590 0 0.08362850000000001
iB00_2329_v n1_266538_287424 0 -1.3999999999624122e-07
iB00_2330_v n1_266538_288590 0 0.08442549999999997
iB00_2331_v n1_244346_290768 0 3.2499999999054824e-07
iB00_2332_v n1_244346_294112 0 -1.4999999994273067e-08
iB00_2333_v n1_266538_290768 0 8.000000000559643e-08
iB00_2334_v n1_266538_294112 0 2.500000000323119e-08
iB00_2335_v n1_244346_297456 0 -2.60000000008024e-07
iB00_2336_v n1_244346_300800 0 9.500000001342202e-08
iB00_2337_v n1_266538_297456 0 1.0999999999414256e-07
iB00_2338_v n1_266538_300800 0 -2.1500000001715798e-07
iB00_2339_v n1_244346_304144 0 4.500000000103041e-08
iB00_2340_v n1_244346_307488 0 9.49999999998695e-08
iB00_2341_v n1_266538_304144 0 1.000000001425208e-08
iB00_2342_v n1_266538_307488 0 -2.4500000000252774e-07
iB00_2343_v n1_244346_310832 0 -2.699999999922064e-07
iB00_2344_v n1_244346_311086 0 0.08284235000000001
iB00_2345_v n1_266538_310832 0 4.7499999998579494e-07
iB00_2346_v n1_266538_311086 0 0.07998025
iB00_2347_v n1_244346_314176 0 1.2705494208814505e-18
iB00_2348_v n1_244346_317520 0 2.999999999871053e-08
iB00_2349_v n1_266538_314176 0 -5.000000000349777e-09
iB00_2350_v n1_266538_317520 0 -1.499999999977878e-08
iB00_2351_v n1_244346_320864 0 -2.9999999999134045e-08
iB00_2352_v n1_244346_324208 0 2.99999999953224e-08
iB00_2353_v n1_266538_320864 0 3.000000000209866e-08
iB00_2354_v n1_266538_324208 0 -2.000000000097559e-08
iB00_2355_v n1_244346_327552 0 -3.499999999270756e-08
iB00_2356_v n1_244346_330896 0 2.499999999497262e-08
iB00_2357_v n1_266538_327552 0 1.500000000104933e-08
iB00_2358_v n1_266538_330896 0 -1.999999999970504e-08
iB00_2359_v n1_244346_332974 0 0.07766925
iB00_2360_v n1_244346_334240 0 -1.0000000000699553e-08
iB00_2361_v n1_266538_332974 0 0.08146920000000002
iB00_2362_v n1_266538_334240 0 1.5000000002531638e-08
iB00_2363_v n1_244346_337584 0 -1.4999999997237682e-08
iB00_2364_v n1_244346_340928 0 0.0
iB00_2365_v n1_266538_337584 0 -1.0000000000699553e-08
iB00_2366_v n1_266538_340928 0 -3.1763735522036263e-18
iB00_2367_v n1_244346_344272 0 2.499999999751372e-08
iB00_2368_v n1_244346_347616 0 1.0000000000699553e-08
iB00_2369_v n1_266538_344272 0 -4.999999996961645e-09
iB00_2370_v n1_266538_347616 0 1.4999999997025924e-08
iB00_2371_v n1_244346_350960 0 -5.000000000773293e-09
iB00_2372_v n1_244346_354304 0 -2.99999999953224e-08
iB00_2373_v n1_266538_350960 0 -3.999999999941008e-08
iB00_2374_v n1_266538_354304 0 3.499999999990734e-08
iB00_2375_v n1_244346_355470 0 0.08391789999999999
iB00_2376_v n1_244346_357648 0 -2.7499999999890893e-07
iB00_2377_v n1_266538_355470 0 0.08554745000000001
iB00_2378_v n1_266538_357648 0 -3.000000001268657e-08
iB00_2379_v n1_244346_360992 0 3.849999999875458e-07
iB00_2380_v n1_244346_364336 0 -3.5499999999095283e-07
iB00_2381_v n1_266538_360992 0 2.300000000025372e-07
iB00_2382_v n1_266538_364336 0 9.500000000516345e-08
iB00_2383_v n1_244346_367680 0 1.4999999990037902e-08
iB00_2384_v n1_244346_371024 0 4.999999993573513e-09
iB00_2385_v n1_266538_367680 0 9.999999987147026e-09
iB00_2386_v n1_266538_371024 0 -7.000000000066171e-08
iB00_2387_v n1_244346_374368 0 1.1000000000684806e-07
iB00_2388_v n1_244346_377358 0 0.08124150000000001
iB00_2389_v n1_266538_374368 0 -1.799999999854869e-07
iB00_2390_v n1_266538_377358 0 0.07778849999999998
iB00_2391_v n1_244346_377712 0 -8.000000000601994e-08
iB00_2392_v n1_244346_381056 0 3.9500000000730357e-07
iB00_2393_v n1_266538_377712 0 -2.5000000008525147e-08
iB00_2394_v n1_266538_381056 0 2.0000000005422513e-08
iB00_2395_v n1_244346_384400 0 -4.99999999399703e-09
iB00_2396_v n1_244346_387744 0 -2.9500000001386056e-07
iB00_2397_v n1_266538_384400 0 -3.4999999995672174e-08
iB00_2398_v n1_266538_387744 0 3.3999999999562097e-07
iB00_2399_v n1_244346_391088 0 1.0000000010440432e-08
iB00_2400_v n1_244346_394432 0 -9.999999999344301e-08
iB00_2401_v n1_266538_391088 0 -3.3500000000310625e-07
iB00_2402_v n1_266538_394432 0 -2.999999999489888e-08
iB00_2403_v n1_244346_397776 0 3.6500000000054623e-07
iB00_2404_v n1_244346_399854 0 0.08127649999999997
iB00_2405_v n1_266538_397776 0 2.849999999996085e-07
iB00_2406_v n1_266538_399854 0 0.08086349999999996
iB00_2407_v n1_244346_401120 0 1.5499999998882022e-07
iB00_2408_v n1_244346_404464 0 -4.2999999996231816e-07
iB00_2409_v n1_266538_401120 0 1.7500000000546592e-07
iB00_2410_v n1_266538_404464 0 -1.6999999999410472e-07
iB00_2411_v n1_244346_407808 0 2.9999999983463936e-08
iB00_2412_v n1_244346_411152 0 1.9999999974294053e-08
iB00_2413_v n1_266538_407808 0 5.499999999707128e-08
iB00_2414_v n1_266538_411152 0 3.500000000227903e-07
iB00_2415_v n1_244346_414496 0 3.500000000541305e-08
iB00_2416_v n1_244346_417840 0 6.500000003842842e-08
iB00_2417_v n1_266538_414496 0 -2.7000000003244047e-07
iB00_2418_v n1_266538_417840 0 2.0500000000205887e-07
iB00_2419_v n1_244346_421184 0 1.0999999997296674e-07
iB00_2420_v n1_244346_421742 0 0.0816
iB00_2421_v n1_266538_421184 0 -2.1499999998115908e-07
iB00_2422_v n1_266538_421742 0 0.08368650000000004
iB00_2423_v n1_244346_424528 0 -2.499999999243152e-08
iB00_2424_v n1_244346_427872 0 2.0999999997403304e-07
iB00_2425_v n1_266538_424528 0 1.1499999997416355e-07
iB00_2426_v n1_266538_427872 0 -1.1999999999103047e-07
iB00_2427_v n1_244346_431216 0 -4.500000000060689e-08
iB00_2428_v n1_244346_434560 0 2.2000000001539018e-07
iB00_2429_v n1_266538_431216 0 2.500000000039363e-07
iB00_2430_v n1_266538_434560 0 -2.9500000001047243e-07
iB00_2431_v n1_244346_437904 0 4.999999991032414e-09
iB00_2432_v n1_244346_441248 0 -1.6999999997123483e-07
iB00_2433_v n1_266538_437904 0 2.4499999999681027e-07
iB00_2434_v n1_266538_441248 0 -1.5500000000321978e-07
iB00_2435_v n1_244346_444238 0 0.08014950000000001
iB00_2436_v n1_244346_444592 0 2.0000000001399107e-08
iB00_2437_v n1_266538_444238 0 0.08077850000000006
iB00_2438_v n1_266538_444592 0 -7.500000003912797e-08
iB00_2439_v n1_244346_447936 0 2.700000000044884e-07
iB00_2440_v n1_244346_451280 0 -4.000000000008771e-07
iB00_2441_v n1_266538_447936 0 9.000000001984851e-08
iB00_2442_v n1_266538_451280 0 -2.100000000066438e-07
iB00_2443_v n1_244346_454624 0 5.5000000007235676e-08
iB00_2444_v n1_244346_457968 0 1.6999999999833988e-07
iB00_2445_v n1_266538_454624 0 2.710505431213761e-17
iB00_2446_v n1_266538_457968 0 2.1000000000537326e-07
iB00_2447_v n1_244346_461312 0 -2.0000000024268997e-08
iB00_2448_v n1_244346_464656 0 3.4999999995672174e-08
iB00_2449_v n1_266538_461312 0 -8.500000001272247e-08
iB00_2450_v n1_266538_464656 0 7.500000002599896e-08
iB00_2451_v n1_244346_466126 0 0.084104
iB00_2452_v n1_244346_468000 0 -4.050000000080031e-07
iB00_2453_v n1_266538_466126 0 0.08110649999999996
iB00_2454_v n1_266538_468000 0 -3.44999999957219e-07
iB00_2455_v n1_244346_471344 0 6.499999999268864e-08
iB00_2456_v n1_244346_474688 0 3.0000000004809166e-07
iB00_2457_v n1_266538_471344 0 -5.000000034231095e-09
iB00_2458_v n1_266538_474688 0 3.0000000000446946e-07
iB00_2459_v n1_244346_478032 0 -2.0500000001179975e-07
iB00_2460_v n1_244346_481376 0 2.9999999934336025e-08
iB00_2461_v n1_266538_478032 0 6.000000000419732e-08
iB00_2462_v n1_266538_481376 0 -2.149999999896294e-07
iB00_2463_v n1_244346_484720 0 2.0000000031892293e-08
iB00_2464_v n1_244346_488064 0 2.1500000000826414e-07
iB00_2465_v n1_266538_484720 0 -2.50000000356302e-08
iB00_2466_v n1_266538_488064 0 1.4000000000937023e-07
iB00_2467_v n1_244346_488622 0 0.08159499999999999
iB00_2468_v n1_244346_491408 0 -2.249999999683061e-07
iB00_2469_v n1_266538_488622 0 0.08001200000000001
iB00_2470_v n1_266538_491408 0 -1.9000000004420822e-07
iB00_2471_v n1_244346_494752 0 -2.8499999994201024e-07
iB00_2472_v n1_244346_498096 0 3.099999999539235e-07
iB00_2473_v n1_266538_494752 0 -2.499999990010493e-08
iB00_2474_v n1_266538_498096 0 1.4500000000379078e-07
iB00_2475_v n1_244346_501440 0 1.0499999994974707e-07
iB00_2476_v n1_244346_504784 0 -4.9999999962840186e-08
iB00_2477_v n1_266538_501440 0 -1.5499999997696176e-07
iB00_2478_v n1_266538_504784 0 8.500000003813346e-08
iB00_2479_v n1_244346_508128 0 -6.000000000843249e-08
iB00_2480_v n1_244346_510510 0 0.08158650000000003
iB00_2481_v n1_266538_508128 0 -1.1500000002837366e-07
iB00_2482_v n1_266538_510510 0 0.082872
iB00_2483_v n1_244346_511472 0 2.750000000133085e-07
iB00_2484_v n1_244346_514816 0 4.9999999962840186e-08
iB00_2485_v n1_266538_511472 0 4.999999980020986e-09
iB00_2486_v n1_266538_514816 0 -4.299999999945054e-07
iB00_2487_v n1_244346_518160 0 -1.14999999934353e-07
iB00_2488_v n1_244346_521504 0 -2.4999999997683126e-07
iB00_2489_v n1_266538_518160 0 2.1999999993407501e-07
iB00_2490_v n1_266538_521504 0 -4.9999999972581065e-08
iB00_2491_v n1_244346_524848 0 1.999999999631691e-07
iB00_2492_v n1_244346_528192 0 2.0000000001399107e-07
iB00_2493_v n1_266538_524848 0 2.5499999990264213e-07
iB00_2494_v n1_266538_528192 0 -4.0499999995252247e-07
iB00_2495_v n1_244346_531536 0 -2.50000000047135e-07
iB00_2496_v n1_244346_532398 0 0.08107250000000002
iB00_2497_v n1_266538_531536 0 -3.499999996856712e-08
iB00_2498_v n1_266538_532398 0 0.08134349999999996
iB00_2499_v n1_244346_534880 0 5.0000000006038866e-08
iB00_2500_v n1_244346_538224 0 2.0000000001399107e-07
iB00_2501_v n1_266538_534880 0 -2.499999995431504e-08
iB00_2502_v n1_266538_538224 0 -1.9000000007088976e-07
iB00_2503_v n1_244346_541568 0 -1.4999999999948187e-07
iB00_2504_v n1_244346_544912 0 -2.9999999999388155e-07
iB00_2505_v n1_266538_541568 0 1.3000000002264672e-07
iB00_2506_v n1_266538_544912 0 -1.7500000002664175e-07
iB00_2507_v n1_244346_548256 0 1.4999999994188363e-07
iB00_2508_v n1_244346_551600 0 2.0000000006820118e-07
iB00_2509_v n1_266538_548256 0 -1.0499999998701652e-07
iB00_2510_v n1_266538_551600 0 3.199999999910455e-07
iB00_2511_v n1_244346_554894 0 0.08403999999999996
iB00_2512_v n1_244346_554944 0 -1.9999999995978096e-07
iB00_2513_v n1_266538_554894 0 0.079771
iB00_2514_v n1_266538_554944 0 9.000000000375488e-08
iB00_2515_v n1_244346_558288 0 -2.0000000004956645e-07
iB00_2516_v n1_244346_561632 0 5.421010862427522e-17
iB00_2517_v n1_266538_558288 0 -1.7000000002544494e-07
iB00_2518_v n1_266538_561632 0 -2.1000000001723172e-07
iB00_2519_v n1_244346_564976 0 1.999999999580869e-07
iB00_2520_v n1_244346_568320 0 5.00000000712604e-08
iB00_2521_v n1_266538_564976 0 5.000000004415535e-08
iB00_2522_v n1_266538_568320 0 8.499999998900555e-08
iB00_2523_v n1_244346_571664 0 -4.999999999841557e-08
iB00_2524_v n1_244346_575008 0 -2.4999999997683126e-07
iB00_2525_v n1_266538_571664 0 -7.499999999847039e-08
iB00_2526_v n1_266538_575008 0 1.449999999915088e-07
iB00_2527_v n1_244346_576782 0 0.08150799999999994
iB00_2528_v n1_244346_578352 0 -4.999999998994524e-08
iB00_2529_v n1_266538_576782 0 0.08138350000000007
iB00_2530_v n1_266538_578352 0 -1.7000000002375087e-07
iB00_2531_v n1_244346_581696 0 -2.499999999751372e-07
iB00_2532_v n1_244346_585040 0 0.0
iB00_2533_v n1_266538_581696 0 1.6999999999833988e-07
iB00_2534_v n1_266538_585040 0 -1.5499999999729055e-07
iB00_2535_v n1_244346_588384 0 1.500000000003289e-07
iB00_2536_v n1_244346_591728 0 1.9999999995978096e-07
iB00_2537_v n1_266538_588384 0 3.1500000001525967e-07
iB00_2538_v n1_266538_591728 0 -3.550000000180579e-07
iB00_2539_v n1_244346_595072 0 1.000000000036074e-07
iB00_2540_v n1_266538_595072 0 2.850000000004555e-07
iB00_2541_v n1_289034_595072 0 -5.999999997709227e-08
iB00_2542_v n1_311226_595072 0 8.99999999722029e-08
iB00_2543_v n1_289034_591728 0 4.000000000008771e-07
iB00_2544_v n1_311226_591728 0 1.5500000000745495e-07
iB00_2545_v n1_333722_595072 0 2.9500000001386056e-07
iB00_2546_v n1_355914_595072 0 -5.999999999360941e-08
iB00_2547_v n1_333722_591728 0 -1.400000000368988e-07
iB00_2548_v n1_355914_591728 0 -8.999999998882593e-08
iB00_2549_v n1_378410_595072 0 5.999999997709227e-08
iB00_2550_v n1_400602_595072 0 1.3999999997930056e-07
iB00_2551_v n1_378410_591728 0 -1.0999999999414256e-07
iB00_2552_v n1_400602_591728 0 -6.000000000927952e-08
iB00_2553_v n1_422794_595072 0 -1.0000000003410059e-07
iB00_2554_v n1_445290_595072 0 -4.9999999983168977e-08
iB00_2555_v n1_422794_591728 0 0.0
iB00_2556_v n1_445290_591728 0 3.4999999998043866e-07
iB00_2557_v n1_467482_595072 0 -9.999999997989048e-08
iB00_2558_v n1_489978_595072 0 -4.404571325722362e-17
iB00_2559_v n1_467482_591728 0 -2.9999999999388155e-07
iB00_2560_v n1_489978_591728 0 -1.999999999733335e-07
iB00_2561_v n1_512170_595072 0 9.999999997989048e-08
iB00_2562_v n1_534666_595072 0 -1.0000000016623773e-07
iB00_2563_v n1_512170_591728 0 -3.9999999997377203e-07
iB00_2564_v n1_534666_591728 0 -3.500000000278725e-07
iB00_2565_v n1_556858_595072 0 -3.1499999999899664e-06
iB00_2566_v n1_579050_595072 0 2.9000000000537927e-06
iB00_2567_v n1_556858_591728 0 4.000000000171401e-06
iB00_2568_v n1_579050_591728 0 9.999999998497268e-07
iB00_2569_v n1_601546_595072 0 -5.499999999707128e-07
iB00_2570_v n1_623064_595072 0 5.0000000000109636e-08
iB00_2571_v n1_601546_591728 0 1.8499999999803396e-06
iB00_2572_v n1_623064_598416 0 4.9999999996721504e-08
iB00_2573_v n1_625064_598416 0 -1.5499999998780378e-06
iB00_2574_v n1_627064_598416 0 0.0
iB00_2575_v n1_625064_595072 0 -8.000000002965216e-07
iB00_2576_v n1_627064_599278 0 -2.63678e-14
iB00_2577_v n1_625064_591728 0 -4.999999961386261e-08
iB00_2578_v n1_627064_595072 0 0.0
iB00_2579_v n1_625064_588384 0 2.849999999845313e-06
iB00_2580_v n1_627064_591728 0 0.0
iB00_2581_v n1_623064_591728 0 -3.3881317890172014e-18
iB00_2582_v n1_601546_588384 0 -3.1500000000645053e-06
iB00_2583_v n1_601546_585040 0 2.550000000046249e-06
iB00_2584_v n1_623064_588384 0 1.6940658945086007e-18
iB00_2585_v n1_579050_588384 0 -2.7999999998706143e-06
iB00_2586_v n1_556858_588384 0 -9.999999999547589e-07
iB00_2587_v n1_579050_585040 0 9.499999998902747e-07
iB00_2588_v n1_556858_585040 0 -3.10000000002035e-06
iB00_2589_v n1_534666_588384 0 -1.4999999994273067e-07
iB00_2590_v n1_512170_588384 0 4.500000000009867e-07
iB00_2591_v n1_534666_585040 0 5.999999998793429e-07
iB00_2592_v n1_512170_585040 0 -5.0000000020438426e-08
iB00_2593_v n1_489978_588384 0 -5.421010862427522e-17
iB00_2594_v n1_467482_588384 0 2.499999999903838e-07
iB00_2595_v n1_489978_585040 0 1.5000000005115088e-07
iB00_2596_v n1_467482_585040 0 4.999999996114612e-08
iB00_2597_v n1_445290_588384 0 -4.499999999908223e-07
iB00_2598_v n1_422794_588384 0 -4.99999999992626e-08
iB00_2599_v n1_445290_585040 0 5.0000000017050295e-08
iB00_2600_v n1_422794_585040 0 2.5000000000224224e-07
iB00_2601_v n1_400602_588384 0 1.0500000001412158e-07
iB00_2602_v n1_378410_588384 0 2.1000000000240865e-07
iB00_2603_v n1_400602_585040 0 -3.400000000237848e-07
iB00_2604_v n1_378410_585040 0 2.4999999995819653e-08
iB00_2605_v n1_355914_588384 0 1.599999999840878e-07
iB00_2606_v n1_333722_588384 0 -8.499999998604093e-08
iB00_2607_v n1_355914_585040 0 -2.7500000001246146e-07
iB00_2608_v n1_333722_585040 0 -5.4999999980765896e-08
iB00_2609_v n1_311226_588384 0 6.500000001132336e-08
iB00_2610_v n1_289034_588384 0 -1.7000000000511615e-07
iB00_2611_v n1_311226_585040 0 -1.6000000001288692e-07
iB00_2612_v n1_289034_585040 0 -2.900000000067345e-07
iB00_2613_v n1_289034_581696 0 4.500000002347678e-08
iB00_2614_v n1_289034_578352 0 3.3999999999667976e-07
iB00_2615_v n1_311226_581696 0 -9.999999987147026e-09
iB00_2616_v n1_311226_578352 0 1.9999999969423613e-08
iB00_2617_v n1_289034_576782 0 0.08139599999999994
iB00_2618_v n1_289034_575008 0 5.000000034231095e-09
iB00_2619_v n1_311226_576782 0 0.08190850000000006
iB00_2620_v n1_311226_575008 0 -3.3000000001207384e-07
iB00_2621_v n1_289034_571664 0 -3.850000000235447e-07
iB00_2622_v n1_289034_568320 0 2.300000000025372e-07
iB00_2623_v n1_311226_571664 0 3.1500000001525967e-07
iB00_2624_v n1_311226_568320 0 -1.5499999999517297e-07
iB00_2625_v n1_289034_564976 0 -1.250000000290732e-07
iB00_2626_v n1_289034_561632 0 8.500000003982752e-08
iB00_2627_v n1_311226_564976 0 2.4499999999681027e-07
iB00_2628_v n1_311226_561632 0 5.00000001199648e-09
iB00_2629_v n1_289034_558288 0 -1.0499999998616949e-07
iB00_2630_v n1_289034_554944 0 3.350000000166588e-07
iB00_2631_v n1_311226_558288 0 -3.85000000006604e-07
iB00_2632_v n1_311226_554944 0 5.999999999890336e-08
iB00_2633_v n1_289034_554894 0 0.08344899999999998
iB00_2634_v n1_289034_551600 0 1.4999999994273067e-08
iB00_2635_v n1_311226_554894 0 0.08018299999999999
iB00_2636_v n1_311226_551600 0 -2.6000000000823575e-07
iB00_2637_v n1_289034_548256 0 1.7499999998259603e-07
iB00_2638_v n1_289034_544912 0 -5.4999999969966226e-08
iB00_2639_v n1_311226_548256 0 -1.9499999997975997e-07
iB00_2640_v n1_311226_544912 0 2.3999999996829665e-07
iB00_2641_v n1_289034_541568 0 2.6999999998246553e-07
iB00_2642_v n1_289034_538224 0 -3.599999999709738e-07
iB00_2643_v n1_311226_541568 0 7.500000002557544e-08
iB00_2644_v n1_311226_538224 0 -1.7000000001252768e-07
iB00_2645_v n1_289034_534880 0 9.999999973594499e-09
iB00_2646_v n1_289034_532398 0 0.07967800000000004
iB00_2647_v n1_311226_534880 0 3.000000001565119e-08
iB00_2648_v n1_311226_532398 0 0.0808951
iB00_2649_v n1_289034_531536 0 1.299999999811421e-07
iB00_2650_v n1_289034_528192 0 -1.2999999999554167e-07
iB00_2651_v n1_311226_531536 0 8.499999995851236e-08
iB00_2652_v n1_311226_528192 0 -1.2499999995887535e-07
iB00_2653_v n1_289034_524848 0 7.999999998569115e-08
iB00_2654_v n1_289034_521504 0 2.449999999697052e-07
iB00_2655_v n1_311226_524848 0 1.399999999826887e-07
iB00_2656_v n1_311226_521504 0 -1.1500000000370382e-07
iB00_2657_v n1_289034_518160 0 -1.0999999995517905e-07
iB00_2658_v n1_289034_514816 0 1.4999999967168012e-08
iB00_2659_v n1_311226_518160 0 1.0499999998701652e-07
iB00_2660_v n1_311226_514816 0 -2.0999999999129134e-07
iB00_2661_v n1_289034_511472 0 1.2500000003034376e-07
iB00_2662_v n1_289034_510510 0 0.08204949999999993
iB00_2663_v n1_311226_511472 0 -5.5000000024176335e-08
iB00_2664_v n1_311226_510510 0 0.08170415000000002
iB00_2665_v n1_289034_508128 0 4.499999999383063e-08
iB00_2666_v n1_289034_504784 0 -2.0999999997403304e-07
iB00_2667_v n1_311226_508128 0 -1.000000001425208e-08
iB00_2668_v n1_311226_504784 0 -5.293955920339377e-19
iB00_2669_v n1_289034_501440 0 4.999999999375689e-08
iB00_2670_v n1_289034_498096 0 3.199999999681756e-07
iB00_2671_v n1_311226_501440 0 5.000000034231095e-09
iB00_2672_v n1_311226_498096 0 2.500000003330086e-08
iB00_2673_v n1_289034_494752 0 1.1000000002167113e-07
iB00_2674_v n1_289034_491408 0 -7.499999999847039e-08
iB00_2675_v n1_311226_494752 0 8.499999998561741e-08
iB00_2676_v n1_311226_491408 0 -2.9000000001361667e-07
iB00_2677_v n1_289034_488622 0 0.08116249999999998
iB00_2678_v n1_289034_488064 0 5.499999999707128e-08
iB00_2679_v n1_311226_488622 0 0.08219905
iB00_2680_v n1_311226_488064 0 8.500000001568708e-08
iB00_2681_v n1_289034_484720 0 1.2999999999977683e-07
iB00_2682_v n1_289034_481376 0 2.4999999997683126e-07
iB00_2683_v n1_311226_484720 0 -8.500000001272247e-08
iB00_2684_v n1_311226_481376 0 -1.6000000000092258e-07
iB00_2685_v n1_289034_478032 0 -8.499999998138225e-08
iB00_2686_v n1_289034_474688 0 1.2500000001552068e-07
iB00_2687_v n1_311226_478032 0 -1.4499999998981473e-07
iB00_2688_v n1_311226_474688 0 4.550000000058893e-07
iB00_2689_v n1_289034_471344 0 -1.0000000001673641e-07
iB00_2690_v n1_289034_468000 0 -2.7999999999248244e-07
iB00_2691_v n1_311226_471344 0 -3.75000000019457e-07
iB00_2692_v n1_311226_468000 0 3.799999999977839e-07
iB00_2693_v n1_289034_466126 0 0.08116600000000002
iB00_2694_v n1_289034_464656 0 -1.6000000001119286e-07
iB00_2695_v n1_311226_466126 0 0.08134995
iB00_2696_v n1_311226_464656 0 -4.000000001190382e-08
iB00_2697_v n1_289034_461312 0 2.2000000000226117e-07
iB00_2698_v n1_289034_457968 0 -3.149999999881546e-07
iB00_2699_v n1_311226_461312 0 2.300000000025372e-07
iB00_2700_v n1_311226_457968 0 5.0000000021814855e-08
iB00_2701_v n1_289034_454624 0 2.149999999684536e-07
iB00_2702_v n1_289034_451280 0 -1.6999999999833988e-07
iB00_2703_v n1_311226_454624 0 -6.999999999134435e-08
iB00_2704_v n1_311226_451280 0 -1.3999999998692386e-07
iB00_2705_v n1_289034_447936 0 4.000000000788041e-08
iB00_2706_v n1_289034_444592 0 3.3999999999667976e-07
iB00_2707_v n1_311226_447936 0 3.2499999997530164e-07
iB00_2708_v n1_311226_444592 0 -1.6999999999886928e-07
iB00_2709_v n1_289034_444238 0 0.0819655
iB00_2710_v n1_289034_441248 0 -3.6500000003230997e-07
iB00_2711_v n1_311226_444238 0 0.08151520000000001
iB00_2712_v n1_311226_441248 0 -1.5500000001740758e-07
iB00_2713_v n1_289034_437904 0 1.3000000000443551e-07
iB00_2714_v n1_289034_434560 0 2.1500000000826414e-07
iB00_2715_v n1_311226_437904 0 1.8000000001259196e-07
iB00_2716_v n1_311226_434560 0 4.9999999998944965e-08
iB00_2717_v n1_289034_431216 0 -1.2000000000331244e-07
iB00_2718_v n1_289034_427872 0 1.2500000001552068e-07
iB00_2719_v n1_311226_431216 0 -6.000000000419732e-08
iB00_2720_v n1_311226_427872 0 -1.4999999996295358e-07
iB00_2721_v n1_289034_424528 0 -5.500000003772886e-08
iB00_2722_v n1_289034_421742 0 0.08294650000000003
iB00_2723_v n1_311226_424528 0 2.7999999999248244e-07
iB00_2724_v n1_311226_421742 0 0.08177650000000002
iB00_2725_v n1_289034_421184 0 1.7999999998167526e-07
iB00_2726_v n1_289034_417840 0 -2.549999999839573e-07
iB00_2727_v n1_311226_421184 0 -3.000000001565119e-08
iB00_2728_v n1_311226_417840 0 -1.750000000019719e-07
iB00_2729_v n1_289034_414496 0 3.5999999998452634e-07
iB00_2730_v n1_289034_411152 0 -4.5999999997796935e-07
iB00_2731_v n1_311226_414496 0 2.100000000011381e-07
iB00_2732_v n1_311226_411152 0 1.200000000035242e-07
iB00_2733_v n1_289034_407808 0 2.650000000062562e-07
iB00_2734_v n1_289034_404464 0 4.000000002990327e-08
iB00_2735_v n1_311226_407808 0 -4.299999999894232e-07
iB00_2736_v n1_311226_404464 0 6.49999999963944e-08
iB00_2737_v n1_289034_401120 0 -1.4500000003386045e-07
iB00_2738_v n1_289034_399854 0 0.08057750000000005
iB00_2739_v n1_311226_401120 0 1.0999999996703751e-07
iB00_2740_v n1_311226_399854 0 0.08202929999999999
iB00_2741_v n1_289034_397776 0 2.4999999991584488e-08
iB00_2742_v n1_289034_394432 0 -1.2500000001552068e-07
iB00_2743_v n1_311226_397776 0 4.749999999993475e-08
iB00_2744_v n1_311226_394432 0 -2.574999999870968e-07
iB00_2745_v n1_289034_391088 0 3.049999999963489e-07
iB00_2746_v n1_289034_387744 0 -1.5999999999764033e-07
iB00_2747_v n1_311226_391088 0 -2.0000000014951634e-08
iB00_2748_v n1_311226_387744 0 2.510000000142342e-07
iB00_2749_v n1_289034_384400 0 9.999999999429004e-09
iB00_2750_v n1_289034_381056 0 -1.6500000000476637e-07
iB00_2751_v n1_311226_384400 0 4.749999999993475e-08
iB00_2752_v n1_311226_381056 0 -1.389999999971136e-07
iB00_2753_v n1_289034_377712 0 3.5000000000182624e-07
iB00_2754_v n1_289034_377358 0 0.08168949999999997
iB00_2755_v n1_311226_377712 0 1.7199999999034828e-07
iB00_2756_v n1_311226_377358 0 0.07966675000000001
iB00_2757_v n1_289034_374368 0 -1.1499999999406882e-07
iB00_2758_v n1_289034_371024 0 1.7000000000511615e-07
iB00_2759_v n1_311226_374368 0 1.4850000000293448e-07
iB00_2760_v n1_311226_371024 0 -3.2500000000383607e-07
iB00_2761_v n1_289034_367680 0 8.999999999697862e-08
iB00_2762_v n1_289034_364336 0 1.150000000012686e-07
iB00_2763_v n1_311226_367680 0 2.0749999999757508e-07
iB00_2764_v n1_311226_364336 0 2.5149999999826024e-07
iB00_2765_v n1_289034_360992 0 -2.8500000000087903e-07
iB00_2766_v n1_289034_357648 0 -1.5999999999764033e-07
iB00_2767_v n1_311226_360992 0 -1.9249999999652575e-07
iB00_2768_v n1_311226_357648 0 -1.1400000000473501e-07
iB00_2769_v n1_289034_355470 0 0.08155165
iB00_2770_v n1_289034_354304 0 5.000000000349777e-09
iB00_2771_v n1_311226_355470 0 0.08132095
iB00_2772_v n1_311226_354304 0 -1.6999999997875224e-08
iB00_2773_v n1_289034_350960 0 9.99999999985252e-09
iB00_2774_v n1_289034_347616 0 -1.0000000004087685e-08
iB00_2775_v n1_311226_350960 0 -2.2500000001573995e-08
iB00_2776_v n1_311226_347616 0 1.7000000002851543e-08
iB00_2777_v n1_289034_344272 0 5.000000000349777e-09
iB00_2778_v n1_289034_340928 0 2.0000000001399107e-08
iB00_2779_v n1_311226_344272 0 9.499999999309323e-09
iB00_2780_v n1_311226_340928 0 1.20000000008077e-08
iB00_2781_v n1_289034_337584 0 -2.0000000002457898e-08
iB00_2782_v n1_289034_334240 0 6.776263578034403e-18
iB00_2783_v n1_311226_337584 0 -1.2000000002872343e-08
iB00_2784_v n1_311226_334240 0 -4.499999997953695e-09
iB00_2785_v n1_289034_332974 0 0.08163134999999999
iB00_2786_v n1_289034_330896 0 -3.500000000583657e-08
iB00_2787_v n1_311226_332974 0 0.08270565
iB00_2788_v n1_311226_330896 0 1.4499999996482726e-08
iB00_2789_v n1_289034_327552 0 3.8116482626443515e-18
iB00_2790_v n1_289034_324208 0 2.5000000001748884e-08
iB00_2791_v n1_311226_327552 0 2.3500000004354456e-08
iB00_2792_v n1_311226_324208 0 -1.5000000004331583e-08
iB00_2793_v n1_289034_320864 0 4.999999999714502e-09
iB00_2794_v n1_289034_317520 0 0.0
iB00_2795_v n1_311226_320864 0 7.000000005910698e-09
iB00_2796_v n1_311226_317520 0 -9.000000002154257e-09
iB00_2797_v n1_289034_314176 0 -1.4999999998296473e-08
iB00_2798_v n1_289034_311086 0 0.08301534999999999
iB00_2799_v n1_311226_314176 0 -5.000000000349777e-09
iB00_2800_v n1_311226_311086 0 0.08272644999999999
iB00_2801_v n1_289034_310832 0 -2.1500000000275842e-07
iB00_2802_v n1_289034_307488 0 -1.5000000007825594e-08
iB00_2803_v n1_311226_310832 0 7.15000000124557e-08
iB00_2804_v n1_311226_307488 0 -5.249999999933161e-08
iB00_2805_v n1_289034_304144 0 2.549999999949687e-07
iB00_2806_v n1_289034_300800 0 6.000000000419732e-08
iB00_2807_v n1_311226_304144 0 -3.350000000166588e-08
iB00_2808_v n1_311226_300800 0 1.1999999998462478e-07
iB00_2809_v n1_289034_297456 0 -1.3000000000930595e-07
iB00_2810_v n1_289034_294112 0 1.4499999998981473e-07
iB00_2811_v n1_311226_297456 0 -8.849999998518463e-08
iB00_2812_v n1_311226_294112 0 -1.5649999998647935e-07
iB00_2813_v n1_289034_290768 0 -1.5999999999234637e-07
iB00_2814_v n1_289034_288590 0 0.0792215
iB00_2815_v n1_311226_290768 0 -7.450000001402082e-08
iB00_2816_v n1_311226_288590 0 0.08100735000000003
iB00_2817_v n1_289034_287424 0 4.3499999999909036e-07
iB00_2818_v n1_289034_284080 0 -1.0999999999414256e-07
iB00_2819_v n1_311226_287424 0 3.280000000039718e-07
iB00_2820_v n1_311226_284080 0 4.500000007006359e-09
iB00_2821_v n1_289034_280736 0 -2.6500000002065575e-07
iB00_2822_v n1_289034_277392 0 -4.999999993573513e-09
iB00_2823_v n1_311226_280736 0 -1.675000000083294e-07
iB00_2824_v n1_311226_277392 0 -1.8899999998562946e-07
iB00_2825_v n1_289034_274048 0 1.8999999998279833e-07
iB00_2826_v n1_289034_270704 0 -1.599999999840878e-07
iB00_2827_v n1_311226_274048 0 4.405000000016774e-07
iB00_2828_v n1_311226_270704 0 -2.7800000001476773e-07
iB00_2829_v n1_289034_267360 0 -3.999999999390437e-08
iB00_2830_v n1_289034_266702 0 0.081669
iB00_2831_v n1_311226_267360 0 1.6100000000719705e-07
iB00_2832_v n1_311226_266702 0 0.08311560000000003
iB00_2833_v n1_289034_264016 0 1.7499999998513713e-07
iB00_2834_v n1_289034_260672 0 1.7500000000546592e-07
iB00_2835_v n1_311226_264016 0 4.185000000082699e-07
iB00_2836_v n1_311226_260672 0 -1.8000000005367306e-08
iB00_2837_v n1_289034_257328 0 -3.149999999978955e-07
iB00_2838_v n1_289034_253984 0 2.300000000025372e-07
iB00_2839_v n1_311226_257328 0 -3.299999999824277e-07
iB00_2840_v n1_311226_253984 0 -5.499999999865947e-08
iB00_2841_v n1_289034_250640 0 -1.800000000007335e-07
iB00_2842_v n1_289034_247296 0 -2.999999998854613e-08
iB00_2843_v n1_311226_250640 0 2.999999999667765e-07
iB00_2844_v n1_311226_247296 0 -2.9999999998890523e-07
iB00_2845_v n1_289034_244814 0 0.083229
iB00_2846_v n1_289034_243952 0 2.3500000000966324e-07
iB00_2847_v n1_311226_244814 0 0.08217424999999999
iB00_2848_v n1_311226_243952 0 2.2999999997934968e-07
iB00_2849_v n1_289034_240608 0 -2.1499999999555864e-07
iB00_2850_v n1_289034_237264 0 -1.199999999812896e-07
iB00_2851_v n1_311226_240608 0 -1.199999999812896e-07
iB00_2852_v n1_311226_237264 0 6.500000001460561e-08
iB00_2853_v n1_289034_233920 0 -1.0000000031616256e-08
iB00_2854_v n1_289034_230576 0 8.500000001272247e-08
iB00_2855_v n1_311226_233920 0 -1.9499999997975997e-07
iB00_2856_v n1_311226_230576 0 1.0499999996509954e-07
iB00_2857_v n1_289034_227232 0 1.399999999852298e-07
iB00_2858_v n1_289034_223888 0 1.150000000012686e-07
iB00_2859_v n1_311226_227232 0 -4.999999952915932e-09
iB00_2860_v n1_311226_223888 0 -9.999999994346806e-09
iB00_2861_v n1_289034_222318 0 0.07923
iB00_2862_v n1_289034_220544 0 1.3499999997556265e-07
iB00_2863_v n1_311226_222318 0 0.08043164999999998
iB00_2864_v n1_311226_220544 0 -3.000000001533355e-08
iB00_2865_v n1_289034_217200 0 -2.8499999998775e-07
iB00_2866_v n1_289034_213856 0 1.849999999655079e-07
iB00_2867_v n1_311226_217200 0 -3.199999999681756e-07
iB00_2868_v n1_311226_213856 0 3.999999997558728e-08
iB00_2869_v n1_289034_210512 0 3.5000000018118547e-08
iB00_2870_v n1_289034_207168 0 -2.400000000167893e-07
iB00_2871_v n1_311226_210512 0 7.499999999847039e-08
iB00_2872_v n1_311226_207168 0 -1.8499999999293059e-07
iB00_2873_v n1_289034_203824 0 3.800000000045602e-07
iB00_2874_v n1_289034_200480 0 -1.199999999812896e-07
iB00_2875_v n1_311226_203824 0 2.5999999999108334e-07
iB00_2876_v n1_311226_200480 0 -5.50000000258704e-08
iB00_2877_v n1_289034_200430 0 0.0818015
iB00_2878_v n1_289034_197136 0 1.0500000001412158e-07
iB00_2879_v n1_311226_200430 0 0.08526520000000001
iB00_2880_v n1_311226_197136 0 -2.84999999993044e-07
iB00_2881_v n1_289034_193792 0 -1.8999999999677437e-07
iB00_2882_v n1_289034_190448 0 -7.00000000184494e-08
iB00_2883_v n1_311226_193792 0 1.2499999998841563e-07
iB00_2884_v n1_311226_190448 0 2.4000000002610665e-07
iB00_2885_v n1_289034_187104 0 -4.9999999893383484e-09
iB00_2886_v n1_289034_183760 0 2.999999996144108e-08
iB00_2887_v n1_311226_187104 0 1.000000001425208e-08
iB00_2888_v n1_311226_183760 0 -7.999999998484412e-08
iB00_2889_v n1_289034_180416 0 4.5000000018394584e-08
iB00_2890_v n1_289034_177934 0 0.08091999999999995
iB00_2891_v n1_311226_180416 0 -7.00000000184494e-08
iB00_2892_v n1_311226_177934 0 0.08038995000000002
iB00_2893_v n1_289034_177072 0 7.000000000066171e-08
iB00_2894_v n1_289034_173728 0 7.499999999847039e-08
iB00_2895_v n1_311226_177072 0 -7.00000000184494e-08
iB00_2896_v n1_311226_173728 0 -2.999999997457009e-08
iB00_2897_v n1_289034_170384 0 9.999999999979575e-08
iB00_2898_v n1_289034_167040 0 -3.699999999852259e-07
iB00_2899_v n1_311226_170384 0 6.999999999134435e-08
iB00_2900_v n1_311226_167040 0 2.500000000223593e-07
iB00_2901_v n1_289034_163696 0 1.7999999999861592e-07
iB00_2902_v n1_289034_160352 0 -2.6500000002531443e-07
iB00_2903_v n1_311226_163696 0 -5.000000034231095e-09
iB00_2904_v n1_311226_160352 0 -1.699999999738818e-07
iB00_2905_v n1_289034_157008 0 2.950000000244485e-07
iB00_2906_v n1_289034_156046 0 0.08235950000000002
iB00_2907_v n1_311226_157008 0 -2.500000000039363e-07
iB00_2908_v n1_311226_156046 0 0.08261799999999997
iB00_2909_v n1_289034_153664 0 -1.800000000286856e-07
iB00_2910_v n1_289034_150320 0 2.1499999998115908e-07
iB00_2911_v n1_311226_153664 0 -1.6000000001119286e-07
iB00_2912_v n1_311226_150320 0 -2.49999999758085e-08
iB00_2913_v n1_289034_146976 0 -4.399999999935109e-07
iB00_2914_v n1_289034_143632 0 3.3999999999667976e-07
iB00_2915_v n1_311226_146976 0 2.500000000039363e-07
iB00_2916_v n1_311226_143632 0 1.849999999771546e-07
iB00_2917_v n1_289034_140288 0 2.0000000001822623e-08
iB00_2918_v n1_289034_136944 0 7.000000004555446e-08
iB00_2919_v n1_311226_140288 0 -1.9999999998688602e-07
iB00_2920_v n1_311226_136944 0 1.3000000001502343e-07
iB00_2921_v n1_289034_133600 0 -3.000000000209866e-08
iB00_2922_v n1_289034_133550 0 0.08000349999999999
iB00_2923_v n1_311226_133600 0 -3.1000000000813363e-07
iB00_2924_v n1_311226_133550 0 0.08505884999999999
iB00_2925_v n1_289034_130256 0 -4.099999999897182e-07
iB00_2926_v n1_289034_126912 0 1.4000000000979375e-07
iB00_2927_v n1_311226_130256 0 -8.499999998561741e-08
iB00_2928_v n1_311226_126912 0 2.449999999986102e-07
iB00_2929_v n1_289034_123568 0 4.5000000003995024e-08
iB00_2930_v n1_289034_120224 0 -1.7500000000546592e-07
iB00_2931_v n1_311226_123568 0 -2.1500000000826414e-07
iB00_2932_v n1_311226_120224 0 -4.9999999758917e-09
iB00_2933_v n1_289034_116880 0 4.999999997808678e-09
iB00_2934_v n1_289034_113536 0 9.49999999998695e-08
iB00_2935_v n1_311226_116880 0 3.599999999709738e-07
iB00_2936_v n1_266538_111662 0 0.08082600000000006
iB00_2937_v n1_311226_113536 0 -1.3999999999412364e-07
iB00_2938_v n1_289034_111662 0 0.08229500000000002
iB00_2939_v n1_289034_110192 0 1.3499999998742112e-07
iB00_2940_v n1_311226_111662 0 0.08276649999999997
iB00_2941_v n1_266538_110192 0 -4.000000000364525e-08
iB00_2942_v n1_266538_106848 0 3.4999999995926283e-07
iB00_2943_v n1_244346_110192 0 -2.0000000001399107e-07
iB00_2944_v n1_244346_106848 0 9.999999994092696e-08
iB00_2945_v n1_244346_103504 0 -1.4999999988852056e-07
iB00_2946_v n1_221850_106848 0 4.9999999962840186e-08
iB00_2947_v n1_266538_103504 0 -3.59999999975209e-07
iB00_2948_v n1_266538_100160 0 3.450000000038058e-07
iB00_2949_v n1_289034_100160 0 3.5000000001093184e-07
iB00_2950_v n1_289034_103504 0 -3.1500000001525967e-07
iB00_2951_v n1_311226_103504 0 -2.300000000025372e-07
iB00_2952_v n1_289034_106848 0 -5.5000000009776775e-08
iB00_2953_v n1_311226_106848 0 -8.499999998561741e-08
iB00_2954_v n1_333722_106848 0 6.000000000419732e-08
iB00_2955_v n1_311226_110192 0 1.2500000000535629e-07
iB00_2956_v n1_333722_110192 0 2.849999999996085e-07
iB00_2957_v n1_355914_110192 0 5.499999999198908e-08
iB00_2958_v n1_333722_111662 0 0.08071585000000002
iB00_2959_v n1_333722_113536 0 -3.2000000004949077e-07
iB00_2960_v n1_355914_111662 0 0.08209015000000001
iB00_2961_v n1_355914_113536 0 -9.999999991805708e-09
iB00_2962_v n1_333722_116880 0 1.750000000101246e-07
iB00_2963_v n1_333722_120224 0 2.4999999981420093e-08
iB00_2964_v n1_355914_116880 0 -4.9999999962840186e-08
iB00_2965_v n1_355914_120224 0 -1.0000000000996015e-07
iB00_2966_v n1_333722_123568 0 -2.5499999997908686e-07
iB00_2967_v n1_333722_126912 0 3.3999999999667976e-07
iB00_2968_v n1_355914_123568 0 3.1000000000813363e-07
iB00_2969_v n1_355914_126912 0 1.549999999854321e-07
iB00_2970_v n1_333722_130256 0 -1.7500000000673647e-07
iB00_2971_v n1_333722_133550 0 0.08157770000000002
iB00_2972_v n1_355914_130256 0 -1.0000000000699553e-07
iB00_2973_v n1_355914_133550 0 0.08015044999999997
iB00_2974_v n1_333722_133600 0 1.9000000001445619e-07
iB00_2975_v n1_333722_136944 0 -1.0999999999414256e-07
iB00_2976_v n1_355914_133600 0 1.2500000001552068e-07
iB00_2977_v n1_355914_136944 0 -2.600000000059064e-07
iB00_2978_v n1_333722_140288 0 4.999999994526425e-09
iB00_2979_v n1_333722_143632 0 2.5000000008525147e-08
iB00_2980_v n1_355914_140288 0 2.300000000025372e-07
iB00_2981_v n1_355914_143632 0 -3.650000000378157e-07
iB00_2982_v n1_333722_146976 0 -2.499999999020806e-08
iB00_2983_v n1_333722_150320 0 -1.4999999999694077e-07
iB00_2984_v n1_355914_146976 0 -2.4999999981420093e-08
iB00_2985_v n1_355914_150320 0 3.000000000099752e-07
iB00_2986_v n1_333722_153664 0 1.6499999997850835e-07
iB00_2987_v n1_333722_156046 0 0.08145840000000001
iB00_2988_v n1_355914_153664 0 -3.6500000003230997e-07
iB00_2989_v n1_355914_156046 0 0.0815426
iB00_2990_v n1_333722_157008 0 -1.000000002748697e-08
iB00_2991_v n1_333722_160352 0 -4.49999999828192e-08
iB00_2992_v n1_355914_157008 0 1.6000000001119286e-07
iB00_2993_v n1_355914_160352 0 -1.5000000002637517e-07
iB00_2994_v n1_333722_163696 0 3.6999999999570793e-07
iB00_2995_v n1_333722_167040 0 -2.6699999999021777e-07
iB00_2996_v n1_355914_163696 0 1.3500000002977276e-07
iB00_2997_v n1_355914_167040 0 2.6999999993122003e-08
iB00_2998_v n1_333722_170384 0 5.699999998367984e-08
iB00_2999_v n1_333722_173728 0 -1.6399999999520964e-07
iB00_3000_v n1_355914_170384 0 4.7999999997936846e-08
iB00_3001_v n1_355914_173728 0 -2.959999999961005e-07
iB00_3002_v n1_333722_177072 0 7.500000000662308e-08
iB00_3003_v n1_333722_177934 0 0.08138980000000001
iB00_3004_v n1_355914_177072 0 2.4999999981420093e-08
iB00_3005_v n1_355914_177934 0 0.08360374999999998
iB00_3006_v n1_333722_180416 0 1.3800000002000882e-07
iB00_3007_v n1_333722_183760 0 -4.550000000792635e-08
iB00_3008_v n1_355914_180416 0 1.1700000002038205e-07
iB00_3009_v n1_355914_183760 0 1.8549999998383878e-07
iB00_3010_v n1_333722_187104 0 2.3499999995735896e-07
iB00_3011_v n1_333722_190448 0 -3.7999999983684765e-08
iB00_3012_v n1_355914_187104 0 -1.150000000012686e-07
iB00_3013_v n1_355914_190448 0 -3.0699999998200456e-07
iB00_3014_v n1_333722_193792 0 1.4450000000303582e-07
iB00_3015_v n1_333722_197136 0 -2.354999999805603e-07
iB00_3016_v n1_355914_193792 0 8.050000000359853e-08
iB00_3017_v n1_355914_197136 0 1.550000000858055e-08
iB00_3018_v n1_333722_200430 0 0.08142245000000001
iB00_3019_v n1_333722_200480 0 4.055000000060052e-07
iB00_3020_v n1_355914_200430 0 0.08097335000000001
iB00_3021_v n1_355914_200480 0 -4.3050000000203663e-07
iB00_3022_v n1_333722_203824 0 -1.9750000002450997e-07
iB00_3023_v n1_333722_207168 0 1.4950000002604373e-07
iB00_3024_v n1_355914_203824 0 2.475000000139258e-07
iB00_3025_v n1_355914_207168 0 -7.950000002284092e-08
iB00_3026_v n1_333722_210512 0 -3.400000002772594e-08
iB00_3027_v n1_333722_213856 0 -2.409999999856884e-07
iB00_3028_v n1_355914_210512 0 9.899999998388628e-08
iB00_3029_v n1_355914_213856 0 -2.2399999999347773e-07
iB00_3030_v n1_333722_217200 0 5.699999999596182e-08
iB00_3031_v n1_333722_220544 0 -1.2700000000752908e-07
iB00_3032_v n1_355914_217200 0 -3.700000001478562e-08
iB00_3033_v n1_355914_220544 0 1.5200000000716038e-07
iB00_3034_v n1_333722_222318 0 0.08063355000000001
iB00_3035_v n1_333722_223888 0 -1.5500000000406682e-07
iB00_3036_v n1_355914_222318 0 0.08093680000000002
iB00_3037_v n1_355914_223888 0 8.999999998512016e-08
iB00_3038_v n1_333722_227232 0 1.379999999997859e-07
iB00_3039_v n1_333722_230576 0 -3.49999998601469e-09
iB00_3040_v n1_355914_227232 0 -2.0799999998202465e-07
iB00_3041_v n1_355914_230576 0 -1.6500000008608153e-08
iB00_3042_v n1_333722_233920 0 -7.649999998146525e-08
iB00_3043_v n1_333722_237264 0 -5.1499999983951536e-08
iB00_3044_v n1_355914_233920 0 1.3649999996956895e-07
iB00_3045_v n1_355914_237264 0 -2.684999999818947e-07
iB00_3046_v n1_333722_240608 0 7.549999998281408e-08
iB00_3047_v n1_333722_243952 0 -1.7550000000346802e-07
iB00_3048_v n1_355914_240608 0 2.5949999999308124e-07
iB00_3049_v n1_355914_243952 0 -3.144999999846468e-07
iB00_3050_v n1_333722_244814 0 0.08317424999999999
iB00_3051_v n1_333722_247296 0 -4.1300000000314176e-07
iB00_3052_v n1_355914_244814 0 0.08100249999999999
iB00_3053_v n1_355914_247296 0 4.480000000187192e-07
iB00_3054_v n1_333722_250640 0 2.580000000047924e-07
iB00_3055_v n1_333722_253984 0 3.6000000018781425e-08
iB00_3056_v n1_355914_250640 0 6.999999999134435e-09
iB00_3057_v n1_355914_253984 0 -2.0999999993803414e-08
iB00_3058_v n1_333722_257328 0 -1.1000000003088262e-07
iB00_3059_v n1_333722_260672 0 -1.9099999999574319e-07
iB00_3060_v n1_355914_257328 0 -1.0999999999414256e-07
iB00_3061_v n1_355914_260672 0 -2.3100000001950547e-07
iB00_3062_v n1_333722_264016 0 2.6550000002268125e-07
iB00_3063_v n1_333722_266702 0 0.08078249999999998
iB00_3064_v n1_355914_264016 0 1.3099999999154587e-07
iB00_3065_v n1_355914_266702 0 0.08047240000000003
iB00_3066_v n1_333722_267360 0 3.105000000027476e-07
iB00_3067_v n1_333722_270704 0 -2.679999999997745e-07
iB00_3068_v n1_355914_267360 0 -1.2150000001595346e-07
iB00_3069_v n1_355914_270704 0 2.1600000000172723e-07
iB00_3070_v n1_333722_274048 0 1.6150000001070487e-07
iB00_3071_v n1_333722_277392 0 1.0500000000056905e-07
iB00_3072_v n1_355914_274048 0 6.799999999933595e-08
iB00_3073_v n1_355914_277392 0 -5.599999999667537e-08
iB00_3074_v n1_333722_280736 0 6.84999999915147e-08
iB00_3075_v n1_333722_284080 0 -4.425000000072383e-07
iB00_3076_v n1_355914_280736 0 -1.6599999998721804e-07
iB00_3077_v n1_355914_284080 0 2.3800000000678144e-07
iB00_3078_v n1_333722_287424 0 7.649999999951764e-08
iB00_3079_v n1_333722_288590 0 0.0814773
iB00_3080_v n1_355914_287424 0 1.6049999999564243e-07
iB00_3081_v n1_355914_288590 0 0.08161634999999999
iB00_3082_v n1_333722_290768 0 -1.4499999999865564e-07
iB00_3083_v n1_333722_294112 0 5.0999999999501965e-08
iB00_3084_v n1_355914_290768 0 7.950000000759433e-08
iB00_3085_v n1_355914_294112 0 7.549999998948446e-08
iB00_3086_v n1_333722_297456 0 -2.3450000000297906e-07
iB00_3087_v n1_333722_300800 0 -1.1999999992707948e-08
iB00_3088_v n1_355914_297456 0 8.800000001428759e-08
iB00_3089_v n1_355914_300800 0 -3.880000000031928e-07
iB00_3090_v n1_333722_304144 0 2.0650000000061797e-07
iB00_3091_v n1_333722_307488 0 -9.15000000138548e-08
iB00_3092_v n1_355914_304144 0 1.520000000025017e-07
iB00_3093_v n1_355914_307488 0 2.0399999999366681e-07
iB00_3094_v n1_333722_310832 0 8.150000000997888e-08
iB00_3095_v n1_333722_311086 0 0.07991465
iB00_3096_v n1_355914_310832 0 -2.2799999998342375e-07
iB00_3097_v n1_355914_311086 0 0.0804568
iB00_3098_v n1_333722_314176 0 -1.849999999913424e-08
iB00_3099_v n1_333722_317520 0 9.499999995921191e-09
iB00_3100_v n1_355914_314176 0 8.499999999916994e-09
iB00_3101_v n1_355914_317520 0 -5.000000027666589e-10
iB00_3102_v n1_333722_320864 0 7.000000001516715e-09
iB00_3103_v n1_333722_324208 0 -2.1500000002181666e-08
iB00_3104_v n1_355914_320864 0 -4.000000000957448e-09
iB00_3105_v n1_355914_324208 0 2.150000000059348e-08
iB00_3106_v n1_333722_327552 0 2.9499999999014364e-08
iB00_3107_v n1_333722_330896 0 -3.649999999645473e-08
iB00_3108_v n1_355914_327552 0 -7.999999998526764e-09
iB00_3109_v n1_355914_330896 0 -8.000000001597258e-09
iB00_3110_v n1_333722_332974 0 0.08262875
iB00_3111_v n1_333722_334240 0 1.0499999998701652e-08
iB00_3112_v n1_355914_332974 0 0.08378659999999999
iB00_3113_v n1_355914_334240 0 -1.0999999998291937e-08
iB00_3114_v n1_333722_337584 0 -1.1499999997670465e-08
iB00_3115_v n1_333722_340928 0 -2.2499999998185864e-08
iB00_3116_v n1_355914_337584 0 3.350000000166588e-08
iB00_3117_v n1_355914_340928 0 -2.950000000208486e-08
iB00_3118_v n1_333722_344272 0 -5.000000001779145e-09
iB00_3119_v n1_333722_347616 0 8.00000000022083e-09
iB00_3120_v n1_355914_344272 0 3.050000000348889e-08
iB00_3121_v n1_355914_347616 0 5.000000000773293e-09
iB00_3122_v n1_333722_350960 0 3.1500000000446e-08
iB00_3123_v n1_333722_354304 0 -1.8500000002310613e-08
iB00_3124_v n1_355914_350960 0 -2.89999999993182e-08
iB00_3125_v n1_355914_354304 0 2.5500000001974444e-08
iB00_3126_v n1_333722_355470 0 0.08210459999999999
iB00_3127_v n1_333722_357648 0 4.274999999994127e-07
iB00_3128_v n1_355914_355470 0 0.08085799999999999
iB00_3129_v n1_355914_357648 0 -2.8499999989881156e-08
iB00_3130_v n1_333722_360992 0 -4.1649999999439746e-07
iB00_3131_v n1_333722_364336 0 3.1100000000413783e-07
iB00_3132_v n1_355914_360992 0 7.89999999960397e-08
iB00_3133_v n1_355914_364336 0 -2.274999999959037e-07
iB00_3134_v n1_333722_367680 0 9.550000000141854e-08
iB00_3135_v n1_333722_371024 0 -7.950000000081807e-08
iB00_3136_v n1_355914_367680 0 6.199999998942945e-08
iB00_3137_v n1_355914_371024 0 -4.04999999947652e-08
iB00_3138_v n1_333722_374368 0 -2.2850000000493102e-07
iB00_3139_v n1_333722_377358 0 0.07976975
iB00_3140_v n1_355914_374368 0 -2.0000000001399107e-08
iB00_3141_v n1_355914_377358 0 0.08262799999999998
iB00_3142_v n1_333722_377712 0 -9.499999999902246e-08
iB00_3143_v n1_333722_381056 0 6.999999999134435e-08
iB00_3144_v n1_355914_377712 0 -6.200000000975824e-08
iB00_3145_v n1_355914_381056 0 -8.099999998000128e-08
iB00_3146_v n1_333722_384400 0 2.4600000001123743e-07
iB00_3147_v n1_333722_387744 0 -5.3500000003064985e-08
iB00_3148_v n1_355914_384400 0 2.1499999995405403e-08
iB00_3149_v n1_355914_387744 0 -2.72500000004028e-07
iB00_3150_v n1_333722_391088 0 -3.1549999999409765e-07
iB00_3151_v n1_333722_394432 0 -2.449999999697052e-08
iB00_3152_v n1_355914_391088 0 2.0499999999401206e-08
iB00_3153_v n1_355914_394432 0 3.7699999999516e-07
iB00_3154_v n1_333722_397776 0 3.3149999998913947e-07
iB00_3155_v n1_333722_399854 0 0.08249965000000002
iB00_3156_v n1_355914_397776 0 -2.1899999999228092e-07
iB00_3157_v n1_355914_399854 0 0.08126755
iB00_3158_v n1_333722_401120 0 -1.9400000000789622e-07
iB00_3159_v n1_333722_404464 0 -6.999999999134435e-08
iB00_3160_v n1_355914_401120 0 -3.4599999999981e-07
iB00_3161_v n1_355914_404464 0 2.1999999997896776e-07
iB00_3162_v n1_333722_407808 0 1.4000000001381716e-07
iB00_3163_v n1_333722_411152 0 -6.450000001332126e-08
iB00_3164_v n1_355914_407808 0 -1.89999999999739e-07
iB00_3165_v n1_355914_411152 0 4.245000000308819e-07
iB00_3166_v n1_333722_414496 0 3.2000000000046873e-07
iB00_3167_v n1_333722_417840 0 -2.1200000002025154e-07
iB00_3168_v n1_355914_414496 0 -4.350000000236543e-07
iB00_3169_v n1_355914_417840 0 2.4200000002319724e-07
iB00_3170_v n1_333722_421184 0 -1.5600000000134156e-07
iB00_3171_v n1_333722_421742 0 0.0819149
iB00_3172_v n1_355914_421184 0 -4.3999999986815e-08
iB00_3173_v n1_355914_421742 0 0.08128309999999998
iB00_3174_v n1_333722_424528 0 1.8850000001092077e-07
iB00_3175_v n1_333722_427872 0 5.3500000003064985e-08
iB00_3176_v n1_355914_424528 0 3.649999998967847e-08
iB00_3177_v n1_355914_427872 0 -2.7849999998619417e-07
iB00_3178_v n1_333722_431216 0 -8.999999996330906e-09
iB00_3179_v n1_333722_434560 0 5.00000000712604e-09
iB00_3180_v n1_355914_431216 0 -4.600000000592845e-08
iB00_3181_v n1_355914_434560 0 2.2999999998199665e-07
iB00_3182_v n1_333722_437904 0 8.849999999640782e-08
iB00_3183_v n1_333722_441248 0 -2.714999999993417e-07
iB00_3184_v n1_355914_437904 0 5.650000001818263e-08
iB00_3185_v n1_355914_441248 0 -6.350000000630564e-08
iB00_3186_v n1_333722_444238 0 0.08146985000000001
iB00_3187_v n1_333722_444592 0 2.384999999685729e-07
iB00_3188_v n1_355914_444238 0 0.08144795
iB00_3189_v n1_355914_444592 0 2.0650000001554692e-07
iB00_3190_v n1_333722_447936 0 -8.249999999603044e-08
iB00_3191_v n1_333722_451280 0 1.4200000000180214e-07
iB00_3192_v n1_355914_447936 0 -1.4749999997982523e-07
iB00_3193_v n1_355914_451280 0 6.299999999919793e-08
iB00_3194_v n1_333722_454624 0 -8.599999999707996e-08
iB00_3195_v n1_333722_457968 0 -2.7949999999448034e-07
iB00_3196_v n1_355914_454624 0 -1.5399999998095756e-07
iB00_3197_v n1_355914_457968 0 1.9449999999001645e-07
iB00_3198_v n1_333722_461312 0 5.9000000001840377e-08
iB00_3199_v n1_333722_464656 0 4.259999999783014e-07
iB00_3200_v n1_355914_461312 0 -3.7399999999634774e-07
iB00_3201_v n1_355914_464656 0 1.3899999999663713e-07
iB00_3202_v n1_333722_466126 0 0.08126219999999999
iB00_3203_v n1_333722_468000 0 -4.3899999998056605e-07
iB00_3204_v n1_355914_466126 0 0.08161435000000002
iB00_3205_v n1_355914_468000 0 1.4000000015209528e-08
iB00_3206_v n1_333722_471344 0 1.9749999999528734e-07
iB00_3207_v n1_333722_474688 0 -1.5049999999494287e-07
iB00_3208_v n1_355914_471344 0 2.92499999996745e-07
iB00_3209_v n1_355914_474688 0 -3.6949999999209424e-07
iB00_3210_v n1_333722_478032 0 2.049999999664835e-08
iB00_3211_v n1_333722_481376 0 2.080000000091297e-07
iB00_3212_v n1_355914_478032 0 9.500000016249982e-09
iB00_3213_v n1_355914_481376 0 -7.800000001676441e-08
iB00_3214_v n1_333722_484720 0 -8.800000000168797e-08
iB00_3215_v n1_333722_488064 0 1.2500000001552068e-07
iB00_3216_v n1_355914_484720 0 3.4299999998469236e-07
iB00_3217_v n1_355914_488064 0 -2.4499999998833994e-07
iB00_3218_v n1_333722_488622 0 0.0804907
iB00_3219_v n1_333722_491408 0 -1.0200000002610898e-07
iB00_3220_v n1_355914_488622 0 0.08035375000000003
iB00_3221_v n1_355914_491408 0 1.319999999934793e-07
iB00_3222_v n1_333722_494752 0 1.1499999984647333e-08
iB00_3223_v n1_333722_498096 0 1.7500000000546592e-07
iB00_3224_v n1_355914_494752 0 -3.6500000016783524e-08
iB00_3225_v n1_355914_498096 0 -2.699999999911476e-07
iB00_3226_v n1_333722_501440 0 -9.29999999814972e-08
iB00_3227_v n1_333722_504784 0 -2.549999999839573e-07
iB00_3228_v n1_355914_501440 0 -8.199999997049977e-08
iB00_3229_v n1_355914_504784 0 -1.207021949837378e-17
iB00_3230_v n1_333722_508128 0 1.9499999999807706e-07
iB00_3231_v n1_333722_510510 0 0.08349754999999995
iB00_3232_v n1_355914_508128 0 -4.0000000002798214e-08
iB00_3233_v n1_355914_510510 0 0.08026130000000004
iB00_3234_v n1_333722_511472 0 3.5500000003457503e-07
iB00_3235_v n1_333722_514816 0 -3.5000000001093184e-07
iB00_3236_v n1_355914_511472 0 -6.500000003842842e-08
iB00_3237_v n1_355914_514816 0 -1.549999999949612e-07
iB00_3238_v n1_333722_518160 0 7.000000001230841e-08
iB00_3239_v n1_333722_521504 0 8.999999999274345e-08
iB00_3240_v n1_355914_518160 0 1.2500000001552068e-07
iB00_3241_v n1_355914_521504 0 3.0999999999627517e-07
iB00_3242_v n1_333722_524848 0 1.9499999999034789e-07
iB00_3243_v n1_333722_528192 0 -1.3999999995558364e-07
iB00_3244_v n1_355914_524848 0 -8.000000000559643e-08
iB00_3245_v n1_355914_528192 0 -2.999999998558152e-08
iB00_3246_v n1_333722_531536 0 5.999999998736254e-08
iB00_3247_v n1_333722_532398 0 0.08152959999999998
iB00_3248_v n1_355914_531536 0 -2.710505431213761e-17
iB00_3249_v n1_355914_532398 0 0.08204480000000003
iB00_3250_v n1_333722_534880 0 -1.999999996381202e-08
iB00_3251_v n1_333722_538224 0 -3.000000001565119e-08
iB00_3252_v n1_355914_534880 0 -3.000000001565119e-08
iB00_3253_v n1_355914_538224 0 2.3500000001178083e-07
iB00_3254_v n1_333722_541568 0 4.7000000000630335e-07
iB00_3255_v n1_333722_544912 0 -4.0000000002798214e-08
iB00_3256_v n1_355914_541568 0 -2.710505431213761e-17
iB00_3257_v n1_355914_544912 0 -2.3000000000041962e-07
iB00_3258_v n1_333722_548256 0 -5.999999998513908e-08
iB00_3259_v n1_333722_551600 0 -1.0000000000699553e-07
iB00_3260_v n1_355914_548256 0 4.5000000009924254e-08
iB00_3261_v n1_355914_551600 0 -1.6000000000314604e-07
iB00_3262_v n1_333722_554894 0 0.08139669999999999
iB00_3263_v n1_333722_554944 0 -1.6999999997123483e-07
iB00_3264_v n1_355914_554894 0 0.08263379999999998
iB00_3265_v n1_355914_554944 0 5.999999998471556e-08
iB00_3266_v n1_333722_558288 0 -5.000000005008458e-09
iB00_3267_v n1_333722_561632 0 1.350000000026677e-07
iB00_3268_v n1_355914_558288 0 1.0000000000699553e-07
iB00_3269_v n1_355914_561632 0 -3.699999999907316e-07
iB00_3270_v n1_333722_564976 0 2.400000000045073e-07
iB00_3271_v n1_333722_568320 0 -2.0000000001399107e-07
iB00_3272_v n1_355914_564976 0 1.3499999997556265e-07
iB00_3273_v n1_355914_568320 0 1.1500000002583256e-07
iB00_3274_v n1_333722_571664 0 -1.7499999999424274e-07
iB00_3275_v n1_333722_575008 0 2.9500000001386056e-07
iB00_3276_v n1_355914_571664 0 4.49999999828192e-08
iB00_3277_v n1_355914_575008 0 -9.500000000961037e-08
iB00_3278_v n1_333722_576782 0 0.08218165
iB00_3279_v n1_333722_578352 0 -7.999999997849137e-08
iB00_3280_v n1_355914_576782 0 0.08207234999999996
iB00_3281_v n1_355914_578352 0 -1.0500000001412158e-07
iB00_3282_v n1_333722_581696 0 -4.500000003469997e-08
iB00_3283_v n1_355914_581696 0 1.2000000001940607e-07
iB00_3284_v n1_378410_581696 0 -1.8000000001259196e-07
iB00_3285_v n1_400602_581696 0 -5.929230630780102e-18
iB00_3286_v n1_378410_578352 0 9.000000001984851e-08
iB00_3287_v n1_400602_578352 0 2.550000000119094e-07
iB00_3288_v n1_422794_581696 0 2.710505431213761e-17
iB00_3289_v n1_445290_581696 0 3.5000000001093184e-07
iB00_3290_v n1_422794_578352 0 -3.000000000209866e-07
iB00_3291_v n1_445290_578352 0 -1.500000000155755e-07
iB00_3292_v n1_467482_581696 0 -1.4999999999694077e-07
iB00_3293_v n1_489978_581696 0 -2.999999999854112e-07
iB00_3294_v n1_467482_578352 0 9.999999997989048e-08
iB00_3295_v n1_489978_578352 0 2.9999999995830617e-07
iB00_3296_v n1_512170_581696 0 -3.5000000001093184e-07
iB00_3297_v n1_534666_581696 0 2.1000000001096368e-06
iB00_3298_v n1_512170_578352 0 2.0000000012241129e-07
iB00_3299_v n1_534666_578352 0 -4.999999999062287e-07
iB00_3300_v n1_556858_581696 0 2.900000000013135e-06
iB00_3301_v n1_579050_581696 0 1.5499999999390242e-06
iB00_3302_v n1_556858_578352 0 -2.9500000000301854e-06
iB00_3303_v n1_579050_578352 0 -1.5999999998442661e-06
iB00_3304_v n1_601546_581696 0 -2.700000000053354e-06
iB00_3305_v n1_623064_581696 0 0.0
iB00_3306_v n1_601546_578352 0 -3.4999999990251163e-07
iB00_3307_v n1_623064_585040 0 0.0
iB00_3308_v n1_625064_585040 0 -1.5000000026799132e-07
iB00_3309_v n1_627064_585040 0 0.0
iB00_3310_v n1_625064_581696 0 -2.3499999998662395e-06
iB00_3311_v n1_627064_588384 0 0.0
iB00_3312_v n1_625064_578352 0 2.799999999658856e-06
iB00_3313_v n1_627064_581696 0 0.0
iB00_3314_v n1_625064_576782 0 2.6801480868994202e-14
iB00_3315_v n1_627064_578352 0 0.0
iB00_3316_v n1_623064_578352 0 -3.3881317890172014e-18
iB00_3317_v n1_601546_576782 0 0.06699999999999957
iB00_3318_v n1_601546_575008 0 3.3000000001495375e-06
iB00_3319_v n1_579050_576782 0 0.06440000000000004
iB00_3320_v n1_556858_576782 0 0.06440500000000024
iB00_3321_v n1_579050_575008 0 1.749999999946239e-06
iB00_3322_v n1_556858_575008 0 7.499999999271056e-07
iB00_3323_v n1_534666_576782 0 0.06439999999999994
iB00_3324_v n1_512170_576782 0 0.06823849999999994
iB00_3325_v n1_534666_575008 0 1.5500000000948783e-06
iB00_3326_v n1_512170_575008 0 3.3500000001089895e-06
iB00_3327_v n1_489978_576782 0 0.0795115
iB00_3328_v n1_467482_576782 0 0.08208150000000008
iB00_3329_v n1_489978_575008 0 -5.0000000017050295e-08
iB00_3330_v n1_467482_575008 0 2.500000000344295e-07
iB00_3331_v n1_445290_576782 0 0.08012749999999993
iB00_3332_v n1_422794_576782 0 0.08160450000000005
iB00_3333_v n1_445290_575008 0 -1.0000000003410059e-07
iB00_3334_v n1_422794_575008 0 2.9999999994475364e-07
iB00_3335_v n1_400602_576782 0 0.080327
iB00_3336_v n1_378410_576782 0 0.08159650000000006
iB00_3337_v n1_400602_575008 0 2.3499999998933445e-07
iB00_3338_v n1_378410_575008 0 -2.050000000211171e-07
iB00_3339_v n1_378410_571664 0 1.5000000000583462e-07
iB00_3340_v n1_378410_568320 0 -2.4999999981420093e-08
iB00_3341_v n1_400602_571664 0 2.5000000008525147e-08
iB00_3342_v n1_400602_568320 0 -2.5000000002595917e-07
iB00_3343_v n1_378410_564976 0 2.499999999781018e-07
iB00_3344_v n1_378410_561632 0 -3.000000001565119e-08
iB00_3345_v n1_400602_564976 0 3.550000000180579e-07
iB00_3346_v n1_400602_561632 0 -1.1500000001566816e-07
iB00_3347_v n1_378410_558288 0 -3.6499999997513524e-07
iB00_3348_v n1_378410_554944 0 2.4499999999681027e-07
iB00_3349_v n1_400602_558288 0 -7.00000000184494e-08
iB00_3350_v n1_400602_554944 0 -6.999999997440369e-08
iB00_3351_v n1_378410_554894 0 0.08184099999999998
iB00_3352_v n1_378410_551600 0 3.500000002277723e-08
iB00_3353_v n1_400602_554894 0 0.08195149999999998
iB00_3354_v n1_400602_551600 0 -4.000000000169707e-07
iB00_3355_v n1_378410_548256 0 -2.5000000001748884e-07
iB00_3356_v n1_378410_544912 0 4.100000000422342e-07
iB00_3357_v n1_400602_548256 0 2.8999999997962947e-07
iB00_3358_v n1_400602_544912 0 -9.999999996379685e-08
iB00_3359_v n1_378410_541568 0 3.9999999983316456e-08
iB00_3360_v n1_378410_538224 0 -3.599999999709738e-07
iB00_3361_v n1_400602_541568 0 6.499999998421831e-08
iB00_3362_v n1_400602_538224 0 1.749999999766668e-07
iB00_3363_v n1_378410_534880 0 2.1499999998454721e-07
iB00_3364_v n1_378410_532398 0 0.0815325
iB00_3365_v n1_400602_534880 0 -2.299999999483271e-07
iB00_3366_v n1_400602_532398 0 0.08186150000000003
iB00_3367_v n1_378410_531536 0 -1.749999999897958e-07
iB00_3368_v n1_378410_528192 0 -1.000000001425208e-08
iB00_3369_v n1_400602_531536 0 5.421010862427522e-17
iB00_3370_v n1_400602_528192 0 -2.1000000006127743e-07
iB00_3371_v n1_378410_524848 0 1.900000000022801e-07
iB00_3372_v n1_378410_521504 0 -3.4999999995672174e-08
iB00_3373_v n1_400602_524848 0 1.4999999994273067e-08
iB00_3374_v n1_400602_521504 0 1.499999999876234e-07
iB00_3375_v n1_378410_518160 0 -1.6999999999346944e-07
iB00_3376_v n1_378410_514816 0 -1.6999999999833988e-07
iB00_3377_v n1_400602_518160 0 1.85000000019718e-07
iB00_3378_v n1_400602_514816 0 -4.0999999997616565e-07
iB00_3379_v n1_378410_511472 0 1.0000000010228674e-08
iB00_3380_v n1_378410_510510 0 0.08240099999999999
iB00_3381_v n1_400602_511472 0 3.299999999824277e-07
iB00_3382_v n1_400602_510510 0 0.07890650000000007
iB00_3383_v n1_378410_508128 0 4.0999999999734147e-07
iB00_3384_v n1_378410_504784 0 9.999999987147026e-09
iB00_3385_v n1_400602_508128 0 -8.000000000559643e-08
iB00_3386_v n1_400602_504784 0 -1.200000000532874e-07
iB00_3387_v n1_378410_501440 0 -2.1500000000169963e-07
iB00_3388_v n1_378410_498096 0 2.1999999998828512e-07
iB00_3389_v n1_400602_501440 0 2.2500000007672633e-07
iB00_3390_v n1_400602_498096 0 -1.9999999984458448e-08
iB00_3391_v n1_378410_494752 0 -2.050000000003648e-07
iB00_3392_v n1_378410_491408 0 -1.4999999967168012e-08
iB00_3393_v n1_400602_494752 0 -3.200000000223857e-07
iB00_3394_v n1_400602_491408 0 3.700000000521415e-07
iB00_3395_v n1_378410_488622 0 0.081896
iB00_3396_v n1_378410_488064 0 -7.499999999847039e-08
iB00_3397_v n1_400602_488622 0 0.0820035
iB00_3398_v n1_400602_488064 0 4.500000000052219e-07
iB00_3399_v n1_378410_484720 0 1.7499999999127812e-07
iB00_3400_v n1_378410_481376 0 -5.00000000712604e-09
iB00_3401_v n1_400602_484720 0 -5.5000000024176335e-08
iB00_3402_v n1_400602_481376 0 -9.99999998545296e-09
iB00_3403_v n1_378410_478032 0 -1.350000000001266e-07
iB00_3404_v n1_378410_474688 0 2.5999999999108334e-07
iB00_3405_v n1_400602_478032 0 -4.050000000080031e-07
iB00_3406_v n1_400602_474688 0 2.6999999998034794e-07
iB00_3407_v n1_378410_471344 0 -3.299999999923803e-07
iB00_3408_v n1_378410_468000 0 8.499999998561741e-08
iB00_3409_v n1_400602_471344 0 1.5000000048483175e-08
iB00_3410_v n1_400602_468000 0 -1.6499999999629604e-07
iB00_3411_v n1_378410_466126 0 0.07998249999999998
iB00_3412_v n1_378410_464656 0 1.4000000000979375e-07
iB00_3413_v n1_400602_466126 0 0.08122599999999999
iB00_3414_v n1_400602_464656 0 -2.799999999704596e-07
iB00_3415_v n1_378410_461312 0 -4.399999999913933e-07
iB00_3416_v n1_378410_457968 0 4.600000000050744e-07
iB00_3417_v n1_400602_461312 0 7.499999999847039e-08
iB00_3418_v n1_400602_457968 0 1.999999998911713e-08
iB00_3419_v n1_378410_454624 0 -1.6500000000222527e-07
iB00_3420_v n1_378410_451280 0 -2.9500000001386056e-07
iB00_3421_v n1_400602_454624 0 5.5000000024176335e-08
iB00_3422_v n1_400602_451280 0 1.8499999996762548e-07
iB00_3423_v n1_378410_447936 0 5.5000000014647214e-08
iB00_3424_v n1_378410_444592 0 3.9499999999375104e-07
iB00_3425_v n1_400602_447936 0 -8.000000000559643e-08
iB00_3426_v n1_400602_444592 0 -2.4999999999716005e-07
iB00_3427_v n1_378410_444238 0 0.08138100000000001
iB00_3428_v n1_378410_441248 0 -3.099999999810286e-07
iB00_3429_v n1_400602_444238 0 0.0826245
iB00_3430_v n1_400602_441248 0 -7.000000003539006e-08
iB00_3431_v n1_378410_437904 0 3.3499999999590647e-07
iB00_3432_v n1_378410_434560 0 -2.499999995431504e-08
iB00_3433_v n1_400602_437904 0 4.0000000002798214e-08
iB00_3434_v n1_400602_434560 0 2.69999999995171e-07
iB00_3435_v n1_378410_431216 0 -3.799999999969369e-07
iB00_3436_v n1_378410_427872 0 2.7500000001246146e-07
iB00_3437_v n1_400602_431216 0 -3.8500000003370907e-07
iB00_3438_v n1_400602_427872 0 7.999999999882016e-08
iB00_3439_v n1_378410_424528 0 -7.000000000108523e-08
iB00_3440_v n1_378410_421742 0 0.08113599999999999
iB00_3441_v n1_400602_424528 0 1.8499999999261295e-07
iB00_3442_v n1_400602_421742 0 0.08224599999999999
iB00_3443_v n1_378410_421184 0 2.45000000002316e-07
iB00_3444_v n1_378410_417840 0 -2.0000000001399107e-07
iB00_3445_v n1_400602_421184 0 8.999999999274345e-08
iB00_3446_v n1_400602_417840 0 -2.4999999995396137e-08
iB00_3447_v n1_378410_414496 0 -1.299999999999886e-07
iB00_3448_v n1_378410_411152 0 -3.000000004275624e-08
iB00_3449_v n1_400602_414496 0 -5.00000000712604e-09
iB00_3450_v n1_400602_411152 0 1.2000000001982959e-07
iB00_3451_v n1_378410_407808 0 1.100000000324708e-07
iB00_3452_v n1_378410_404464 0 2.9499999995965046e-07
iB00_3453_v n1_400602_407808 0 -1.5000000002404583e-07
iB00_3454_v n1_400602_404464 0 -3.249999999918188e-07
iB00_3455_v n1_378410_401120 0 3.000000000315745e-08
iB00_3456_v n1_378410_399854 0 0.081529
iB00_3457_v n1_400602_401120 0 8.499999998561741e-08
iB00_3458_v n1_400602_399854 0 0.08119250000000001
iB00_3459_v n1_378410_397776 0 5.4999999995377215e-08
iB00_3460_v n1_378410_394432 0 -1.2000000000839464e-07
iB00_3461_v n1_400602_397776 0 4.200000000022762e-07
iB00_3462_v n1_400602_394432 0 -2.34999999990605e-07
iB00_3463_v n1_378410_391088 0 -2.3499999999653423e-07
iB00_3464_v n1_378410_387744 0 2.0500000000756458e-07
iB00_3465_v n1_400602_391088 0 1.6499999999121384e-07
iB00_3466_v n1_400602_387744 0 1.1499999999406882e-07
iB00_3467_v n1_378410_384400 0 1.8999999999232745e-07
iB00_3468_v n1_378410_381056 0 -2.8000000000603497e-07
iB00_3469_v n1_400602_384400 0 -3.85000000006604e-07
iB00_3470_v n1_400602_381056 0 1.6000000000780472e-07
iB00_3471_v n1_378410_377712 0 2.9500000000030804e-07
iB00_3472_v n1_378410_377358 0 0.08196
iB00_3473_v n1_400602_377712 0 2.3499999999611072e-07
iB00_3474_v n1_400602_377358 0 0.0811045
iB00_3475_v n1_378410_374368 0 -9.999999999005488e-09
iB00_3476_v n1_378410_371024 0 3.3999999999667976e-07
iB00_3477_v n1_400602_374368 0 4.499999999637173e-08
iB00_3478_v n1_400602_371024 0 2.500000001403086e-08
iB00_3479_v n1_378410_367680 0 -2.999999999976932e-07
iB00_3480_v n1_378410_364336 0 6.499999999777083e-08
iB00_3481_v n1_400602_367680 0 5.99999999906448e-08
iB00_3482_v n1_400602_364336 0 -3.2000000000544505e-07
iB00_3483_v n1_378410_360992 0 -7.499999999518813e-08
iB00_3484_v n1_378410_357648 0 2.649999999982094e-07
iB00_3485_v n1_400602_360992 0 -1.0999999999414256e-07
iB00_3486_v n1_400602_357648 0 2.1000000000240865e-07
iB00_3487_v n1_378410_355470 0 0.08068959999999999
iB00_3488_v n1_378410_354304 0 -3.0000000000404595e-08
iB00_3489_v n1_400602_355470 0 0.08332339999999999
iB00_3490_v n1_400602_354304 0 5.000000001620326e-09
iB00_3491_v n1_378410_350960 0 2.9999999999239924e-08
iB00_3492_v n1_378410_347616 0 3.3881317890172014e-18
iB00_3493_v n1_400602_350960 0 -5.0000000037379085e-09
iB00_3494_v n1_400602_347616 0 1.5000000000202297e-08
iB00_3495_v n1_378410_344272 0 -1.5000000001896363e-08
iB00_3496_v n1_378410_340928 0 2.4999999998360752e-08
iB00_3497_v n1_400602_344272 0 -2.4999999998360752e-08
iB00_3498_v n1_400602_340928 0 3.0000000005063276e-08
iB00_3499_v n1_378410_337584 0 -2.4999999998890147e-08
iB00_3500_v n1_378410_334240 0 -2.000000000478724e-08
iB00_3501_v n1_400602_337584 0 -3.000000000548679e-08
iB00_3502_v n1_400602_334240 0 5.000000002043843e-09
iB00_3503_v n1_378410_332974 0 0.08097769999999999
iB00_3504_v n1_378410_330896 0 2.4999999998360752e-08
iB00_3505_v n1_400602_332974 0 0.08203590000000001
iB00_3506_v n1_400602_330896 0 -3.3881317890172014e-18
iB00_3507_v n1_378410_327552 0 -1.999999999642279e-08
iB00_3508_v n1_378410_324208 0 -1.0000000000699553e-08
iB00_3509_v n1_400602_327552 0 3.3881317890172014e-18
iB00_3510_v n1_400602_324208 0 -4.658681209898652e-18
iB00_3511_v n1_378410_320864 0 4.999999999396865e-09
iB00_3512_v n1_378410_317520 0 9.999999997311422e-09
iB00_3513_v n1_400602_320864 0 3.500000000244844e-08
iB00_3514_v n1_400602_317520 0 -2.4999999998360752e-08
iB00_3515_v n1_378410_314176 0 1.376428539288238e-18
iB00_3516_v n1_378410_311086 0 0.0827631
iB00_3517_v n1_400602_314176 0 -1.500000000104933e-08
iB00_3518_v n1_400602_311086 0 0.0795166
iB00_3519_v n1_378410_310832 0 -6.000000001637342e-08
iB00_3520_v n1_378410_307488 0 -1.949999999933125e-07
iB00_3521_v n1_400602_310832 0 -1.89999999999739e-07
iB00_3522_v n1_400602_307488 0 2.5500000000598015e-07
iB00_3523_v n1_378410_304144 0 -1.500000000024465e-07
iB00_3524_v n1_378410_300800 0 6.000000000419732e-08
iB00_3525_v n1_400602_304144 0 -2.8999999997962947e-07
iB00_3526_v n1_400602_300800 0 1.9999999999239173e-07
iB00_3527_v n1_378410_297456 0 4.000000000115709e-07
iB00_3528_v n1_378410_294112 0 -1.350000000026677e-07
iB00_3529_v n1_400602_297456 0 -2.4499999999681027e-07
iB00_3530_v n1_400602_294112 0 -1.0000000000741905e-07
iB00_3531_v n1_378410_290768 0 -7.999999999797313e-08
iB00_3532_v n1_378410_288590 0 0.082662
iB00_3533_v n1_400602_290768 0 1.7000000002544494e-07
iB00_3534_v n1_400602_288590 0 0.0837805
iB00_3535_v n1_378410_287424 0 3.7499999999881056e-07
iB00_3536_v n1_378410_284080 0 -1.3500000001622024e-07
iB00_3537_v n1_400602_287424 0 7.000000000489687e-08
iB00_3538_v n1_400602_284080 0 -3.3500000001030603e-07
iB00_3539_v n1_378410_280736 0 -9.000000000121378e-08
iB00_3540_v n1_378410_277392 0 1.4999999994273067e-08
iB00_3541_v n1_400602_280736 0 4.2500000000940223e-07
iB00_3542_v n1_400602_277392 0 -1.650000000005312e-07
iB00_3543_v n1_378410_274048 0 1.7499999999297219e-07
iB00_3544_v n1_378410_270704 0 -1.1999999999484211e-07
iB00_3545_v n1_400602_274048 0 -9.49999999998695e-08
iB00_3546_v n1_400602_270704 0 1.19999999979172e-07
iB00_3547_v n1_378410_267360 0 1.4000000000619386e-07
iB00_3548_v n1_378410_266702 0 0.08044
iB00_3549_v n1_400602_267360 0 -2.0000000001399107e-08
iB00_3550_v n1_400602_266702 0 0.08195449999999999
iB00_3551_v n1_378410_264016 0 -3.44999999989618e-07
iB00_3552_v n1_378410_260672 0 1.4999999994273067e-08
iB00_3553_v n1_400602_264016 0 6.499999998421831e-08
iB00_3554_v n1_400602_260672 0 -2.0999999998250337e-07
iB00_3555_v n1_378410_257328 0 -3.499999997724921e-08
iB00_3556_v n1_378410_253984 0 2.4999999981420093e-08
iB00_3557_v n1_400602_257328 0 1.1499999997416355e-07
iB00_3558_v n1_400602_253984 0 1.0000000039239553e-08
iB00_3559_v n1_378410_250640 0 2.1999999999972007e-07
iB00_3560_v n1_378410_247296 0 8.999999999274345e-08
iB00_3561_v n1_400602_250640 0 -4.0000000002798214e-08
iB00_3562_v n1_400602_247296 0 -7.000000001506127e-08
iB00_3563_v n1_378410_244814 0 0.08401950000000002
iB00_3564_v n1_378410_243952 0 -3.500000002277723e-08
iB00_3565_v n1_400602_244814 0 0.0817425
iB00_3566_v n1_400602_243952 0 2.3499999999102852e-07
iB00_3567_v n1_378410_240608 0 8.999999998914356e-08
iB00_3568_v n1_378410_237264 0 -9.499999997276444e-08
iB00_3569_v n1_400602_240608 0 -2.0000000001399107e-07
iB00_3570_v n1_400602_237264 0 3.6499999999292293e-07
iB00_3571_v n1_378410_233920 0 -1.2000000001347684e-07
iB00_3572_v n1_378410_230576 0 2.710505431213761e-17
iB00_3573_v n1_400602_233920 0 -5.0000000017050295e-08
iB00_3574_v n1_400602_230576 0 7.500000003616335e-08
iB00_3575_v n1_378410_227232 0 -2.4500000002433884e-07
iB00_3576_v n1_378410_223888 0 1.0500000001412158e-07
iB00_3577_v n1_400602_227232 0 -2.600000000181884e-07
iB00_3578_v n1_400602_223888 0 -1.4999999988343836e-08
iB00_3579_v n1_378410_222318 0 0.08125599999999998
iB00_3580_v n1_378410_220544 0 -5.999999997709227e-08
iB00_3581_v n1_400602_222318 0 0.08198800000000002
iB00_3582_v n1_400602_220544 0 1.1499999998136333e-07
iB00_3583_v n1_378410_217200 0 -8.000000002931335e-08
iB00_3584_v n1_378410_213856 0 -9.999999960041972e-09
iB00_3585_v n1_400602_217200 0 4.5000000009924254e-08
iB00_3586_v n1_400602_213856 0 5.99999999906448e-08
iB00_3587_v n1_378410_210512 0 1.4999999996877693e-07
iB00_3588_v n1_378410_207168 0 -8.499999998561741e-08
iB00_3589_v n1_400602_210512 0 1.4999999999694077e-07
iB00_3590_v n1_400602_207168 0 -1.8999999998152778e-07
iB00_3591_v n1_378410_203824 0 2.85000000013161e-07
iB00_3592_v n1_378410_200480 0 -2.2499999999541116e-07
iB00_3593_v n1_400602_203824 0 3.999999997569316e-08
iB00_3594_v n1_400602_200480 0 -1.749999999559145e-07
iB00_3595_v n1_378410_200430 0 0.083073
iB00_3596_v n1_378410_197136 0 1.4999999994273067e-08
iB00_3597_v n1_400602_200430 0 0.08164799999999997
iB00_3598_v n1_400602_197136 0 -3.0500000000270166e-07
iB00_3599_v n1_378410_193792 0 -1.9499999998907734e-07
iB00_3600_v n1_378410_190448 0 1.399999999826887e-07
iB00_3601_v n1_400602_193792 0 1.89999999999739e-07
iB00_3602_v n1_400602_190448 0 2.5500000001826213e-07
iB00_3603_v n1_378410_187104 0 -1.499999997457955e-08
iB00_3604_v n1_378410_183760 0 2.949999999867555e-07
iB00_3605_v n1_400602_187104 0 -1.0499999998701652e-07
iB00_3606_v n1_400602_183760 0 1.1499999999449234e-07
iB00_3607_v n1_378410_180416 0 -4.5999999999491e-07
iB00_3608_v n1_378410_177934 0 0.08041100000000007
iB00_3609_v n1_400602_180416 0 -6.999999999134435e-08
iB00_3610_v n1_400602_177934 0 0.08329099999999996
iB00_3611_v n1_378410_177072 0 -1.0000000015099114e-08
iB00_3612_v n1_378410_173728 0 -4.0000000002798214e-08
iB00_3613_v n1_400602_177072 0 -1.000000001425208e-08
iB00_3614_v n1_400602_173728 0 3.500000002362426e-08
iB00_3615_v n1_378410_170384 0 -2.000000000046737e-07
iB00_3616_v n1_378410_167040 0 2.999999996144108e-08
iB00_3617_v n1_400602_170384 0 -3.1000000000813363e-07
iB00_3618_v n1_400602_167040 0 -3.5000000053270414e-08
iB00_3619_v n1_378410_163696 0 1.450000000213667e-07
iB00_3620_v n1_378410_160352 0 1.6999999999833988e-07
iB00_3621_v n1_400602_163696 0 3.600000000251839e-07
iB00_3622_v n1_400602_160352 0 -1.2000000004227596e-07
iB00_3623_v n1_378410_157008 0 -4.050000000147794e-07
iB00_3624_v n1_378410_156046 0 0.07966699999999999
iB00_3625_v n1_400602_157008 0 4.0000000002798214e-08
iB00_3626_v n1_400602_156046 0 0.08144699999999998
iB00_3627_v n1_378410_153664 0 1.6999999997779933e-07
iB00_3628_v n1_378410_150320 0 1.89999999999739e-07
iB00_3629_v n1_400602_153664 0 -6.999999999134435e-08
iB00_3630_v n1_400602_150320 0 -1.350000000280787e-07
iB00_3631_v n1_378410_146976 0 -3.0999999999881627e-07
iB00_3632_v n1_378410_143632 0 2.1499999998115908e-07
iB00_3633_v n1_400602_146976 0 -1.0999999993993245e-07
iB00_3634_v n1_400602_143632 0 4.5499999999032507e-07
iB00_3635_v n1_378410_140288 0 -1.9500000002211162e-07
iB00_3636_v n1_378410_136944 0 0.0
iB00_3637_v n1_400602_140288 0 -4.700000000735366e-07
iB00_3638_v n1_400602_136944 0 6.999999998710918e-08
iB00_3639_v n1_378410_133600 0 3.3500000003614054e-07
iB00_3640_v n1_378410_133550 0 0.08461999999999996
iB00_3641_v n1_400602_133600 0 8.000000000559643e-08
iB00_3642_v n1_400602_133550 0 0.08116549999999999
iB00_3643_v n1_378410_130256 0 -2.549999999809927e-07
iB00_3644_v n1_378410_126912 0 1.2499999998841563e-07
iB00_3645_v n1_400602_130256 0 -4.999999980020986e-09
iB00_3646_v n1_400602_126912 0 -1.9999999980223283e-08
iB00_3647_v n1_378410_123568 0 8.500000000933434e-08
iB00_3648_v n1_378410_120224 0 7.499999999847039e-08
iB00_3649_v n1_400602_123568 0 -7.500000002557544e-08
iB00_3650_v n1_400602_120224 0 3.150000000389766e-07
iB00_3651_v n1_378410_116880 0 4.4999999991713046e-08
iB00_3652_v n1_378410_113536 0 -6.000000000419732e-08
iB00_3653_v n1_400602_116880 0 -2.6500000002531443e-07
iB00_3654_v n1_400602_113536 0 1.2000000001686497e-07
iB00_3655_v n1_378410_111662 0 0.0800755
iB00_3656_v n1_378410_110192 0 -1.6000000001119286e-07
iB00_3657_v n1_400602_111662 0 0.08294549999999996
iB00_3658_v n1_355914_106848 0 3.250000000024067e-07
iB00_3659_v n1_400602_110192 0 -1.5000000000456407e-07
iB00_3660_v n1_378410_106848 0 -1.950000000009358e-07
iB00_3661_v n1_378410_103504 0 1.300000000167175e-07
iB00_3662_v n1_400602_106848 0 3.000000000209866e-07
iB00_3663_v n1_355914_103504 0 -3.799999999999015e-07
iB00_3664_v n1_355914_100160 0 -9.500000001003389e-08
iB00_3665_v n1_333722_103504 0 -3.1000000000813363e-07
iB00_3666_v n1_333722_100160 0 2.0000000000255612e-07
iB00_3667_v n1_333722_96816 0 8.49999999948289e-08
iB00_3668_v n1_311226_100160 0 1.6999999997123483e-07
iB00_3669_v n1_311226_96816 0 1.0500000001369806e-07
iB00_3670_v n1_311226_93472 0 5.499999999707128e-08
iB00_3671_v n1_289034_96816 0 -8.500000003982752e-08
iB00_3672_v n1_333722_93472 0 -1.2999999997944804e-07
iB00_3673_v n1_333722_90128 0 5.4999999969966226e-08
iB00_3674_v n1_355914_90128 0 1.0999999999414256e-07
iB00_3675_v n1_355914_93472 0 -8.000000000559643e-08
iB00_3676_v n1_378410_93472 0 4.249999999822972e-07
iB00_3677_v n1_355914_96816 0 1.7999999999787477e-07
iB00_3678_v n1_378410_96816 0 -7.00000000184494e-08
iB00_3679_v n1_400602_96816 0 3.999999997569316e-08
iB00_3680_v n1_378410_100160 0 -1.6499999999121384e-07
iB00_3681_v n1_400602_100160 0 1.9500000000686503e-07
iB00_3682_v n1_422794_100160 0 4.9999999962840186e-08
iB00_3683_v n1_400602_103504 0 -2.3500000001559247e-07
iB00_3684_v n1_422794_103504 0 1.0000000003410059e-07
iB00_3685_v n1_445290_103504 0 1.5000000000202297e-07
iB00_3686_v n1_422794_106848 0 9.999999997989048e-08
iB00_3687_v n1_422794_110192 0 -4.0000000002798214e-07
iB00_3688_v n1_445290_106848 0 -9.999999997989048e-08
iB00_3689_v n1_445290_110192 0 1.000000000036074e-07
iB00_3690_v n1_422794_111662 0 0.08124849999999997
iB00_3691_v n1_422794_113536 0 9.999999997989048e-08
iB00_3692_v n1_445290_111662 0 0.08322850000000004
iB00_3693_v n1_445290_113536 0 -2.5000000005137015e-07
iB00_3694_v n1_422794_116880 0 5.000000003229689e-08
iB00_3695_v n1_422794_120224 0 5.421010862427522e-17
iB00_3696_v n1_445290_116880 0 4.0000000002798214e-07
iB00_3697_v n1_445290_120224 0 -3.499999999770505e-07
iB00_3698_v n1_422794_123568 0 -1.000000000213951e-07
iB00_3699_v n1_422794_126912 0 -1.5000000005115088e-07
iB00_3700_v n1_445290_123568 0 -5.00000000712604e-08
iB00_3701_v n1_445290_126912 0 3.000000000802789e-07
iB00_3702_v n1_422794_130256 0 3.000000000438565e-07
iB00_3703_v n1_422794_133550 0 0.0822485
iB00_3704_v n1_445290_130256 0 -2.0000000006820118e-07
iB00_3705_v n1_445290_133550 0 0.08161499999999984
iB00_3706_v n1_422794_133600 0 -3.0000000001759847e-07
iB00_3707_v n1_422794_136944 0 -5.0000000017050295e-08
iB00_3708_v n1_445290_133600 0 -4.9999999962840186e-08
iB00_3709_v n1_445290_136944 0 -4.999999998994524e-08
iB00_3710_v n1_422794_140288 0 2.3500000000119291e-07
iB00_3711_v n1_422794_143632 0 1.2500000004262574e-07
iB00_3712_v n1_445290_140288 0 0.0
iB00_3713_v n1_445290_143632 0 9.999999997226718e-08
iB00_3714_v n1_422794_146976 0 3.500000000329547e-08
iB00_3715_v n1_422794_150320 0 -5.000000034231095e-09
iB00_3716_v n1_445290_146976 0 -1.4999999994273067e-07
iB00_3717_v n1_445290_150320 0 1.9999999998858008e-07
iB00_3718_v n1_422794_153664 0 -2.99999999953224e-08
iB00_3719_v n1_422794_156046 0 0.07957750000000001
iB00_3720_v n1_445290_153664 0 -3.5000000006514195e-07
iB00_3721_v n1_445290_156046 0 0.08022600000000008
iB00_3722_v n1_422794_157008 0 -1.2499999997909827e-07
iB00_3723_v n1_422794_160352 0 1.0500000001412158e-07
iB00_3724_v n1_445290_157008 0 -4.999999999536625e-07
iB00_3725_v n1_445290_160352 0 3.9999999998478346e-07
iB00_3726_v n1_422794_163696 0 -8.000000001914895e-08
iB00_3727_v n1_422794_167040 0 2.6500000002531443e-07
iB00_3728_v n1_445290_163696 0 -1.4999999999694077e-07
iB00_3729_v n1_445290_167040 0 2.371692252312041e-17
iB00_3730_v n1_422794_170384 0 -2.500000000141007e-07
iB00_3731_v n1_422794_173728 0 -1.2999999996843661e-07
iB00_3732_v n1_445290_170384 0 1.9999999995978096e-07
iB00_3733_v n1_445290_173728 0 -4.9999999973851614e-08
iB00_3734_v n1_422794_177072 0 7.999999999119687e-08
iB00_3735_v n1_422794_177934 0 0.085048
iB00_3736_v n1_445290_177072 0 -1.4999999999694077e-07
iB00_3737_v n1_445290_177934 0 0.08231399999999994
iB00_3738_v n1_422794_180416 0 4.9999999991639306e-08
iB00_3739_v n1_422794_183760 0 3.499999996856712e-08
iB00_3740_v n1_445290_180416 0 4.5000000004503243e-07
iB00_3741_v n1_445290_183760 0 -2.7999999993827233e-07
iB00_3742_v n1_422794_187104 0 -3.700000000030136e-07
iB00_3743_v n1_422794_190448 0 3.5499999999095283e-07
iB00_3744_v n1_445290_187104 0 1.450000000169198e-07
iB00_3745_v n1_445290_190448 0 1.0499999996753476e-07
iB00_3746_v n1_422794_193792 0 -3.149999999957779e-07
iB00_3747_v n1_422794_197136 0 1.0500000001412158e-07
iB00_3748_v n1_445290_193792 0 -2.9500000006807067e-07
iB00_3749_v n1_445290_197136 0 -4.500000001754755e-08
iB00_3750_v n1_422794_200430 0 0.08084450000000001
iB00_3751_v n1_422794_200480 0 1.9499999997975997e-07
iB00_3752_v n1_445290_200430 0 0.08169449999999995
iB00_3753_v n1_445290_200480 0 3.950000000005273e-07
iB00_3754_v n1_422794_203824 0 -8.999999999994323e-08
iB00_3755_v n1_422794_207168 0 1.6999999999833988e-07
iB00_3756_v n1_445290_203824 0 -1.7499999995125581e-07
iB00_3757_v n1_445290_207168 0 -7.499999999000006e-08
iB00_3758_v n1_422794_210512 0 -2.500000001318383e-08
iB00_3759_v n1_422794_213856 0 -1.6999999997123483e-07
iB00_3760_v n1_445290_210512 0 1.6500000004542395e-07
iB00_3761_v n1_445290_213856 0 4.9999999732447224e-09
iB00_3762_v n1_422794_217200 0 2.2999999997373808e-07
iB00_3763_v n1_422794_220544 0 -3.299999999824277e-07
iB00_3764_v n1_445290_217200 0 -4.9999999962840186e-08
iB00_3765_v n1_445290_220544 0 -1.5000000004437462e-08
iB00_3766_v n1_422794_222318 0 0.08144900000000001
iB00_3767_v n1_422794_223888 0 4.000000000008771e-07
iB00_3768_v n1_445290_222318 0 0.082276
iB00_3769_v n1_445290_223888 0 1.4000000001657e-07
iB00_3770_v n1_422794_227232 0 -2.0999999998207985e-07
iB00_3771_v n1_422794_230576 0 2.2999999997543215e-07
iB00_3772_v n1_445290_227232 0 -2.600000000181884e-07
iB00_3773_v n1_445290_230576 0 -8.499999998138225e-08
iB00_3774_v n1_422794_233920 0 -2.6000000000167125e-07
iB00_3775_v n1_422794_237264 0 -1.8000000001259196e-07
iB00_3776_v n1_445290_233920 0 1.6999999999833988e-07
iB00_3777_v n1_445290_237264 0 1.9999999975141086e-08
iB00_3778_v n1_422794_240608 0 -1.499999999384955e-08
iB00_3779_v n1_422794_243952 0 2.549999999839573e-07
iB00_3780_v n1_445290_240608 0 -4.9999999962840186e-08
iB00_3781_v n1_445290_243952 0 -3.0000000008874924e-08
iB00_3782_v n1_422794_244814 0 0.08254900000000004
iB00_3783_v n1_422794_247296 0 2.0000000001399107e-08
iB00_3784_v n1_445290_244814 0 0.08106650000000004
iB00_3785_v n1_445290_247296 0 -3.449999999860181e-07
iB00_3786_v n1_422794_250640 0 3.3999999998143317e-07
iB00_3787_v n1_422794_253984 0 -2.4499999999681027e-07
iB00_3788_v n1_445290_250640 0 2.9999999999388155e-07
iB00_3789_v n1_445290_253984 0 1.6940658945086007e-17
iB00_3790_v n1_422794_257328 0 2.450000000264564e-07
iB00_3791_v n1_422794_260672 0 -2.0000000001399107e-07
iB00_3792_v n1_445290_257328 0 -2.5500000001106235e-07
iB00_3793_v n1_445290_260672 0 1.9999999975564602e-08
iB00_3794_v n1_422794_264016 0 -9.000000001603686e-08
iB00_3795_v n1_422794_266702 0 0.08063450000000004
iB00_3796_v n1_445290_264016 0 2.900000000067345e-07
iB00_3797_v n1_445290_266702 0 0.079675
iB00_3798_v n1_422794_267360 0 1.149999999987275e-07
iB00_3799_v n1_422794_270704 0 -4.050000000080031e-07
iB00_3800_v n1_445290_267360 0 1.4999999994273067e-08
iB00_3801_v n1_445290_270704 0 1.899999999950803e-07
iB00_3802_v n1_422794_274048 0 9.000000000375488e-08
iB00_3803_v n1_422794_277392 0 8.000000000559643e-08
iB00_3804_v n1_445290_274048 0 -1.4499999998981473e-07
iB00_3805_v n1_445290_277392 0 3.500000000583657e-08
iB00_3806_v n1_422794_280736 0 4.000000000915096e-08
iB00_3807_v n1_422794_284080 0 -4.0000000002798214e-08
iB00_3808_v n1_445290_280736 0 2.450000000239153e-07
iB00_3809_v n1_445290_284080 0 -1.3552527156068805e-17
iB00_3810_v n1_422794_287424 0 3.1999999999570417e-07
iB00_3811_v n1_422794_288590 0 0.0810485
iB00_3812_v n1_445290_287424 0 -1.7500000000546592e-07
iB00_3813_v n1_445290_288590 0 0.08237349999999999
iB00_3814_v n1_422794_290768 0 1.299999999760599e-07
iB00_3815_v n1_422794_294112 0 2.0000000014951634e-08
iB00_3816_v n1_445290_290768 0 -2.3500000000966324e-07
iB00_3817_v n1_445290_294112 0 8.000000001025511e-08
iB00_3818_v n1_422794_297456 0 -1.5500000000449033e-07
iB00_3819_v n1_422794_300800 0 1.0500000000056905e-07
iB00_3820_v n1_445290_297456 0 -5.00000000712604e-09
iB00_3821_v n1_445290_300800 0 1.9999999996740426e-08
iB00_3822_v n1_422794_304144 0 -1.6999999999071659e-07
iB00_3823_v n1_422794_307488 0 1.999999998784658e-08
iB00_3824_v n1_445290_304144 0 1.5500000000406682e-07
iB00_3825_v n1_445290_307488 0 -9.500000000198708e-08
iB00_3826_v n1_422794_310832 0 1.8000000000454515e-07
iB00_3827_v n1_422794_311086 0 0.08006749999999999
iB00_3828_v n1_445290_310832 0 2.849999999996085e-07
iB00_3829_v n1_445290_311086 0 0.08197674999999999
iB00_3830_v n1_422794_314176 0 4.999999995267579e-09
iB00_3831_v n1_422794_317520 0 3.500000000244844e-08
iB00_3832_v n1_445290_314176 0 -2.99999999953224e-08
iB00_3833_v n1_445290_317520 0 2.4999999994549104e-08
iB00_3834_v n1_422794_320864 0 -4.999999999502744e-09
iB00_3835_v n1_422794_324208 0 -1.9999999994622843e-08
iB00_3836_v n1_445290_320864 0 1.3552527156068805e-17
iB00_3837_v n1_445290_324208 0 -1.5000000007825594e-08
iB00_3838_v n1_422794_327552 0 -1.000000000112307e-08
iB00_3839_v n1_422794_330896 0 2.499999999497262e-08
iB00_3840_v n1_445290_327552 0 2.0000000001399107e-08
iB00_3841_v n1_445290_330896 0 -4.499999999806579e-08
iB00_3842_v n1_422794_332974 0 0.08076154999999999
iB00_3843_v n1_422794_334240 0 2.4999999998360752e-08
iB00_3844_v n1_445290_332974 0 0.08280940000000002
iB00_3845_v n1_445290_334240 0 9.999999997734938e-09
iB00_3846_v n1_422794_337584 0 -5.00000000119681e-09
iB00_3847_v n1_422794_340928 0 4.999999996961645e-09
iB00_3848_v n1_445290_337584 0 -5.000000000349777e-09
iB00_3849_v n1_445290_340928 0 -9.999999996887905e-09
iB00_3850_v n1_422794_344272 0 -1.499999999850823e-08
iB00_3851_v n1_422794_347616 0 -5.000000000349777e-09
iB00_3852_v n1_445290_344272 0 2.999999999871053e-08
iB00_3853_v n1_445290_347616 0 5.000000002043843e-09
iB00_3854_v n1_422794_350960 0 1.999999999758746e-08
iB00_3855_v n1_422794_354304 0 -2.4999999998360752e-08
iB00_3856_v n1_445290_350960 0 -1.500000000104933e-08
iB00_3857_v n1_445290_354304 0 1.4999999998931748e-08
iB00_3858_v n1_422794_355470 0 0.0827531
iB00_3859_v n1_422794_357648 0 -1.4999999994273067e-08
iB00_3860_v n1_445290_355470 0 0.07939710000000003
iB00_3861_v n1_445290_357648 0 -1.8500000000531844e-07
iB00_3862_v n1_422794_360992 0 -3.1000000000389847e-07
iB00_3863_v n1_422794_364336 0 1.3552527156068805e-17
iB00_3864_v n1_445290_360992 0 2.0499999999401206e-07
iB00_3865_v n1_445290_364336 0 8.499999999747588e-08
iB00_3866_v n1_422794_367680 0 -8.500000001399302e-08
iB00_3867_v n1_422794_371024 0 4.200000000158287e-07
iB00_3868_v n1_445290_367680 0 -4.49999999828192e-08
iB00_3869_v n1_445290_371024 0 -1.8000000000200405e-07
iB00_3870_v n1_422794_374368 0 2.5000000009795697e-08
iB00_3871_v n1_422794_377358 0 0.08170200000000002
iB00_3872_v n1_445290_374368 0 2.0000000001399107e-07
iB00_3873_v n1_445290_377358 0 0.081671
iB00_3874_v n1_422794_377712 0 3.499999999270756e-08
iB00_3875_v n1_422794_381056 0 -1.7999999999903944e-07
iB00_3876_v n1_445290_377712 0 -3.1999999999528066e-07
iB00_3877_v n1_445290_381056 0 -9.000000003890675e-08
iB00_3878_v n1_422794_384400 0 1.899999999950803e-07
iB00_3879_v n1_422794_387744 0 1.350000000026677e-07
iB00_3880_v n1_445290_384400 0 1.6000000001119286e-07
iB00_3881_v n1_445290_387744 0 -7.499999998788248e-08
iB00_3882_v n1_422794_391088 0 -3.400000000051501e-07
iB00_3883_v n1_422794_394432 0 2.5000000001748884e-07
iB00_3884_v n1_445290_391088 0 2.04999999966907e-07
iB00_3885_v n1_445290_394432 0 -1.0164395367051604e-17
iB00_3886_v n1_422794_397776 0 -8.499999999789939e-08
iB00_3887_v n1_422794_399854 0 0.08102450000000003
iB00_3888_v n1_445290_397776 0 -1.9999999998688602e-07
iB00_3889_v n1_445290_399854 0 0.0806065
iB00_3890_v n1_422794_401120 0 -3.250000000172298e-07
iB00_3891_v n1_422794_404464 0 2.1000000002824315e-07
iB00_3892_v n1_445290_401120 0 1.9499999997975997e-07
iB00_3893_v n1_445290_404464 0 -3.049999999836434e-07
iB00_3894_v n1_422794_407808 0 2.899999999851352e-07
iB00_3895_v n1_422794_411152 0 -8.999999999274345e-08
iB00_3896_v n1_445290_407808 0 2.1999999998828512e-07
iB00_3897_v n1_445290_411152 0 -2.3000000000041962e-07
iB00_3898_v n1_422794_414496 0 5.499999999918886e-08
iB00_3899_v n1_422794_417840 0 -2.700000000053354e-07
iB00_3900_v n1_445290_414496 0 3.6499999997809986e-07
iB00_3901_v n1_445290_417840 0 1.000000000239362e-08
iB00_3902_v n1_422794_421184 0 -9.499999996005895e-08
iB00_3903_v n1_422794_421742 0 0.0808305
iB00_3904_v n1_445290_421184 0 -2.749999999853564e-07
iB00_3905_v n1_445290_421742 0 0.0818345
iB00_3906_v n1_422794_424528 0 -4.9999999995450954e-08
iB00_3907_v n1_422794_427872 0 7.999999997849137e-08
iB00_3908_v n1_445290_424528 0 -3.999999997569316e-08
iB00_3909_v n1_445290_427872 0 -4.0000000026515136e-08
iB00_3910_v n1_422794_431216 0 2.3499999998425225e-07
iB00_3911_v n1_422794_434560 0 -5.999999997709227e-08
iB00_3912_v n1_445290_431216 0 1.000000001425208e-08
iB00_3913_v n1_445290_434560 0 9.999999998666674e-08
iB00_3914_v n1_422794_437904 0 -2.900000000245222e-07
iB00_3915_v n1_422794_441248 0 6.000000000419732e-08
iB00_3916_v n1_445290_437904 0 -2.7999999999248244e-07
iB00_3917_v n1_445290_441248 0 3.550000000061994e-07
iB00_3918_v n1_422794_444238 0 0.0829385
iB00_3919_v n1_422794_444592 0 -2.599999999639783e-07
iB00_3920_v n1_445290_444238 0 0.08182
iB00_3921_v n1_445290_444592 0 -3.200000000062921e-07
iB00_3922_v n1_422794_447936 0 -3.0000000014804155e-08
iB00_3923_v n1_422794_451280 0 3.3000000000953274e-07
iB00_3924_v n1_445290_447936 0 3.5499999999095283e-07
iB00_3925_v n1_445290_451280 0 2.500000001784251e-08
iB00_3926_v n1_422794_454624 0 -1.9999999999493283e-07
iB00_3927_v n1_422794_457968 0 -1.0499999998701652e-07
iB00_3928_v n1_445290_454624 0 -2.900000000338396e-07
iB00_3929_v n1_445290_457968 0 -8.999999999951972e-08
iB00_3930_v n1_422794_461312 0 1.1499999997162245e-07
iB00_3931_v n1_422794_464656 0 -3.000000001565119e-08
iB00_3932_v n1_445290_461312 0 1.2500000004262574e-07
iB00_3933_v n1_445290_464656 0 -9.499999996683521e-08
iB00_3934_v n1_422794_466126 0 0.08193300000000002
iB00_3935_v n1_422794_468000 0 -1.2499999998841563e-07
iB00_3936_v n1_445290_466126 0 0.08080299999999996
iB00_3937_v n1_445290_468000 0 -3.999999996976393e-08
iB00_3938_v n1_422794_471344 0 2.0000000024692513e-08
iB00_3939_v n1_422794_474688 0 -2.0499999999401206e-07
iB00_3940_v n1_445290_471344 0 1.6499999999121384e-07
iB00_3941_v n1_445290_474688 0 -6.500000002064072e-08
iB00_3942_v n1_422794_478032 0 2.0999999994311634e-07
iB00_3943_v n1_422794_481376 0 -2.5500000001106235e-07
iB00_3944_v n1_445290_478032 0 -2.300000000025372e-07
iB00_3945_v n1_445290_481376 0 8.500000003220423e-08
iB00_3946_v n1_422794_484720 0 4.1000000001682323e-07
iB00_3947_v n1_422794_488064 0 -2.9499999995965046e-07
iB00_3948_v n1_445290_484720 0 -2.5000000062735256e-08
iB00_3949_v n1_445290_488064 0 -1.0500000001158048e-07
iB00_3950_v n1_422794_488622 0 0.0809715
iB00_3951_v n1_422794_491408 0 -1.0500000001412158e-07
iB00_3952_v n1_445290_488622 0 0.07996350000000002
iB00_3953_v n1_445290_491408 0 1.0000000000276037e-07
iB00_3954_v n1_422794_494752 0 3.1499999998646055e-07
iB00_3955_v n1_422794_498096 0 -5.500000005128139e-08
iB00_3956_v n1_445290_494752 0 -3.5000000006514195e-07
iB00_3957_v n1_445290_498096 0 2.0000000006057788e-07
iB00_3958_v n1_422794_501440 0 -2.3999999997443764e-07
iB00_3959_v n1_422794_504784 0 2.900000000338396e-07
iB00_3960_v n1_445290_501440 0 2.5000000003104136e-07
iB00_3961_v n1_445290_504784 0 -1.5000000002997506e-07
iB00_3962_v n1_422794_508128 0 4.9999999546099976e-09
iB00_3963_v n1_422794_510510 0 0.08303400000000005
iB00_3964_v n1_445290_508128 0 -5.0000000017050295e-08
iB00_3965_v n1_445290_510510 0 0.08154749999999997
iB00_3966_v n1_422794_511472 0 2.699999999460431e-07
iB00_3967_v n1_422794_514816 0 -3.3999999999667976e-07
iB00_3968_v n1_445290_511472 0 2.9999999999388155e-07
iB00_3969_v n1_445290_514816 0 -2.4999999995565543e-07
iB00_3970_v n1_422794_518160 0 3.400000000390314e-07
iB00_3971_v n1_422794_521504 0 -2.4499999999681027e-07
iB00_3972_v n1_445290_518160 0 1.9999999995978096e-07
iB00_3973_v n1_445290_521504 0 -3.999999999890186e-07
iB00_3974_v n1_422794_524848 0 -9.500000005492664e-08
iB00_3975_v n1_422794_528192 0 2.0000000001399107e-07
iB00_3976_v n1_445290_524848 0 4.5000000004503243e-07
iB00_3977_v n1_445290_528192 0 -2.0000000003601393e-07
iB00_3978_v n1_422794_531536 0 -2.649999999397641e-07
iB00_3979_v n1_422794_532398 0 0.08258199999999999
iB00_3980_v n1_445290_531536 0 0.0
iB00_3981_v n1_445290_532398 0 0.07925800000000002
iB00_3982_v n1_422794_534880 0 9.999999999767817e-08
iB00_3983_v n1_422794_538224 0 -9.999999997989048e-08
iB00_3984_v n1_445290_534880 0 -4.9999999962840186e-08
iB00_3985_v n1_445290_538224 0 -5.000000001874436e-08
iB00_3986_v n1_422794_541568 0 -2.499999999802194e-07
iB00_3987_v n1_422794_544912 0 2.0000000001399107e-07
iB00_3988_v n1_445290_541568 0 0.0
iB00_3989_v n1_445290_544912 0 4.5000000002978584e-07
iB00_3990_v n1_422794_548256 0 9.99999999959841e-08
iB00_3991_v n1_422794_551600 0 1.0000000003410059e-07
iB00_3992_v n1_445290_548256 0 -5.0000000017050295e-08
iB00_3993_v n1_445290_551600 0 -1.499999999410366e-07
iB00_3994_v n1_422794_554894 0 0.08036649999999997
iB00_3995_v n1_422794_554944 0 -4.999999999536625e-07
iB00_3996_v n1_445290_554894 0 0.08304849999999996
iB00_3997_v n1_445290_554944 0 -1.5000000001896363e-07
iB00_3998_v n1_422794_558288 0 2.500000000242651e-07
iB00_3999_v n1_422794_561632 0 -1.0000000003410059e-07
iB00_4000_v n1_445290_558288 0 -5.421010862427522e-17
iB00_4001_v n1_445290_561632 0 1.999999999970504e-07
iB00_4002_v n1_422794_564976 0 -4.9999999971310515e-08
iB00_4003_v n1_422794_568320 0 -5.0000000017050295e-08
iB00_4004_v n1_445290_564976 0 -1.0000000003410059e-07
iB00_4005_v n1_445290_568320 0 5.421010862427522e-17
iB00_4006_v n1_422794_571664 0 -4.999999996029909e-08
iB00_4007_v n1_445290_571664 0 2.710505431213761e-17
iB00_4008_v n1_467482_571664 0 -2.5000000003104136e-07
iB00_4009_v n1_489978_571664 0 -5.0000000025520624e-08
iB00_4010_v n1_467482_568320 0 -1.0000000003410059e-07
iB00_4011_v n1_489978_568320 0 5.0000000017050295e-08
iB00_4012_v n1_512170_571664 0 1.4999999994273067e-07
iB00_4013_v n1_534666_571664 0 -1.1499999999720284e-06
iB00_4014_v n1_512170_568320 0 -2.900000000013135e-06
iB00_4015_v n1_534666_568320 0 2.299999999944057e-06
iB00_4016_v n1_556858_571664 0 -2.149999999974221e-06
iB00_4017_v n1_579050_571664 0 -3.0999999998814365e-06
iB00_4018_v n1_556858_568320 0 2.949999999921765e-06
iB00_4019_v n1_579050_568320 0 1.4000000001081019e-06
iB00_4020_v n1_601546_571664 0 -1.1500000001753163e-06
iB00_4021_v n1_623064_571664 0 3.3881317890172014e-18
iB00_4022_v n1_601546_568320 0 -4.999999980020986e-08
iB00_4023_v n1_623064_575008 0 1.6940658945086007e-18
iB00_4024_v n1_625064_575008 0 -3.499999999892478e-06
iB00_4025_v n1_627064_575008 0 0.0
iB00_4026_v n1_625064_571664 0 3.149999999925592e-06
iB00_4027_v n1_627064_576782 0 -2.63678e-14
iB00_4028_v n1_625064_568320 0 2.9999999998371715e-07
iB00_4029_v n1_627064_571664 0 0.0
iB00_4030_v n1_625064_564976 0 1.4999999989275572e-07
iB00_4031_v n1_627064_568320 0 0.0
iB00_4032_v n1_623064_568320 0 0.0
iB00_4033_v n1_601546_564976 0 -5.000000007803667e-08
iB00_4034_v n1_601546_561632 0 2.0999999999487005e-06
iB00_4035_v n1_623064_564976 0 -8.470329472543003e-19
iB00_4036_v n1_579050_564976 0 -2.5000000008525147e-07
iB00_4037_v n1_556858_564976 0 -3.9999999999748895e-06
iB00_4038_v n1_579050_561632 0 1.5500000000948783e-06
iB00_4039_v n1_556858_561632 0 1.599999999996732e-06
iB00_4040_v n1_534666_564976 0 -3.1499999999899664e-06
iB00_4041_v n1_512170_564976 0 -7.999999999221331e-07
iB00_4042_v n1_534666_561632 0 2.500000000093573e-06
iB00_4043_v n1_512170_561632 0 1.4999999998880926e-06
iB00_4044_v n1_489978_564976 0 2.5000000003104136e-07
iB00_4045_v n1_467482_564976 0 1.4999999999355264e-07
iB00_4046_v n1_489978_561632 0 -3.500000000227903e-07
iB00_4047_v n1_467482_561632 0 9.999999997989048e-08
iB00_4048_v n1_467482_558288 0 1.5000000004945682e-07
iB00_4049_v n1_467482_554944 0 -1.5000000005115088e-07
iB00_4050_v n1_489978_558288 0 2.5000000003104136e-07
iB00_4051_v n1_489978_554944 0 1.5000000000202297e-07
iB00_4052_v n1_467482_554894 0 0.08282549999999997
iB00_4053_v n1_467482_551600 0 2.0000000001399107e-07
iB00_4054_v n1_489978_554894 0 0.08117599999999997
iB00_4055_v n1_489978_551600 0 1.9999999997841569e-07
iB00_4056_v n1_467482_548256 0 -2.499999999988541e-07
iB00_4057_v n1_467482_544912 0 9.999999997989048e-08
iB00_4058_v n1_489978_548256 0 2.5000000003104136e-07
iB00_4059_v n1_489978_544912 0 -3.4999999999060305e-07
iB00_4060_v n1_467482_541568 0 -3.499999999990734e-07
iB00_4061_v n1_467482_538224 0 -5.421010862427522e-17
iB00_4062_v n1_489978_541568 0 3.4999999995672174e-07
iB00_4063_v n1_489978_538224 0 -4.999999998486304e-08
iB00_4064_v n1_467482_534880 0 4.9999999991639306e-08
iB00_4065_v n1_467482_532398 0 0.08251950000000004
iB00_4066_v n1_489978_534880 0 -4.999999990863008e-08
iB00_4067_v n1_489978_532398 0 0.08289049999999991
iB00_4068_v n1_467482_531536 0 3.9999999995344324e-07
iB00_4069_v n1_467482_528192 0 -2.4999999997683126e-07
iB00_4070_v n1_489978_531536 0 1.4999999994273067e-07
iB00_4071_v n1_489978_528192 0 -5.0000000033990953e-08
iB00_4072_v n1_467482_524848 0 -1.4999999995967133e-07
iB00_4073_v n1_467482_521504 0 2.4999999992262115e-07
iB00_4074_v n1_489978_524848 0 1.9999999995978096e-07
iB00_4075_v n1_489978_521504 0 -1.4999999998169418e-07
iB00_4076_v n1_467482_518160 0 -4.999999998909821e-08
iB00_4077_v n1_467482_514816 0 -1.4999999994273067e-07
iB00_4078_v n1_489978_518160 0 -1.4999999999694077e-07
iB00_4079_v n1_489978_514816 0 2.9999999994983584e-07
iB00_4080_v n1_467482_511472 0 -4.999999997808678e-08
iB00_4081_v n1_467482_510510 0 0.08138999999999998
iB00_4082_v n1_489978_511472 0 -3.4999999990251163e-07
iB00_4083_v n1_489978_510510 0 0.08141399999999997
iB00_4084_v n1_467482_508128 0 2.999999999981167e-07
iB00_4085_v n1_467482_504784 0 -1.9999999995978096e-07
iB00_4086_v n1_489978_508128 0 -4.5000000004503243e-07
iB00_4087_v n1_489978_504784 0 3.0000000002776287e-07
iB00_4088_v n1_467482_501440 0 4.999999998655711e-08
iB00_4089_v n1_467482_498096 0 0.0
iB00_4090_v n1_489978_501440 0 -1.5000000005115088e-07
iB00_4091_v n1_489978_498096 0 2.5000000001071257e-07
iB00_4092_v n1_467482_494752 0 2.4999999996666686e-07
iB00_4093_v n1_467482_491408 0 -2.4999999997683126e-07
iB00_4094_v n1_489978_494752 0 -2.0000000001399107e-07
iB00_4095_v n1_489978_491408 0 9.999999997142015e-08
iB00_4096_v n1_467482_488622 0 0.08120000000000002
iB00_4097_v n1_467482_488064 0 -5.0000000017050295e-08
iB00_4098_v n1_489978_488622 0 0.07874200000000008
iB00_4099_v n1_489978_488064 0 9.999999997904345e-08
iB00_4100_v n1_467482_484720 0 3.7269449679189215e-17
iB00_4101_v n1_467482_481376 0 -1.4999999999694077e-07
iB00_4102_v n1_489978_484720 0 -1.4999999999694077e-07
iB00_4103_v n1_489978_481376 0 -3.0000000003962133e-07
iB00_4104_v n1_467482_478032 0 -1.4999999998677638e-07
iB00_4105_v n1_467482_474688 0 9.999999997989048e-08
iB00_4106_v n1_489978_478032 0 2.0000000001399107e-07
iB00_4107_v n1_489978_474688 0 -4.999999999248634e-08
iB00_4108_v n1_467482_471344 0 4.9999999982321944e-08
iB00_4109_v n1_467482_468000 0 1.4999999994273067e-07
iB00_4110_v n1_489978_471344 0 2.9999999993967144e-07
iB00_4111_v n1_489978_468000 0 -9.999999995024433e-08
iB00_4112_v n1_467482_466126 0 0.08050799999999997
iB00_4113_v n1_467482_464656 0 -9.999999997989048e-08
iB00_4114_v n1_489978_466126 0 0.08172750000000004
iB00_4115_v n1_489978_464656 0 -2.0000000001568514e-07
iB00_4116_v n1_467482_461312 0 -5.0000000022979525e-08
iB00_4117_v n1_467482_457968 0 1.3500000005687782e-07
iB00_4118_v n1_489978_461312 0 -1.9999999995978096e-07
iB00_4119_v n1_489978_457968 0 4.499999999518588e-07
iB00_4120_v n1_467482_454624 0 -3.500000002277723e-08
iB00_4121_v n1_467482_451280 0 -6.999999993713424e-08
iB00_4122_v n1_489978_454624 0 -1.4999999999694077e-07
iB00_4123_v n1_489978_451280 0 -1.6093625997831706e-17
iB00_4124_v n1_467482_447936 0 3.999999996976393e-08
iB00_4125_v n1_467482_444592 0 -1.9999999995978096e-07
iB00_4126_v n1_489978_447936 0 -1.4999999999694077e-07
iB00_4127_v n1_489978_444592 0 -5.000000004161425e-08
iB00_4128_v n1_467482_444238 0 0.08331249999999994
iB00_4129_v n1_467482_441248 0 1.1500000008258376e-07
iB00_4130_v n1_489978_444238 0 0.08248250000000006
iB00_4131_v n1_489978_441248 0 -1.7500000002325361e-07
iB00_4132_v n1_467482_437904 0 -2.8000000000264684e-07
iB00_4133_v n1_467482_434560 0 -5.0000000017050295e-08
iB00_4134_v n1_489978_437904 0 4.3499999994233915e-07
iB00_4135_v n1_489978_434560 0 -1.7500000002664175e-07
iB00_4136_v n1_467482_431216 0 2.950000000358834e-07
iB00_4137_v n1_467482_427872 0 -2.6500000002531443e-07
iB00_4138_v n1_489978_431216 0 -9.999999992568037e-08
iB00_4139_v n1_489978_427872 0 1.7000000005170296e-07
iB00_4140_v n1_467482_424528 0 2.650000000600428e-07
iB00_4141_v n1_467482_421742 0 0.08172149999999993
iB00_4142_v n1_489978_424528 0 -3.6000000007939403e-07
iB00_4143_v n1_489978_421742 0 0.08239500000000008
iB00_4144_v n1_467482_421184 0 1.4500000000082616e-07
iB00_4145_v n1_467482_417840 0 -2.710505431213761e-17
iB00_4146_v n1_489978_421184 0 -1.1000000002124762e-07
iB00_4147_v n1_489978_417840 0 -2.449999999866459e-07
iB00_4148_v n1_467482_414496 0 -7.999999997044456e-08
iB00_4149_v n1_467482_411152 0 -1.0000000000699553e-07
iB00_4150_v n1_489978_414496 0 2.900000000067345e-07
iB00_4151_v n1_489978_411152 0 -1.499999999850823e-08
iB00_4152_v n1_467482_407808 0 -5.000000002382656e-08
iB00_4153_v n1_467482_404464 0 8.500000001272247e-08
iB00_4154_v n1_489978_407808 0 -1.85000000019718e-07
iB00_4155_v n1_489978_404464 0 2.600000000054829e-07
iB00_4156_v n1_467482_401120 0 2.899999999775119e-07
iB00_4157_v n1_467482_399854 0 0.08165300000000003
iB00_4158_v n1_489978_401120 0 -1.9000000002684404e-07
iB00_4159_v n1_489978_399854 0 0.08117100000000005
iB00_4160_v n1_467482_397776 0 6.500000001047633e-08
iB00_4161_v n1_467482_394432 0 -9.500000002697455e-08
iB00_4162_v n1_489978_397776 0 -1.7500000000546592e-07
iB00_4163_v n1_489978_394432 0 5.0000000014509196e-08
iB00_4164_v n1_467482_391088 0 -1.9999999997756865e-07
iB00_4165_v n1_467482_387744 0 2.549999999839573e-07
iB00_4166_v n1_489978_391088 0 -1.4999999999694077e-07
iB00_4167_v n1_489978_387744 0 2.100000000163847e-07
iB00_4168_v n1_467482_384400 0 -2.549999999920041e-07
iB00_4169_v n1_467482_381056 0 2.5999999999108334e-07
iB00_4170_v n1_489978_384400 0 1.2500000001552068e-07
iB00_4171_v n1_489978_381056 0 1.000000000061485e-07
iB00_4172_v n1_467482_377712 0 -2.2000000000691985e-07
iB00_4173_v n1_467482_377358 0 0.08149849999999997
iB00_4174_v n1_489978_377712 0 -3.600000000251839e-07
iB00_4175_v n1_489978_377358 0 0.08233750000000002
iB00_4176_v n1_467482_374368 0 -3.5000000000542613e-07
iB00_4177_v n1_467482_371024 0 2.3499999999611072e-07
iB00_4178_v n1_489978_374368 0 4.5000000009924254e-08
iB00_4179_v n1_489978_371024 0 1.099999999949896e-07
iB00_4180_v n1_467482_367680 0 -1.6999999998817549e-07
iB00_4181_v n1_467482_364336 0 -5.0000000017050295e-08
iB00_4182_v n1_489978_367680 0 1.2000000000839464e-07
iB00_4183_v n1_489978_364336 0 -4.749999999917242e-07
iB00_4184_v n1_467482_360992 0 1.0000000000233685e-07
iB00_4185_v n1_467482_357648 0 2.7999999999248244e-07
iB00_4186_v n1_489978_360992 0 2.699999999917829e-07
iB00_4187_v n1_489978_357648 0 -1.9499999999966525e-07
iB00_4188_v n1_467482_355470 0 0.07972830000000004
iB00_4189_v n1_467482_354304 0 0.0
iB00_4190_v n1_489978_355470 0 0.08197249999999999
iB00_4191_v n1_489978_354304 0 -1.499999999977878e-08
iB00_4192_v n1_467482_350960 0 -1.4999999996814165e-08
iB00_4193_v n1_467482_347616 0 2.999999999871053e-08
iB00_4194_v n1_489978_350960 0 1.49999999976612e-08
iB00_4195_v n1_489978_347616 0 -1.9999999999281525e-08
iB00_4196_v n1_467482_344272 0 8.470329472543003e-19
iB00_4197_v n1_467482_340928 0 -4.499999999975986e-08
iB00_4198_v n1_489978_344272 0 5.000000000349777e-09
iB00_4199_v n1_489978_340928 0 2.0000000000552074e-08
iB00_4200_v n1_467482_337584 0 4.999999998232194e-09
iB00_4201_v n1_467482_334240 0 1.500000000104933e-08
iB00_4202_v n1_489978_337584 0 -2.499999999497262e-08
iB00_4203_v n1_489978_334240 0 3.499999999736624e-08
iB00_4204_v n1_467482_332974 0 0.08352145
iB00_4205_v n1_467482_330896 0 1.4999999994273067e-08
iB00_4206_v n1_489978_332974 0 0.08168004999999999
iB00_4207_v n1_489978_330896 0 -4.999999995267579e-09
iB00_4208_v n1_467482_327552 0 -2.499999999751372e-08
iB00_4209_v n1_467482_324208 0 4.0000000002798214e-08
iB00_4210_v n1_489978_327552 0 -3.999999999602195e-08
iB00_4211_v n1_489978_324208 0 2.5000000003019433e-08
iB00_4212_v n1_467482_320864 0 -3.99999999947514e-08
iB00_4213_v n1_467482_317520 0 2.5000000001748884e-08
iB00_4214_v n1_489978_320864 0 -9.99999999392329e-09
iB00_4215_v n1_489978_317520 0 1.999999999970504e-08
iB00_4216_v n1_467482_314176 0 -1.0000000001970103e-08
iB00_4217_v n1_467482_311086 0 0.08142855000000002
iB00_4218_v n1_489978_314176 0 -5.000000000349777e-09
iB00_4219_v n1_489978_311086 0 0.08082750000000001
iB00_4220_v n1_467482_310832 0 1.0999999999033091e-07
iB00_4221_v n1_467482_307488 0 2.7500000001246146e-07
iB00_4222_v n1_489978_310832 0 9.999999999344301e-08
iB00_4223_v n1_489978_307488 0 5.000000010090656e-09
iB00_4224_v n1_467482_304144 0 1.4999999982838122e-08
iB00_4225_v n1_467482_300800 0 -1.6999999998478735e-07
iB00_4226_v n1_489978_304144 0 8.499999999916994e-08
iB00_4227_v n1_489978_300800 0 -1.1000000000515399e-07
iB00_4228_v n1_467482_297456 0 2.0999999999012667e-07
iB00_4229_v n1_467482_294112 0 -3.3999999999667976e-07
iB00_4230_v n1_489978_297456 0 -3.000000000209866e-08
iB00_4231_v n1_489978_294112 0 -1.2499999999603892e-07
iB00_4232_v n1_467482_290768 0 1.7000000000172801e-07
iB00_4233_v n1_467482_288590 0 0.082139
iB00_4234_v n1_489978_290768 0 1.6499999999121384e-07
iB00_4235_v n1_489978_288590 0 0.08138100000000002
iB00_4236_v n1_467482_287424 0 1.1000000000007179e-07
iB00_4237_v n1_467482_284080 0 -1.8000000001259196e-07
iB00_4238_v n1_489978_287424 0 -2.3500000000966324e-07
iB00_4239_v n1_489978_284080 0 -6.499999998083018e-08
iB00_4240_v n1_467482_280736 0 8.999999999994323e-08
iB00_4241_v n1_467482_277392 0 -5.499999999707128e-08
iB00_4242_v n1_489978_280736 0 8.000000000559643e-08
iB00_4243_v n1_489978_277392 0 2.099999999858915e-07
iB00_4244_v n1_467482_274048 0 -9.9999999980314e-08
iB00_4245_v n1_467482_270704 0 -3.4999999995672174e-08
iB00_4246_v n1_489978_274048 0 -1.8000000001259196e-07
iB00_4247_v n1_489978_270704 0 -7.999999998357357e-08
iB00_4248_v n1_467482_267360 0 1.4499999998430902e-07
iB00_4249_v n1_467482_266702 0 0.0820445
iB00_4250_v n1_489978_267360 0 1.9999999974294053e-08
iB00_4251_v n1_489978_266702 0 0.08093050000000006
iB00_4252_v n1_467482_264016 0 -4.800000000179085e-07
iB00_4253_v n1_467482_260672 0 3.000000001565119e-08
iB00_4254_v n1_489978_264016 0 -1.4999999999694077e-07
iB00_4255_v n1_489978_260672 0 2.5499999996278147e-07
iB00_4256_v n1_467482_257328 0 1.4499999999023825e-07
iB00_4257_v n1_467482_253984 0 -1.5500000000406682e-07
iB00_4258_v n1_489978_257328 0 1.7499999997836087e-07
iB00_4259_v n1_489978_253984 0 -3.999999999966419e-07
iB00_4260_v n1_467482_250640 0 1.000000000112307e-07
iB00_4261_v n1_467482_247296 0 -9.999999997989048e-08
iB00_4262_v n1_489978_250640 0 5.5000000024176335e-08
iB00_4263_v n1_489978_247296 0 2.4999999969561632e-08
iB00_4264_v n1_467482_244814 0 0.07828199999999996
iB00_4265_v n1_467482_243952 0 2.999999998854613e-08
iB00_4266_v n1_489978_244814 0 0.07951800000000005
iB00_4267_v n1_489978_243952 0 2.000000003951559e-08
iB00_4268_v n1_467482_240608 0 -2.1499999999301754e-07
iB00_4269_v n1_467482_237264 0 6.500000001132336e-08
iB00_4270_v n1_489978_240608 0 4.2999999996231816e-07
iB00_4271_v n1_489978_237264 0 -1.2499999997571013e-07
iB00_4272_v n1_467482_233920 0 4.050000000130853e-07
iB00_4273_v n1_467482_230576 0 -1.85000000019718e-07
iB00_4274_v n1_489978_233920 0 -8.99999999656384e-08
iB00_4275_v n1_489978_230576 0 -2.999999994111229e-08
iB00_4276_v n1_467482_227232 0 -1.7000000000342208e-07
iB00_4277_v n1_467482_223888 0 -4.0000000002798214e-08
iB00_4278_v n1_489978_227232 0 1.349999999484576e-07
iB00_4279_v n1_489978_223888 0 -1.4999999999439968e-07
iB00_4280_v n1_467482_222318 0 0.08356700000000004
iB00_4281_v n1_467482_220544 0 -2.6000000004529344e-07
iB00_4282_v n1_489978_222318 0 0.08208749999999995
iB00_4283_v n1_489978_220544 0 1.5000000002235176e-07
iB00_4284_v n1_467482_217200 0 2.0500000002789337e-07
iB00_4285_v n1_467482_213856 0 -1.6500000004542395e-07
iB00_4286_v n1_489978_217200 0 0.0
iB00_4287_v n1_489978_213856 0 -5.0000000028908756e-08
iB00_4288_v n1_467482_210512 0 1.149999999961864e-07
iB00_4289_v n1_467482_207168 0 4.9999999962840186e-08
iB00_4290_v n1_489978_210512 0 -4.9999999962840186e-08
iB00_4291_v n1_489978_207168 0 5.000000001874436e-08
iB00_4292_v n1_467482_203824 0 1.0000000006459378e-07
iB00_4293_v n1_467482_200480 0 -2.5000000003104136e-07
iB00_4294_v n1_489978_203824 0 2.4999999997683126e-07
iB00_4295_v n1_489978_200480 0 5.000000005008458e-08
iB00_4296_v n1_467482_200430 0 0.08071100000000002
iB00_4297_v n1_467482_197136 0 1.5000000005115088e-07
iB00_4298_v n1_489978_200430 0 0.079635
iB00_4299_v n1_489978_197136 0 -3.0000000002437474e-07
iB00_4300_v n1_467482_193792 0 -1.500000000231988e-07
iB00_4301_v n1_467482_190448 0 1.0000000003410059e-07
iB00_4302_v n1_489978_193792 0 5.0000000017050295e-08
iB00_4303_v n1_489978_190448 0 4.999999998486304e-08
iB00_4304_v n1_467482_187104 0 -3.7269449679189215e-17
iB00_4305_v n1_467482_183760 0 5.000000012547051e-08
iB00_4306_v n1_489978_187104 0 -3.0000000004809166e-07
iB00_4307_v n1_489978_183760 0 4.999999996961645e-08
iB00_4308_v n1_467482_180416 0 -2.500000000115596e-07
iB00_4309_v n1_467482_177934 0 0.08127850000000011
iB00_4310_v n1_489978_180416 0 0.0
iB00_4311_v n1_489978_177934 0 0.08165249999999993
iB00_4312_v n1_467482_177072 0 -5.000000004246128e-08
iB00_4313_v n1_467482_173728 0 -9.999999997989048e-08
iB00_4314_v n1_489978_177072 0 -1.9999999995978096e-07
iB00_4315_v n1_489978_173728 0 -1.5000000002235176e-07
iB00_4316_v n1_467482_170384 0 5.00000000068859e-08
iB00_4317_v n1_467482_167040 0 -1.4999999994273067e-07
iB00_4318_v n1_489978_170384 0 9.999999997989048e-08
iB00_4319_v n1_489978_167040 0 1.000000000137718e-07
iB00_4320_v n1_467482_163696 0 3.4999999994147514e-07
iB00_4321_v n1_467482_160352 0 -4.9999999962840186e-08
iB00_4322_v n1_489978_163696 0 -2.0000000001399107e-07
iB00_4323_v n1_489978_160352 0 2.999999999515299e-07
iB00_4324_v n1_467482_157008 0 -1.9999999998603898e-07
iB00_4325_v n1_467482_156046 0 0.08061749999999995
iB00_4326_v n1_489978_157008 0 -4.9999999962840186e-08
iB00_4327_v n1_489978_156046 0 0.08074150000000001
iB00_4328_v n1_467482_153664 0 -2.0000000001314404e-07
iB00_4329_v n1_467482_150320 0 4.499999999908223e-07
iB00_4330_v n1_489978_153664 0 2.9999999999388155e-07
iB00_4331_v n1_489978_150320 0 1.5000000001388143e-07
iB00_4332_v n1_467482_146976 0 -1.500000000621623e-07
iB00_4333_v n1_467482_143632 0 5.00000000712604e-08
iB00_4334_v n1_489978_146976 0 -2.5000000003104136e-07
iB00_4335_v n1_489978_143632 0 -9.999999999174894e-08
iB00_4336_v n1_467482_140288 0 -5.00000000712604e-08
iB00_4337_v n1_467482_136944 0 -2.9999999993967144e-07
iB00_4338_v n1_489978_140288 0 2.4999999997683126e-07
iB00_4339_v n1_489978_136944 0 1.500000000054111e-07
iB00_4340_v n1_467482_133600 0 2.500000000090185e-07
iB00_4341_v n1_467482_133550 0 0.08190650000000003
iB00_4342_v n1_489978_133600 0 -3.4999999995672174e-07
iB00_4343_v n1_489978_133550 0 0.07795750000000008
iB00_4344_v n1_467482_130256 0 -2.5000000003612356e-07
iB00_4345_v n1_467482_126912 0 1.9999999995978096e-07
iB00_4346_v n1_489978_130256 0 -2.4999999997683126e-07
iB00_4347_v n1_489978_126912 0 1.9999999997841569e-07
iB00_4348_v n1_467482_123568 0 3.0000000004300946e-07
iB00_4349_v n1_467482_120224 0 -3.0000000004809166e-07
iB00_4350_v n1_489978_123568 0 -1.4999999999694077e-07
iB00_4351_v n1_489978_120224 0 -2.202285662861181e-17
iB00_4352_v n1_467482_116880 0 -1.4999999996305946e-07
iB00_4353_v n1_467482_113536 0 1.9999999995978096e-07
iB00_4354_v n1_489978_116880 0 2.5000000003104136e-07
iB00_4355_v n1_489978_113536 0 4.9999999983168977e-08
iB00_4356_v n1_467482_111662 0 0.08178299999999998
iB00_4357_v n1_467482_110192 0 1.000000000883107e-07
iB00_4358_v n1_489978_111662 0 0.07938300000000009
iB00_4359_v n1_489978_110192 0 9.99999999392329e-08
iB00_4360_v n1_467482_106848 0 3.4999999994994547e-07
iB00_4361_v n1_467482_103504 0 -3.4999999995672174e-07
iB00_4362_v n1_489978_106848 0 -4.9999999962840186e-08
iB00_4363_v n1_445290_100160 0 -4.9999999962840186e-08
iB00_4364_v n1_489978_103504 0 4.4999999998912826e-07
iB00_4365_v n1_467482_100160 0 -9.147955830346444e-17
iB00_4366_v n1_467482_96816 0 -4.999999999333337e-08
iB00_4367_v n1_489978_100160 0 0.0
iB00_4368_v n1_445290_96816 0 1.4999999995967133e-07
iB00_4369_v n1_445290_93472 0 -3.499999999787446e-07
iB00_4370_v n1_422794_96816 0 0.0
iB00_4371_v n1_422794_93472 0 1.8634724839594607e-17
iB00_4372_v n1_422794_90128 0 1.5000000002404583e-07
iB00_4373_v n1_400602_93472 0 -1.9999999998688602e-07
iB00_4374_v n1_400602_90128 0 -1.800000000159801e-07
iB00_4375_v n1_400602_89166 0 0.07892750000000007
iB00_4376_v n1_378410_90128 0 -1.599999999840878e-07
iB00_4377_v n1_378410_89166 0 0.08022549999999996
iB00_4378_v n1_378410_86784 0 2.4499999994260016e-07
iB00_4379_v n1_355914_89166 0 0.08139780000000003
iB00_4380_v n1_400602_86784 0 2.1500000001080523e-07
iB00_4381_v n1_400602_83440 0 -1.0500000001412158e-07
iB00_4382_v n1_422794_83440 0 -2.999999999667765e-07
iB00_4383_v n1_422794_86784 0 2.4999999997683126e-07
iB00_4384_v n1_445290_86784 0 -5.421010862427522e-17
iB00_4385_v n1_422794_89166 0 0.08336949999999997
iB00_4386_v n1_445290_89166 0 0.07987050000000007
iB00_4387_v n1_467482_89166 0 0.0805235
iB00_4388_v n1_445290_90128 0 -2.541098841762901e-17
iB00_4389_v n1_467482_90128 0 -5.0000000017050295e-08
iB00_4390_v n1_489978_90128 0 -9.999999997989048e-08
iB00_4391_v n1_467482_93472 0 -4.999999996961645e-08
iB00_4392_v n1_489978_93472 0 2.5000000003104136e-07
iB00_4393_v n1_512170_93472 0 -5.000000012547051e-08
iB00_4394_v n1_489978_96816 0 -4.0000000001781774e-07
iB00_4395_v n1_512170_96816 0 -8.999999998732244e-07
iB00_4396_v n1_534666_96816 0 1.300000000013015e-06
iB00_4397_v n1_512170_100160 0 3.4999999999534644e-06
iB00_4398_v n1_512170_103504 0 -1.8499999998719194e-06
iB00_4399_v n1_534666_100160 0 -2.6499999999278837e-06
iB00_4400_v n1_534666_103504 0 -4.999999999536625e-07
iB00_4401_v n1_512170_106848 0 -1.8000000001055908e-06
iB00_4402_v n1_512170_110192 0 3.600000000034999e-06
iB00_4403_v n1_534666_106848 0 2.6499999999278837e-06
iB00_4404_v n1_534666_110192 0 -3.100000000050843e-06
iB00_4405_v n1_512170_111662 0 0.06959000000000001
iB00_4406_v n1_512170_113536 0 1.0842021724855044e-16
iB00_4407_v n1_534666_111662 0 0.06440500000000013
iB00_4408_v n1_534666_113536 0 -3.45000000008888e-06
iB00_4409_v n1_512170_116880 0 2.9499999999861397e-06
iB00_4410_v n1_512170_120224 0 1.4499999999523575e-06
iB00_4411_v n1_534666_116880 0 3.1499999999899664e-06
iB00_4412_v n1_534666_120224 0 6.000000000978774e-07
iB00_4413_v n1_512170_123568 0 -4.599999999920301e-06
iB00_4414_v n1_512170_126912 0 -1.500000001595711e-07
iB00_4415_v n1_534666_123568 0 -1.0500000000327955e-06
iB00_4416_v n1_534666_126912 0 -1.900000000078705e-06
iB00_4417_v n1_512170_130256 0 4.749999999978228e-06
iB00_4418_v n1_512170_133550 0 0.0713999999999999
iB00_4419_v n1_534666_130256 0 2.9500000001386056e-06
iB00_4420_v n1_534666_133550 0 0.06440000000000004
iB00_4421_v n1_512170_133600 0 5.99999999986069e-07
iB00_4422_v n1_512170_136944 0 -1.6500000000205586e-06
iB00_4423_v n1_534666_133600 0 -7.499999999304938e-07
iB00_4424_v n1_534666_136944 0 1.24999999997733e-06
iB00_4425_v n1_512170_140288 0 1.599999999940828e-06
iB00_4426_v n1_512170_143632 0 2.4999999997683126e-07
iB00_4427_v n1_534666_140288 0 -1.199999999867106e-06
iB00_4428_v n1_534666_143632 0 1.8499999999854218e-06
iB00_4429_v n1_512170_146976 0 -7.499999999643751e-07
iB00_4430_v n1_512170_150320 0 3.600000000034999e-06
iB00_4431_v n1_534666_146976 0 3.5000000001093184e-07
iB00_4432_v n1_534666_150320 0 -7.499999999847039e-07
iB00_4433_v n1_512170_153664 0 -1.800000000085262e-06
iB00_4434_v n1_512170_156046 0 0.06999550000000017
iB00_4435_v n1_534666_153664 0 -1.4999999999694077e-06
iB00_4436_v n1_534666_156046 0 0.0644049999999999
iB00_4437_v n1_512170_157008 0 1.9999999999366228e-07
iB00_4438_v n1_512170_160352 0 -5.0000000017050295e-08
iB00_4439_v n1_534666_157008 0 -3.3000000001495375e-06
iB00_4440_v n1_534666_160352 0 1.5000000000405585e-06
iB00_4441_v n1_512170_163696 0 -1.5000000004776275e-07
iB00_4442_v n1_512170_167040 0 -9.999999992568037e-08
iB00_4443_v n1_534666_163696 0 1.6000000001119286e-06
iB00_4444_v n1_534666_167040 0 -3.200000000071391e-06
iB00_4445_v n1_512170_170384 0 5.000000001874436e-08
iB00_4446_v n1_512170_173728 0 2.4999999997683126e-07
iB00_4447_v n1_534666_170384 0 2.2500000000083217e-06
iB00_4448_v n1_534666_173728 0 -2.200000000052258e-06
iB00_4449_v n1_512170_177072 0 -4.500000000101347e-06
iB00_4450_v n1_512170_177934 0 0.06959750000000013
iB00_4451_v n1_534666_177072 0 3.400000000075218e-06
iB00_4452_v n1_534666_177934 0 0.06440150000000001
iB00_4453_v n1_512170_180416 0 -9.999999994600916e-08
iB00_4454_v n1_512170_183760 0 -5.0000000017050295e-08
iB00_4455_v n1_534666_180416 0 -3.050000000064286e-06
iB00_4456_v n1_534666_183760 0 -4.999999987983096e-08
iB00_4457_v n1_512170_187104 0 5.0000000025520624e-08
iB00_4458_v n1_512170_190448 0 1.4999999999694077e-07
iB00_4459_v n1_534666_187104 0 2.949999999921765e-06
iB00_4460_v n1_534666_190448 0 8.999999999985853e-07
iB00_4461_v n1_512170_193792 0 -3.500000000092378e-07
iB00_4462_v n1_512170_197136 0 1.5000000005115088e-07
iB00_4463_v n1_534666_193792 0 -1.100000000158266e-06
iB00_4464_v n1_534666_197136 0 -3.1999999998748795e-06
iB00_4465_v n1_512170_200430 0 0.07005949999999998
iB00_4466_v n1_512170_200480 0 -2.9999999999388155e-07
iB00_4467_v n1_534666_200430 0 0.06440399999999989
iB00_4468_v n1_534666_200480 0 -2.5000000001240664e-07
iB00_4469_v n1_512170_203824 0 1.9999999992081745e-07
iB00_4470_v n1_512170_207168 0 1.50000000105361e-07
iB00_4471_v n1_534666_203824 0 3.9999999997377203e-07
iB00_4472_v n1_534666_207168 0 -9.999999999513707e-08
iB00_4473_v n1_512170_210512 0 -1.8634724839594607e-17
iB00_4474_v n1_512170_213856 0 -3.5000000001093184e-07
iB00_4475_v n1_534666_210512 0 -2.5000000003104136e-07
iB00_4476_v n1_534666_213856 0 4.999999998486304e-08
iB00_4477_v n1_512170_217200 0 2.0000000000382667e-07
iB00_4478_v n1_512170_220544 0 0.0
iB00_4479_v n1_534666_217200 0 2.0000000001399107e-07
iB00_4480_v n1_534666_220544 0 -1.9999999998010975e-07
iB00_4481_v n1_512170_222318 0 0.06857500000000008
iB00_4482_v n1_512170_223888 0 0.0
iB00_4483_v n1_534666_222318 0 0.06440149999999996
iB00_4484_v n1_534666_223888 0 -2.0000000006311898e-07
iB00_4485_v n1_512170_227232 0 -1.5000000001981066e-07
iB00_4486_v n1_512170_230576 0 5.0000000017050295e-08
iB00_4487_v n1_534666_227232 0 1.5000000005115088e-07
iB00_4488_v n1_534666_230576 0 -1.9999999998773305e-07
iB00_4489_v n1_512170_233920 0 5.0000000019591393e-08
iB00_4490_v n1_512170_237264 0 -1.4999999999694077e-07
iB00_4491_v n1_534666_233920 0 2.300000000025372e-07
iB00_4492_v n1_534666_237264 0 4.500000006328733e-08
iB00_4493_v n1_512170_240608 0 -6.000000004061974e-08
iB00_4494_v n1_512170_243952 0 3.8500000003370907e-07
iB00_4495_v n1_534666_240608 0 -3.350000000166588e-07
iB00_4496_v n1_534666_243952 0 6.500000002487589e-08
iB00_4497_v n1_512170_244814 0 0.07059799999999995
iB00_4498_v n1_512170_247296 0 1.5000000005115088e-07
iB00_4499_v n1_534666_244814 0 0.06440199999999992
iB00_4500_v n1_534666_247296 0 -1.1000000003480014e-07
iB00_4501_v n1_512170_250640 0 5.999999999403293e-08
iB00_4502_v n1_512170_253984 0 -2.1000000002824315e-07
iB00_4503_v n1_534666_250640 0 8.499999998561741e-08
iB00_4504_v n1_534666_253984 0 6.500000002148776e-08
iB00_4505_v n1_512170_257328 0 3.250000000430643e-07
iB00_4506_v n1_512170_260672 0 -3.65000000059415e-07
iB00_4507_v n1_534666_257328 0 -1.7000000002544494e-07
iB00_4508_v n1_534666_260672 0 -9.999999998666674e-08
iB00_4509_v n1_512170_264016 0 2.0499999999062392e-07
iB00_4510_v n1_512170_266702 0 0.068818
iB00_4511_v n1_534666_264016 0 2.700000000053354e-07
iB00_4512_v n1_534666_266702 0 0.06440149999999996
iB00_4513_v n1_512170_267360 0 1.6000000000780472e-07
iB00_4514_v n1_512170_270704 0 -2.000000002850416e-08
iB00_4515_v n1_534666_267360 0 -1.2999999996843661e-07
iB00_4516_v n1_534666_270704 0 2.5000000001748884e-08
iB00_4517_v n1_512170_274048 0 2.5000000016148444e-08
iB00_4518_v n1_512170_277392 0 -2.1499999998115908e-07
iB00_4519_v n1_534666_274048 0 -2.710505431213761e-17
iB00_4520_v n1_534666_277392 0 3.0500000000016056e-07
iB00_4521_v n1_512170_280736 0 2.699999999926299e-07
iB00_4522_v n1_512170_284080 0 -3.999999997569316e-08
iB00_4523_v n1_534666_280736 0 -6.000000000419732e-08
iB00_4524_v n1_534666_284080 0 -6.999999998837973e-08
iB00_4525_v n1_512170_287424 0 -1.3499999999419738e-07
iB00_4526_v n1_512170_288590 0 0.06835299999999997
iB00_4527_v n1_534666_287424 0 2.649999999982094e-07
iB00_4528_v n1_534666_288590 0 0.06440100000000001
iB00_4529_v n1_512170_290768 0 -1.49999999951201e-08
iB00_4530_v n1_512170_294112 0 -2.100000000011381e-07
iB00_4531_v n1_534666_290768 0 -1.4999999994273067e-08
iB00_4532_v n1_534666_294112 0 1.6999999999579878e-07
iB00_4533_v n1_512170_297456 0 -1.350000000026677e-07
iB00_4534_v n1_512170_300800 0 2.5500000001106235e-07
iB00_4535_v n1_534666_297456 0 2.1499999998115908e-07
iB00_4536_v n1_534666_300800 0 -3.5999999999511426e-07
iB00_4537_v n1_512170_304144 0 -4.999999993573513e-09
iB00_4538_v n1_512170_307488 0 1.2999999996843661e-07
iB00_4539_v n1_534666_304144 0 -4.49999999828192e-08
iB00_4540_v n1_534666_307488 0 1.699999999602234e-07
iB00_4541_v n1_512170_310832 0 -3.0999999998526374e-07
iB00_4542_v n1_512170_311086 0 0.0803575
iB00_4543_v n1_534666_310832 0 -2.0999999997403304e-07
iB00_4544_v n1_534666_311086 0 0.07780650000000001
iB00_4545_v n1_512170_314176 0 -4.0000000002798214e-08
iB00_4546_v n1_512170_317520 0 4.499999999637173e-08
iB00_4547_v n1_534666_314176 0 -5.000000000349777e-09
iB00_4548_v n1_534666_317520 0 -1.9999999992081745e-08
iB00_4549_v n1_512170_320864 0 -2.0000000001822623e-08
iB00_4550_v n1_512170_324208 0 -9.99999999392329e-09
iB00_4551_v n1_534666_320864 0 -8.50000000059462e-08
iB00_4552_v n1_534666_324208 0 -1.9000000000143305e-07
iB00_4553_v n1_512170_327552 0 1.9999999992081745e-08
iB00_4554_v n1_512170_330896 0 0.0
iB00_4555_v n1_534666_327552 0 1.8500000000616548e-07
iB00_4556_v n1_534666_330896 0 5.999999999487996e-08
iB00_4557_v n1_512170_332974 0 0.07953710000000005
iB00_4558_v n1_512170_334240 0 1.4999999994273067e-08
iB00_4559_v n1_534666_332974 0 0.08108464999999997
iB00_4560_v n1_534666_334240 0 3.000000000209866e-08
iB00_4561_v n1_512170_337584 0 -2.499999999751372e-08
iB00_4562_v n1_512170_340928 0 2.5000000001748884e-08
iB00_4563_v n1_534666_337584 0 -1.9999999994622843e-08
iB00_4564_v n1_534666_340928 0 -1.4999999999355264e-08
iB00_4565_v n1_512170_344272 0 5.000000002043843e-09
iB00_4566_v n1_512170_347616 0 -2.0000000001399107e-08
iB00_4567_v n1_534666_344272 0 1.500000000104933e-08
iB00_4568_v n1_534666_347616 0 9.99999999265274e-09
iB00_4569_v n1_512170_350960 0 5.0000000028908756e-09
iB00_4570_v n1_512170_354304 0 -2.0000000001399107e-08
iB00_4571_v n1_534666_350960 0 -5.000000000349777e-09
iB00_4572_v n1_534666_354304 0 3.3881317890172014e-18
iB00_4573_v n1_512170_355470 0 0.08226464999999998
iB00_4574_v n1_512170_357648 0 -2.650000000117619e-07
iB00_4575_v n1_534666_355470 0 0.08216305000000003
iB00_4576_v n1_534666_357648 0 4.999999973668239e-09
iB00_4577_v n1_512170_360992 0 1.5999999999044055e-07
iB00_4578_v n1_512170_364336 0 -7.99999999920439e-08
iB00_4579_v n1_534666_360992 0 9.500000002697455e-08
iB00_4580_v n1_534666_364336 0 9.000000000121378e-08
iB00_4581_v n1_512170_367680 0 -3.000000000336921e-08
iB00_4582_v n1_512170_371024 0 2.549999999975098e-07
iB00_4583_v n1_534666_367680 0 -5.421010862427522e-17
iB00_4584_v n1_534666_371024 0 -1.650000000001077e-07
iB00_4585_v n1_512170_374368 0 -2.5999999999362443e-07
iB00_4586_v n1_512170_377358 0 0.06901149999999996
iB00_4587_v n1_534666_374368 0 1.0000000000699553e-07
iB00_4588_v n1_534666_377358 0 0.06709900000000002
iB00_4589_v n1_512170_377712 0 -1.449999999991321e-07
iB00_4590_v n1_512170_381056 0 -1.0999999996703751e-07
iB00_4591_v n1_534666_377712 0 -1.6500000004542395e-07
iB00_4592_v n1_534666_381056 0 3.200000000092567e-07
iB00_4593_v n1_512170_384400 0 3.499999998804888e-08
iB00_4594_v n1_512170_387744 0 2.999999999667765e-07
iB00_4595_v n1_534666_384400 0 -2.6500000002531443e-07
iB00_4596_v n1_534666_387744 0 5.5000000039846444e-08
iB00_4597_v n1_512170_391088 0 -3.099999999810286e-07
iB00_4598_v n1_512170_394432 0 2.1499999998115908e-07
iB00_4599_v n1_534666_391088 0 2.799999999653774e-07
iB00_4600_v n1_534666_394432 0 -1.1499999999279827e-07
iB00_4601_v n1_512170_397776 0 -1.299999999735188e-07
iB00_4602_v n1_512170_399854 0 0.0685455
iB00_4603_v n1_534666_397776 0 -1.3500000002977276e-07
iB00_4604_v n1_534666_399854 0 0.06440149999999999
iB00_4605_v n1_512170_401120 0 2.800000000272108e-07
iB00_4606_v n1_512170_404464 0 -3.150000000423647e-07
iB00_4607_v n1_534666_401120 0 -9.999999960041972e-09
iB00_4608_v n1_534666_404464 0 7.499999998152973e-08
iB00_4609_v n1_512170_407808 0 2.199999999721915e-07
iB00_4610_v n1_512170_411152 0 -1.2499999998841563e-07
iB00_4611_v n1_534666_407808 0 1.5000000102693284e-08
iB00_4612_v n1_534666_411152 0 -1.8500000002141207e-07
iB00_4613_v n1_512170_414496 0 1.5000000004860978e-07
iB00_4614_v n1_512170_417840 0 2.499999995431504e-08
iB00_4615_v n1_534666_414496 0 -2.999999998854613e-08
iB00_4616_v n1_534666_417840 0 -5.590417451878382e-17
iB00_4617_v n1_512170_421184 0 -1.4399560103323106e-17
iB00_4618_v n1_512170_421742 0 0.06805649999999999
iB00_4619_v n1_534666_421184 0 -1.0500000001412158e-07
iB00_4620_v n1_534666_421742 0 0.06440200000000003
iB00_4621_v n1_512170_424528 0 -1.8000000003800295e-07
iB00_4622_v n1_512170_427872 0 2.800000000195875e-07
iB00_4623_v n1_534666_424528 0 -1.349999999484576e-07
iB00_4624_v n1_534666_427872 0 2.549999999839573e-07
iB00_4625_v n1_512170_431216 0 -1.4999999998592935e-07
iB00_4626_v n1_512170_434560 0 0.0
iB00_4627_v n1_534666_431216 0 1.5000000048483175e-08
iB00_4628_v n1_534666_434560 0 -3.000000000624912e-07
iB00_4629_v n1_512170_437904 0 2.5000000004120576e-07
iB00_4630_v n1_512170_441248 0 4.9999999962840186e-08
iB00_4631_v n1_534666_437904 0 -1.9999999995978096e-07
iB00_4632_v n1_534666_441248 0 2.999999999083312e-07
iB00_4633_v n1_512170_444238 0 0.06718400000000002
iB00_4634_v n1_512170_444592 0 -2.9999999999388155e-07
iB00_4635_v n1_534666_444238 0 0.06440150000000001
iB00_4636_v n1_534666_444592 0 1.4999999995713023e-07
iB00_4637_v n1_512170_447936 0 1.0000000000530147e-07
iB00_4638_v n1_512170_451280 0 1.0000000003410059e-07
iB00_4639_v n1_534666_447936 0 -3.5000000001093184e-07
iB00_4640_v n1_534666_451280 0 1.000000000137718e-07
iB00_4641_v n1_512170_454624 0 -2.0000000005549568e-07
iB00_4642_v n1_512170_457968 0 1.0000000003410059e-07
iB00_4643_v n1_534666_454624 0 -4.9999999962840186e-08
iB00_4644_v n1_534666_457968 0 2.9999999998371715e-07
iB00_4645_v n1_512170_461312 0 1.0000000002224213e-07
iB00_4646_v n1_512170_464656 0 -1.0000000003410059e-07
iB00_4647_v n1_534666_461312 0 -4.5000000004503243e-07
iB00_4648_v n1_534666_464656 0 2.500000000428998e-07
iB00_4649_v n1_512170_466126 0 0.06829700000000004
iB00_4650_v n1_512170_468000 0 -1.4999999999694077e-07
iB00_4651_v n1_534666_466126 0 0.06440199999999992
iB00_4652_v n1_534666_468000 0 2.5000000011574466e-07
iB00_4653_v n1_512170_471344 0 2.4999999996158466e-07
iB00_4654_v n1_512170_474688 0 -9.999999997989048e-08
iB00_4655_v n1_534666_471344 0 9.99999999907325e-07
iB00_4656_v n1_534666_474688 0 -3.3000000000182474e-06
iB00_4657_v n1_512170_478032 0 -5.000000002721469e-08
iB00_4658_v n1_512170_481376 0 -1.4999999994273067e-07
iB00_4659_v n1_534666_478032 0 2.3999999999510524e-06
iB00_4660_v n1_534666_481376 0 -1.949999999988182e-06
iB00_4661_v n1_512170_484720 0 1.999999999995915e-07
iB00_4662_v n1_512170_488064 0 -5.421010862427522e-17
iB00_4663_v n1_534666_484720 0 -1.199999999867106e-06
iB00_4664_v n1_534666_488064 0 -4.5000000006620826e-07
iB00_4665_v n1_512170_488622 0 0.06979999999999996
iB00_4666_v n1_512170_491408 0 3.3000000000411173e-06
iB00_4667_v n1_534666_488622 0 0.06440200000000008
iB00_4668_v n1_534666_491408 0 -4.500000001907221e-07
iB00_4669_v n1_512170_494752 0 -3.7499999999218253e-06
iB00_4670_v n1_512170_498096 0 4.150000000005712e-06
iB00_4671_v n1_534666_494752 0 2.500000000093573e-06
iB00_4672_v n1_534666_498096 0 5.999999999504936e-07
iB00_4673_v n1_512170_501440 0 -2.949999999970893e-06
iB00_4674_v n1_512170_504784 0 -1.5000000005115088e-07
iB00_4675_v n1_534666_501440 0 -1.149999999958476e-06
iB00_4676_v n1_534666_504784 0 2.3999999999375e-06
iB00_4677_v n1_512170_508128 0 2.650000000168441e-06
iB00_4678_v n1_512170_510510 0 0.06666699999999974
iB00_4679_v n1_534666_508128 0 -3.85000000012025e-06
iB00_4680_v n1_534666_510510 0 0.06440500000000013
iB00_4681_v n1_512170_511472 0 -1.199999999997549e-06
iB00_4682_v n1_512170_514816 0 8.500000000730146e-07
iB00_4683_v n1_534666_511472 0 -2.149999999974221e-06
iB00_4684_v n1_534666_514816 0 -1.4500000001861385e-06
iB00_4685_v n1_512170_518160 0 -2.1500000000131847e-06
iB00_4686_v n1_512170_521504 0 -1.5000000005115088e-07
iB00_4687_v n1_534666_518160 0 4.700000000084845e-06
iB00_4688_v n1_534666_521504 0 -3.69999999993188e-06
iB00_4689_v n1_512170_524848 0 1.900000000156632e-06
iB00_4690_v n1_512170_528192 0 -1.0000000001241655e-06
iB00_4691_v n1_534666_524848 0 3.3999999999667976e-06
iB00_4692_v n1_534666_528192 0 -3.999999999985054e-06
iB00_4693_v n1_512170_531536 0 1.1500000000313207e-06
iB00_4694_v n1_512170_532398 0 0.06873999999999986
iB00_4695_v n1_534666_531536 0 4.299999999948442e-06
iB00_4696_v n1_534666_532398 0 0.06439999999999994
iB00_4697_v n1_512170_534880 0 -2.3499999998679335e-06
iB00_4698_v n1_512170_538224 0 2.749999999853564e-06
iB00_4699_v n1_534666_534880 0 -1.2499999998841563e-06
iB00_4700_v n1_534666_538224 0 1.200000000046677e-06
iB00_4701_v n1_512170_541568 0 -1.949999999931431e-06
iB00_4702_v n1_512170_544912 0 -1.5500000000948783e-06
iB00_4703_v n1_534666_541568 0 -5.999999999877631e-07
iB00_4704_v n1_534666_544912 0 3.4499999999770717e-06
iB00_4705_v n1_512170_548256 0 4.1500000000802505e-06
iB00_4706_v n1_512170_551600 0 0.0
iB00_4707_v n1_534666_548256 0 -1.6500000000205586e-06
iB00_4708_v n1_534666_551600 0 -8.000000000932337e-07
iB00_4709_v n1_512170_554894 0 0.06890999999999993
iB00_4710_v n1_512170_554944 0 1.700000000037609e-06
iB00_4711_v n1_534666_554894 0 0.06440000000000004
iB00_4712_v n1_534666_554944 0 2.100000000065591e-06
iB00_4713_v n1_512170_558288 0 -9.999999999107132e-07
iB00_4714_v n1_534666_558288 0 -7.499999999440463e-07
iB00_4715_v n1_556858_558288 0 -2.5000000008525147e-07
iB00_4716_v n1_579050_558288 0 1.050000000019243e-06
iB00_4717_v n1_556858_554944 0 1.4999999994273067e-07
iB00_4718_v n1_579050_554944 0 -2.1499999999877737e-06
iB00_4719_v n1_601546_558288 0 -5.0000000017050295e-08
iB00_4720_v n1_623064_558288 0 5.000000000095667e-08
iB00_4721_v n1_601546_554944 0 -3.000000000155656e-06
iB00_4722_v n1_623064_561632 0 1.6940658945086007e-18
iB00_4723_v n1_625064_561632 0 0.0
iB00_4724_v n1_627064_561632 0 0.0
iB00_4725_v n1_625064_558288 0 -3.0499999997500368e-06
iB00_4726_v n1_627064_564976 0 0.0
iB00_4727_v n1_625064_554944 0 3.2499999993693105e-06
iB00_4728_v n1_627064_558288 0 0.0
iB00_4729_v n1_625064_554894 0 2.6801480868994202e-14
iB00_4730_v n1_627064_554944 0 0.0
iB00_4731_v n1_623064_554944 0 -5.00000000018037e-08
iB00_4732_v n1_601546_554894 0 0.06440000000000026
iB00_4733_v n1_601546_551600 0 1.449999999759234e-06
iB00_4734_v n1_579050_554894 0 0.06440000000000004
iB00_4735_v n1_556858_554894 0 0.06440000000000004
iB00_4736_v n1_579050_551600 0 2.8999999998454226e-06
iB00_4737_v n1_556858_551600 0 1.4499999999523575e-06
iB00_4738_v n1_556858_548256 0 -3.64999999996904e-06
iB00_4739_v n1_556858_544912 0 3.050000000064286e-06
iB00_4740_v n1_579050_548256 0 1.8000000001801297e-06
iB00_4741_v n1_579050_544912 0 -2.999999999977779e-06
iB00_4742_v n1_556858_541568 0 1.3999999999793529e-06
iB00_4743_v n1_556858_538224 0 -3.7500000000861497e-06
iB00_4744_v n1_579050_541568 0 -1.8000000001801297e-06
iB00_4745_v n1_579050_538224 0 2.5000000002765323e-07
iB00_4746_v n1_556858_534880 0 2.40000000009166e-06
iB00_4747_v n1_556858_532398 0 0.06439999999999994
iB00_4748_v n1_579050_534880 0 2.8000000000874548e-06
iB00_4749_v n1_579050_532398 0 0.06440000000000004
iB00_4750_v n1_556858_531536 0 -4.9999999950981725e-08
iB00_4751_v n1_556858_528192 0 -2.7499999999619842e-06
iB00_4752_v n1_579050_531536 0 9.999999992568037e-08
iB00_4753_v n1_579050_528192 0 -1.1500000000059097e-06
iB00_4754_v n1_556858_524848 0 4.4999999992983595e-07
iB00_4755_v n1_556858_521504 0 -4.5000000004503243e-07
iB00_4756_v n1_579050_524848 0 2.6499999999278837e-06
iB00_4757_v n1_579050_521504 0 -3.4999999999636288e-06
iB00_4758_v n1_556858_518160 0 4.4000000000248945e-06
iB00_4759_v n1_556858_514816 0 -4.999999990863008e-08
iB00_4760_v n1_579050_518160 0 2.4999999997683126e-07
iB00_4761_v n1_579050_514816 0 3.899999999942483e-06
iB00_4762_v n1_556858_511472 0 -3.950000000113693e-06
iB00_4763_v n1_556858_510510 0 0.06440100000000007
iB00_4764_v n1_579050_511472 0 -2.650000000036304e-06
iB00_4765_v n1_579050_510510 0 0.06440000000000004
iB00_4766_v n1_556858_508128 0 1.399999999984435e-06
iB00_4767_v n1_556858_504784 0 -3.5000000001093184e-07
iB00_4768_v n1_579050_508128 0 9.499999999986949e-07
iB00_4769_v n1_579050_504784 0 3.450000000087186e-06
iB00_4770_v n1_556858_501440 0 -1.5999999999662389e-06
iB00_4771_v n1_556858_498096 0 2.3999999999510524e-06
iB00_4772_v n1_579050_501440 0 -4.350000000073913e-06
iB00_4773_v n1_579050_498096 0 2.549999999964087e-06
iB00_4774_v n1_556858_494752 0 -3.2000000000256514e-06
iB00_4775_v n1_556858_491408 0 1.4000000000437274e-06
iB00_4776_v n1_579050_494752 0 -9.499999999986949e-07
iB00_4777_v n1_579050_491408 0 2.0000000009107107e-07
iB00_4778_v n1_556858_488622 0 0.06440299999999999
iB00_4779_v n1_556858_488064 0 -1.95000000001444e-06
iB00_4780_v n1_579050_488622 0 0.06440249999999992
iB00_4781_v n1_579050_488064 0 1.2000000000178778e-06
iB00_4782_v n1_556858_484720 0 -9.500000000545991e-07
iB00_4783_v n1_556858_481376 0 2.0000000006820118e-07
iB00_4784_v n1_579050_484720 0 -1.7999999999632893e-06
iB00_4785_v n1_579050_481376 0 -1.4999999989783792e-07
iB00_4786_v n1_556858_478032 0 1.4499999998956062e-06
iB00_4787_v n1_556858_474688 0 2.900000000013135e-06
iB00_4788_v n1_579050_478032 0 1.1000000000498458e-06
iB00_4789_v n1_579050_474688 0 -3.099999999942423e-06
iB00_4790_v n1_556858_471344 0 -6.000000000157152e-07
iB00_4791_v n1_556858_468000 0 -3.9499999999375104e-06
iB00_4792_v n1_579050_471344 0 2.329999999905498e-06
iB00_4793_v n1_579050_468000 0 2.345000000026826e-06
iB00_4794_v n1_556858_466126 0 0.06440149999999996
iB00_4795_v n1_556858_464656 0 4.150000000005712e-06
iB00_4796_v n1_579050_466126 0 0.06439749999999995
iB00_4797_v n1_579050_464656 0 7.249999999719436e-07
iB00_4798_v n1_556858_461312 0 -8.499999999747588e-07
iB00_4799_v n1_556858_457968 0 -8.500000000730146e-07
iB00_4800_v n1_579050_461312 0 2.115000000005654e-06
iB00_4801_v n1_579050_457968 0 -1.8999999999838374e-06
iB00_4802_v n1_556858_454624 0 -7.999999999653318e-07
iB00_4803_v n1_556858_451280 0 -7.000000001302839e-07
iB00_4804_v n1_579050_454624 0 -1.2949999999211856e-06
iB00_4805_v n1_579050_451280 0 3.895000000016672e-06
iB00_4806_v n1_556858_447936 0 -5.849999998461063e-07
iB00_4807_v n1_556858_444592 0 -4.850000001220198e-07
iB00_4808_v n1_579050_447936 0 -1.305000000098068e-06
iB00_4809_v n1_579050_444592 0 -1.920000000053846e-06
iB00_4810_v n1_556858_444238 0 0.06440350000000004
iB00_4811_v n1_556858_441248 0 -1.0499999995991147e-07
iB00_4812_v n1_579050_444238 0 0.06440299999999999
iB00_4813_v n1_579050_441248 0 -4.999999997554568e-08
iB00_4814_v n1_556858_437904 0 3.3000000000783867e-07
iB00_4815_v n1_556858_434560 0 -2.5000000003104136e-07
iB00_4816_v n1_579050_437904 0 1.6000000001119286e-07
iB00_4817_v n1_579050_434560 0 -2.4999999957279654e-08
iB00_4818_v n1_556858_431216 0 1.600000000018755e-07
iB00_4819_v n1_556858_427872 0 5.500000005128139e-08
iB00_4820_v n1_579050_431216 0 -8.000000000559643e-08
iB00_4821_v n1_579050_427872 0 -4.999999982985601e-09
iB00_4822_v n1_556858_424528 0 -7.000000000404984e-08
iB00_4823_v n1_556858_421742 0 0.06440149999999996
iB00_4824_v n1_579050_424528 0 1.9499999992554987e-07
iB00_4825_v n1_579050_421742 0 0.06440100000000001
iB00_4826_v n1_556858_421184 0 1.8500000000108328e-07
iB00_4827_v n1_556858_417840 0 -1.350000000026677e-07
iB00_4828_v n1_579050_421184 0 1.900000000539491e-07
iB00_4829_v n1_579050_417840 0 -2.4000000001890687e-07
iB00_4830_v n1_556858_414496 0 3.000000001903932e-08
iB00_4831_v n1_556858_411152 0 1.6999999991702472e-07
iB00_4832_v n1_579050_414496 0 4.550000000250534e-07
iB00_4833_v n1_579050_411152 0 -2.0999999999774996e-07
iB00_4834_v n1_556858_407808 0 -2.1999999996287413e-07
iB00_4835_v n1_556858_404464 0 -1.350000000026677e-07
iB00_4836_v n1_579050_407808 0 -2.0500000004822216e-07
iB00_4837_v n1_579050_404464 0 -3.4999999948661845e-08
iB00_4838_v n1_556858_401120 0 -7.999999999034983e-08
iB00_4839_v n1_556858_399854 0 0.06440149999999996
iB00_4840_v n1_579050_401120 0 2.849999999453984e-07
iB00_4841_v n1_579050_399854 0 0.06440150000000001
iB00_4842_v n1_556858_397776 0 1.3500000001113804e-07
iB00_4843_v n1_556858_394432 0 -1.7500000000546592e-07
iB00_4844_v n1_579050_397776 0 -4.49999999828192e-08
iB00_4845_v n1_579050_394432 0 -2.0000000014528118e-08
iB00_4846_v n1_556858_391088 0 4.800000000039324e-07
iB00_4847_v n1_556858_387744 0 -4.150000000222552e-07
iB00_4848_v n1_579050_391088 0 1.5500000000406682e-07
iB00_4849_v n1_579050_387744 0 -4.999999977903404e-09
iB00_4850_v n1_556858_384400 0 1.349999999869976e-07
iB00_4851_v n1_556858_381056 0 1.4000000000979375e-07
iB00_4852_v n1_579050_384400 0 -1.000000001425208e-08
iB00_4853_v n1_579050_381056 0 1.0500000001327454e-07
iB00_4854_v n1_556858_377712 0 7.999999997976192e-08
iB00_4855_v n1_556858_377358 0 0.06640750000000005
iB00_4856_v n1_579050_377712 0 -1.7499999997836087e-07
iB00_4857_v n1_579050_377358 0 0.067014
iB00_4858_v n1_556858_374368 0 -1.8500000001844745e-07
iB00_4859_v n1_556858_371024 0 4.0000000002798214e-08
iB00_4860_v n1_579050_374368 0 2.300000000025372e-07
iB00_4861_v n1_579050_371024 0 -3.49999999732258e-08
iB00_4862_v n1_556858_367680 0 2.1000000000029106e-07
iB00_4863_v n1_556858_364336 0 -1.5499999997696176e-07
iB00_4864_v n1_579050_367680 0 -2.649999999982094e-07
iB00_4865_v n1_579050_364336 0 1.9999999977258668e-08
iB00_4866_v n1_556858_360992 0 -5.5000000015706005e-08
iB00_4867_v n1_556858_357648 0 1.9999999974294053e-08
iB00_4868_v n1_579050_360992 0 2.749999999853564e-07
iB00_4869_v n1_579050_357648 0 -4.4999999968843156e-08
iB00_4870_v n1_556858_355470 0 0.08311565000000001
iB00_4871_v n1_556858_354304 0 -1.4999999987496803e-08
iB00_4872_v n1_579050_355470 0 0.08101785
iB00_4873_v n1_579050_354304 0 -6.3527471044072525e-18
iB00_4874_v n1_556858_350960 0 -1.0000000004087685e-08
iB00_4875_v n1_556858_347616 0 1.9999999994622843e-08
iB00_4876_v n1_579050_350960 0 5.00000000712604e-09
iB00_4877_v n1_579050_347616 0 -2.500000000090185e-08
iB00_4878_v n1_556858_344272 0 4.658681209898652e-18
iB00_4879_v n1_556858_340928 0 1.0000000000699553e-08
iB00_4880_v n1_579050_344272 0 0.0
iB00_4881_v n1_579050_340928 0 -5.929230630780102e-18
iB00_4882_v n1_556858_337584 0 -9.999999997734938e-09
iB00_4883_v n1_556858_334240 0 -3.500000000244844e-08
iB00_4884_v n1_579050_337584 0 3.0000000008874924e-08
iB00_4885_v n1_579050_334240 0 -2.499999999751372e-08
iB00_4886_v n1_556858_332974 0 0.07942135000000002
iB00_4887_v n1_556858_330896 0 -9.000000001307224e-08
iB00_4888_v n1_579050_332974 0 0.07890045000000001
iB00_4889_v n1_579050_330896 0 -8.499999999747588e-08
iB00_4890_v n1_556858_327552 0 -1.249999999926508e-07
iB00_4891_v n1_556858_324208 0 2.100000000011381e-07
iB00_4892_v n1_579050_327552 0 -2.0000000000043854e-07
iB00_4893_v n1_579050_324208 0 1.4999999999397616e-07
iB00_4894_v n1_556858_320864 0 -1.0500000000099256e-07
iB00_4895_v n1_556858_317520 0 -5.499999999707128e-08
iB00_4896_v n1_579050_320864 0 5.00000000712604e-09
iB00_4897_v n1_579050_317520 0 -1.1500000000211563e-07
iB00_4898_v n1_556858_314176 0 -1.6000000000145198e-07
iB00_4899_v n1_556858_311086 0 0.07624000000000002
iB00_4900_v n1_579050_314176 0 2.9999999999388155e-07
iB00_4901_v n1_579050_311086 0 0.07789799999999995
iB00_4902_v n1_556858_310832 0 1.0999999998906036e-07
iB00_4903_v n1_556858_307488 0 8.999999999274345e-08
iB00_4904_v n1_579050_310832 0 -2.499999995431504e-08
iB00_4905_v n1_579050_307488 0 -2.000000003104526e-08
iB00_4906_v n1_556858_304144 0 -6.50000000045471e-08
iB00_4907_v n1_556858_300800 0 1.4499999998981473e-07
iB00_4908_v n1_579050_304144 0 5.0000000017050295e-08
iB00_4909_v n1_579050_300800 0 -2.4999999999207785e-07
iB00_4910_v n1_556858_297456 0 -2.5499999999073356e-07
iB00_4911_v n1_556858_294112 0 2.4499999999681027e-07
iB00_4912_v n1_579050_297456 0 1.1500000002837366e-07
iB00_4913_v n1_579050_294112 0 1.6499999997554373e-07
iB00_4914_v n1_556858_290768 0 -3.350000000230115e-07
iB00_4915_v n1_556858_288590 0 0.06440149999999999
iB00_4916_v n1_579050_290768 0 -8.000000000559643e-08
iB00_4917_v n1_579050_288590 0 0.06440150000000001
iB00_4918_v n1_556858_287424 0 8.500000002500445e-08
iB00_4919_v n1_556858_284080 0 2.050000000211171e-07
iB00_4920_v n1_579050_287424 0 1.4999999999694077e-07
iB00_4921_v n1_579050_284080 0 -2.499999999882662e-07
iB00_4922_v n1_556858_280736 0 -2.2500000002886896e-07
iB00_4923_v n1_556858_277392 0 2.900000000067345e-07
iB00_4924_v n1_579050_280736 0 8.499999998561741e-08
iB00_4925_v n1_579050_277392 0 1.700000000449267e-07
iB00_4926_v n1_556858_274048 0 -2.399999999939194e-07
iB00_4927_v n1_556858_270704 0 1.9500000000686503e-07
iB00_4928_v n1_579050_274048 0 -5.000000034231095e-09
iB00_4929_v n1_579050_270704 0 5.99999999881037e-08
iB00_4930_v n1_556858_267360 0 9.500000002273938e-08
iB00_4931_v n1_556858_266702 0 0.06440100000000001
iB00_4932_v n1_579050_267360 0 -1.4999999994273067e-07
iB00_4933_v n1_579050_266702 0 0.06440199999999992
iB00_4934_v n1_556858_264016 0 -1.9999999997163942e-07
iB00_4935_v n1_556858_260672 0 1.89999999999739e-07
iB00_4936_v n1_579050_264016 0 -2.349999999825582e-07
iB00_4937_v n1_579050_260672 0 5.548065804515667e-17
iB00_4938_v n1_556858_257328 0 4.999999995606392e-08
iB00_4939_v n1_556858_253984 0 -1.2000000000839464e-07
iB00_4940_v n1_579050_257328 0 -4.0000000002798214e-08
iB00_4941_v n1_579050_253984 0 1.4500000002454309e-07
iB00_4942_v n1_556858_250640 0 1.7999999999141614e-07
iB00_4943_v n1_556858_247296 0 -3.9999999948588105e-08
iB00_4944_v n1_579050_250640 0 4.500000009123942e-08
iB00_4945_v n1_579050_247296 0 1.4999999998931748e-07
iB00_4946_v n1_556858_244814 0 0.06440100000000001
iB00_4947_v n1_556858_243952 0 4.0000000002798214e-08
iB00_4948_v n1_579050_244814 0 0.06440149999999996
iB00_4949_v n1_579050_243952 0 -2.6000000001691784e-07
iB00_4950_v n1_556858_240608 0 9.500000003036268e-08
iB00_4951_v n1_556858_237264 0 1.350000000026677e-07
iB00_4952_v n1_579050_240608 0 1.9999999974294053e-08
iB00_4953_v n1_579050_237264 0 -2.000000000478724e-08
iB00_4954_v n1_556858_233920 0 1.599999999815467e-07
iB00_4955_v n1_556858_230576 0 -3.4999999995672174e-07
iB00_4956_v n1_579050_233920 0 1.1500000002837366e-07
iB00_4957_v n1_579050_230576 0 -5.999999998175095e-08
iB00_4958_v n1_556858_227232 0 1.449999999864266e-07
iB00_4959_v n1_556858_223888 0 1.5499999997696176e-07
iB00_4960_v n1_579050_227232 0 -6.000000003130238e-08
iB00_4961_v n1_579050_223888 0 8.500000000171104e-08
iB00_4962_v n1_556858_222318 0 0.06440250000000008
iB00_4963_v n1_556858_220544 0 -3.200000000115437e-06
iB00_4964_v n1_579050_222318 0 0.06440099999999996
iB00_4965_v n1_579050_220544 0 2.184999999992763e-06
iB00_4966_v n1_556858_217200 0 1.6499999999570312e-06
iB00_4967_v n1_556858_213856 0 1.5000000001862482e-06
iB00_4968_v n1_579050_217200 0 -3.5649999999580115e-06
iB00_4969_v n1_579050_213856 0 2.949999999376276e-07
iB00_4970_v n1_556858_210512 0 1.349999999946209e-06
iB00_4971_v n1_556858_207168 0 -3.7999999998863596e-06
iB00_4972_v n1_579050_210512 0 3.810000000063242e-06
iB00_4973_v n1_579050_207168 0 -3.025000000141311e-06
iB00_4974_v n1_556858_203824 0 1.1500000000440262e-06
iB00_4975_v n1_556858_200480 0 1.0999999999414256e-06
iB00_4976_v n1_579050_203824 0 -2.749999999853564e-07
iB00_4977_v n1_579050_200480 0 2.124999999993648e-06
iB00_4978_v n1_556858_200430 0 0.06439849999999986
iB00_4979_v n1_556858_197136 0 1.0842021724855044e-16
iB00_4980_v n1_579050_200430 0 0.06439849999999997
iB00_4981_v n1_579050_197136 0 1.8850000000039639e-06
iB00_4982_v n1_556858_193792 0 4.000000000003689e-06
iB00_4983_v n1_556858_190448 0 -1.8499999999803396e-06
iB00_4984_v n1_579050_193792 0 1.2499999998841563e-06
iB00_4985_v n1_579050_190448 0 2.0000000010377656e-07
iB00_4986_v n1_556858_187104 0 -2.600000000025183e-06
iB00_4987_v n1_556858_183760 0 1.8000000000717095e-06
iB00_4988_v n1_579050_187104 0 -1.2499999999925765e-06
iB00_4989_v n1_579050_183760 0 1.9500000000212164e-06
iB00_4990_v n1_556858_180416 0 1.3499999999936428e-06
iB00_4991_v n1_556858_177934 0 0.06440299999999988
iB00_4992_v n1_579050_180416 0 -2.4999999997683126e-07
iB00_4993_v n1_579050_177934 0 0.06440000000000004
iB00_4994_v n1_556858_177072 0 -7.500000000050327e-07
iB00_4995_v n1_556858_173728 0 -3.84999999990341e-06
iB00_4996_v n1_579050_177072 0 -2.2500000000083217e-06
iB00_4997_v n1_579050_173728 0 2.2000000000234587e-06
iB00_4998_v n1_556858_170384 0 3.2999999999445555e-06
iB00_4999_v n1_556858_167040 0 8.000000000559643e-07
iB00_5000_v n1_579050_170384 0 1.2499999999925765e-06
iB00_5001_v n1_579050_167040 0 -2.0328790734103208e-17
iB00_5002_v n1_556858_163696 0 -1.3499999999368916e-06
iB00_5003_v n1_556858_160352 0 1.8999999998889697e-06
iB00_5004_v n1_579050_163696 0 -1.6500000000205586e-06
iB00_5005_v n1_579050_160352 0 1.4499999999853917e-06
iB00_5006_v n1_556858_157008 0 -4.400000000035059e-06
iB00_5007_v n1_556858_156046 0 0.0644005
iB00_5008_v n1_579050_157008 0 -7.50000000038914e-07
iB00_5009_v n1_579050_156046 0 0.06440100000000001
iB00_5010_v n1_556858_153664 0 4.5000000000437485e-07
iB00_5011_v n1_556858_150320 0 -8.499999999645944e-07
iB00_5012_v n1_579050_153664 0 -7.50000000038914e-07
iB00_5013_v n1_579050_150320 0 -9.499999998699459e-07
iB00_5014_v n1_556858_146976 0 3.500000000017839e-06
iB00_5015_v n1_556858_143632 0 -1.300000000118047e-06
iB00_5016_v n1_579050_146976 0 3.7499999999777295e-06
iB00_5017_v n1_579050_143632 0 -1.6000000001203989e-06
iB00_5018_v n1_556858_140288 0 -2.5000000002087697e-07
iB00_5019_v n1_556858_136944 0 1.7500000000546592e-06
iB00_5020_v n1_579050_140288 0 -1.8499999997634992e-06
iB00_5021_v n1_579050_136944 0 2.999999999954062e-06
iB00_5022_v n1_556858_133600 0 -2.5000000005645235e-07
iB00_5023_v n1_556858_133550 0 0.06439499999999986
iB00_5024_v n1_579050_133600 0 -1.9000000002142303e-06
iB00_5025_v n1_579050_133550 0 0.0644049999999999
iB00_5026_v n1_556858_130256 0 1.8500000000226912e-06
iB00_5027_v n1_556858_126912 0 1.2000000000839464e-06
iB00_5028_v n1_579050_130256 0 -6.999999998050233e-07
iB00_5029_v n1_579050_126912 0 1.950000000034769e-06
iB00_5030_v n1_556858_123568 0 -2.9999999999405096e-06
iB00_5031_v n1_556858_120224 0 4.5000000000166435e-06
iB00_5032_v n1_579050_123568 0 4.499999999366122e-07
iB00_5033_v n1_579050_120224 0 -4.9999999867972496e-08
iB00_5034_v n1_556858_116880 0 -1.2500000001230196e-06
iB00_5035_v n1_556858_113536 0 0.0
iB00_5036_v n1_579050_116880 0 8.500000000730146e-07
iB00_5037_v n1_579050_113536 0 -1.7000000001070656e-06
iB00_5038_v n1_556858_111662 0 0.06440000000000015
iB00_5039_v n1_556858_110192 0 1.749999999946239e-06
iB00_5040_v n1_579050_111662 0 0.06440500000000002
iB00_5041_v n1_579050_110192 0 -4.000000000889685e-07
iB00_5042_v n1_556858_106848 0 -9.499999999038273e-07
iB00_5043_v n1_556858_103504 0 -1.2500000001009967e-06
iB00_5044_v n1_579050_106848 0 -3.85000000001183e-06
iB00_5045_v n1_579050_103504 0 6.500000001776081e-07
iB00_5046_v n1_556858_100160 0 1.1499999999720284e-06
iB00_5047_v n1_556858_96816 0 1.350000000026677e-06
iB00_5048_v n1_579050_100160 0 3.499999999892478e-06
iB00_5049_v n1_534666_93472 0 1.3000000000096268e-06
iB00_5050_v n1_579050_96816 0 4.000000000991329e-07
iB00_5051_v n1_556858_93472 0 -3.9999999995683137e-07
iB00_5052_v n1_556858_90128 0 1.0499999999718092e-06
iB00_5053_v n1_579050_93472 0 -3.1499999999899664e-06
iB00_5054_v n1_534666_90128 0 -2.599999999958267e-06
iB00_5055_v n1_534666_89166 0 0.06440000000000004
iB00_5056_v n1_512170_90128 0 8.999999999816446e-07
iB00_5057_v n1_512170_89166 0 0.06959299999999996
iB00_5058_v n1_512170_86784 0 -2.0000000001060294e-07
iB00_5059_v n1_489978_89166 0 0.08161099999999999
iB00_5060_v n1_489978_86784 0 -1.5000000002743396e-07
iB00_5061_v n1_489978_83440 0 -1.4999999995289506e-07
iB00_5062_v n1_467482_86784 0 -5.421010862427522e-17
iB00_5063_v n1_467482_83440 0 3.0000000007350265e-07
iB00_5064_v n1_467482_80096 0 -4.000000000144296e-07
iB00_5065_v n1_445290_83440 0 -4.9999999962840186e-08
iB00_5066_v n1_445290_80096 0 4.9999999967922384e-08
iB00_5067_v n1_445290_76752 0 -2.0000000001399107e-07
iB00_5068_v n1_422794_80096 0 1.9999999998688602e-07
iB00_5069_v n1_467482_76752 0 3.5000000002448437e-07
iB00_5070_v n1_467482_73408 0 4.9999999962840186e-08
iB00_5071_v n1_489978_73408 0 -5.0000000017050295e-08
iB00_5072_v n1_489978_76752 0 -1.9999999995978096e-07
iB00_5073_v n1_512170_76752 0 3.4999999995672174e-07
iB00_5074_v n1_489978_80096 0 2.4999999996327873e-07
iB00_5075_v n1_512170_80096 0 -4.999999999536625e-07
iB00_5076_v n1_534666_80096 0 -3.1499999999899664e-06
iB00_5077_v n1_512170_83440 0 5.000000000044845e-07
iB00_5078_v n1_534666_83440 0 1.0000000000157452e-06
iB00_5079_v n1_556858_83440 0 3.84999999990341e-06
iB00_5080_v n1_534666_86784 0 8.499999999781469e-07
iB00_5081_v n1_556858_86784 0 -1.1000000000498458e-06
iB00_5082_v n1_579050_86784 0 1.1999999999755262e-06
iB00_5083_v n1_556858_89166 0 0.06440500000000002
iB00_5084_v n1_579050_89166 0 0.06440000000000004
iB00_5085_v n1_601546_89166 0 0.06439999999999961
iB00_5086_v n1_579050_90128 0 -1.5500000000982664e-06
iB00_5087_v n1_601546_90128 0 1.649999999695298e-06
iB00_5088_v n1_623064_90128 0 0.0
iB00_5089_v n1_601546_93472 0 1.1000000000905034e-06
iB00_5090_v n1_601546_96816 0 -1.6000000001119286e-06
iB00_5091_v n1_623064_93472 0 -4.9999999996721504e-08
iB00_5092_v n1_623064_96816 0 0.0
iB00_5093_v n1_601546_100160 0 1.550000000111819e-06
iB00_5094_v n1_601546_103504 0 -1.4000000002605678e-06
iB00_5095_v n1_623064_100160 0 -1.6940658945086007e-18
iB00_5096_v n1_623064_103504 0 -1.6940658945086007e-18
iB00_5097_v n1_601546_106848 0 -2.149999999947116e-06
iB00_5098_v n1_601546_110192 0 2.5000000002019934e-06
iB00_5099_v n1_623064_106848 0 8.470329472543003e-19
iB00_5100_v n1_623064_110192 0 8.470329472543003e-19
iB00_5101_v n1_601546_111662 0 0.06439999999999994
iB00_5102_v n1_601546_113536 0 -2.5500000000022033e-06
iB00_5103_v n1_625064_111662 0 2.6801480868994202e-14
iB00_5104_v n1_623064_113536 0 -1.6940658945086007e-18
iB00_5105_v n1_601546_116880 0 3.800000000074401e-06
iB00_5106_v n1_601546_120224 0 -2.650000000036304e-06
iB00_5107_v n1_623064_116880 0 -1.6940658945086007e-18
iB00_5108_v n1_623064_120224 0 -8.470329472543003e-19
iB00_5109_v n1_601546_123568 0 2.5499999999886508e-06
iB00_5110_v n1_601546_126912 0 -1.0499999999243753e-06
iB00_5111_v n1_623064_123568 0 -4.999999998655711e-09
iB00_5112_v n1_623064_126912 0 -2.0000000000552074e-08
iB00_5113_v n1_601546_130256 0 1.049999999839672e-06
iB00_5114_v n1_601546_133550 0 0.0643950000000003
iB00_5115_v n1_623064_130256 0 0.0
iB00_5116_v n1_625064_133550 0 2.6801480868994202e-14
iB00_5117_v n1_601546_133600 0 2.9499999999014364e-06
iB00_5118_v n1_601546_136944 0 -2.7500000000704045e-06
iB00_5119_v n1_623064_133600 0 1.999999999970504e-08
iB00_5120_v n1_623064_136944 0 -9.99999999985252e-09
iB00_5121_v n1_601546_140288 0 1.299999999914759e-06
iB00_5122_v n1_601546_143632 0 -5.0000000017050295e-08
iB00_5123_v n1_623064_140288 0 -2.0000000000128558e-08
iB00_5124_v n1_623064_143632 0 8.470329472543003e-19
iB00_5125_v n1_601546_146976 0 3.0000000000184366e-06
iB00_5126_v n1_601546_150320 0 -4.650000000067794e-06
iB00_5127_v n1_623064_146976 0 1.5000000000625814e-08
iB00_5128_v n1_623064_150320 0 -5.000000000773293e-09
iB00_5129_v n1_601546_153664 0 1.8499999998075449e-06
iB00_5130_v n1_601546_156046 0 0.06440350000000016
iB00_5131_v n1_623064_153664 0 -4.99999999992626e-09
iB00_5132_v n1_625064_156046 0 2.65846404344971e-14
iB00_5133_v n1_601546_157008 0 -2.0999999998927963e-06
iB00_5134_v n1_601546_160352 0 1.8499999999803396e-06
iB00_5135_v n1_623064_157008 0 4.999999999502744e-09
iB00_5136_v n1_623064_160352 0 -2.49999999996313e-08
iB00_5137_v n1_601546_163696 0 -3.0000000003708023e-07
iB00_5138_v n1_601546_167040 0 1.3849999999952442e-06
iB00_5139_v n1_623064_163696 0 -1.0000000000276037e-08
iB00_5140_v n1_623064_167040 0 -4.99999999992626e-09
iB00_5141_v n1_601546_170384 0 -3.130000000063953e-06
iB00_5142_v n1_601546_173728 0 1.0900000000898039e-06
iB00_5143_v n1_623064_170384 0 8.470329472543003e-19
iB00_5144_v n1_623064_173728 0 0.0
iB00_5145_v n1_601546_177072 0 -9.050000000294283e-07
iB00_5146_v n1_601546_177934 0 0.06440450000000006
iB00_5147_v n1_623064_177072 0 4.2351647362715017e-19
iB00_5148_v n1_625064_177934 0 1.500000026445628e-06
iB00_5149_v n1_601546_180416 0 -3.334999999998673e-06
iB00_5150_v n1_601546_183760 0 1.0500000000327955e-06
iB00_5151_v n1_623064_180416 0 -4.2351647362715017e-19
iB00_5152_v n1_623064_183760 0 0.0
iB00_5153_v n1_601546_187104 0 -9.249999999469711e-07
iB00_5154_v n1_601546_190448 0 6.750000000133385e-07
iB00_5155_v n1_623064_187104 0 0.0
iB00_5156_v n1_623064_190448 0 -4.2351647362715017e-19
iB00_5157_v n1_601546_193792 0 8.099999999778898e-07
iB00_5158_v n1_601546_197136 0 -4.800000000335786e-07
iB00_5159_v n1_623064_193792 0 -4.2351647362715017e-19
iB00_5160_v n1_623064_197136 0 0.0
iB00_5161_v n1_601546_200430 0 0.06440399999999995
iB00_5162_v n1_601546_200480 0 -3.7799999999662756e-06
iB00_5163_v n1_625064_200430 0 2.00000005255015e-06
iB00_5164_v n1_623064_200480 0 0.0
iB00_5165_v n1_601546_203824 0 2.3549999999529866e-06
iB00_5166_v n1_601546_207168 0 -2.9449999999417442e-06
iB00_5167_v n1_623064_203824 0 -4.2351647362715017e-19
iB00_5168_v n1_623064_207168 0 -5.0000000001380185e-09
iB00_5169_v n1_601546_210512 0 2.4999999996327873e-07
iB00_5170_v n1_601546_213856 0 1.910000000065852e-06
iB00_5171_v n1_623064_210512 0 -4.999999999502744e-09
iB00_5172_v n1_623064_213856 0 2.1175823681357508e-19
iB00_5173_v n1_601546_217200 0 2.0450000000354855e-06
iB00_5174_v n1_601546_220544 0 -4.33999999989703e-06
iB00_5175_v n1_623064_217200 0 0.0
iB00_5176_v n1_623064_220544 0 -2.1175823681357508e-19
iB00_5177_v n1_601546_222318 0 0.06440350000000002
iB00_5178_v n1_601546_223888 0 -3.5000000076987337e-08
iB00_5179_v n1_625064_222318 0 2.0000000527669905e-06
iB00_5180_v n1_623064_223888 0 -4.2351647362715017e-19
iB00_5181_v n1_601546_227232 0 3.400000000847712e-07
iB00_5182_v n1_601546_230576 0 -3.2000000013080593e-07
iB00_5183_v n1_623064_227232 0 2.1175823681357508e-19
iB00_5184_v n1_623064_230576 0 0.0
iB00_5185_v n1_601546_233920 0 4.300000000249986e-07
iB00_5186_v n1_601546_237264 0 -4.149999999680451e-07
iB00_5187_v n1_623064_233920 0 4.99999999992626e-09
iB00_5188_v n1_623064_237264 0 2.1175823681357508e-19
iB00_5189_v n1_601546_240608 0 1.500000000155755e-07
iB00_5190_v n1_601546_243952 0 1.6000000001119286e-07
iB00_5191_v n1_623064_240608 0 0.0
iB00_5192_v n1_623064_243952 0 0.0
iB00_5193_v n1_601546_244814 0 0.06440099999999996
iB00_5194_v n1_601546_247296 0 1.6000000001119286e-07
iB00_5195_v n1_625064_244814 0 1.0000000526428249e-06
iB00_5196_v n1_623064_247296 0 0.0
iB00_5197_v n1_601546_250640 0 1.5000000004437462e-07
iB00_5198_v n1_601546_253984 0 5.999999992288216e-08
iB00_5199_v n1_623064_250640 0 4.999999999714502e-09
iB00_5200_v n1_623064_253984 0 -2.1175823681357508e-19
iB00_5201_v n1_601546_257328 0 -1.4000000002080518e-07
iB00_5202_v n1_601546_260672 0 5.500000005128139e-08
iB00_5203_v n1_623064_257328 0 -4.999999999714502e-09
iB00_5204_v n1_623064_260672 0 0.0
iB00_5205_v n1_601546_264016 0 1.6499999998189648e-07
iB00_5206_v n1_601546_266702 0 0.06440100000000001
iB00_5207_v n1_623064_264016 0 0.0
iB00_5208_v n1_625064_266702 0 -1.9999999472959904e-06
iB00_5209_v n1_601546_267360 0 -7.49999999938117e-08
iB00_5210_v n1_601546_270704 0 -2.5000000008525147e-08
iB00_5211_v n1_623064_267360 0 2.1175823681357508e-19
iB00_5212_v n1_623064_270704 0 0.0
iB00_5213_v n1_601546_274048 0 -1.0000000013828564e-08
iB00_5214_v n1_601546_277392 0 -4.9999999962840186e-08
iB00_5215_v n1_623064_274048 0 -2.1175823681357508e-19
iB00_5216_v n1_623064_277392 0 0.0
iB00_5217_v n1_601546_280736 0 3.6500000002426315e-07
iB00_5218_v n1_601546_284080 0 -2.400000000167893e-07
iB00_5219_v n1_623064_280736 0 2.1175823681357508e-19
iB00_5220_v n1_623064_284080 0 -2.1175823681357508e-19
iB00_5221_v n1_601546_287424 0 1.899999999971979e-07
iB00_5222_v n1_601546_288590 0 0.06440149999999996
iB00_5223_v n1_623064_287424 0 -4.2351647362715017e-19
iB00_5224_v n1_625064_288590 0 5.2789710108624276e-14
iB00_5225_v n1_601546_290768 0 -7.999999999924368e-08
iB00_5226_v n1_601546_294112 0 -9.999999987147026e-09
iB00_5227_v n1_623064_290768 0 -2.1175823681357508e-19
iB00_5228_v n1_623064_294112 0 -2.1175823681357508e-19
iB00_5229_v n1_601546_297456 0 2.699999999926299e-07
iB00_5230_v n1_601546_300800 0 -1.6499999999121384e-07
iB00_5231_v n1_623064_297456 0 4.999999999714502e-09
iB00_5232_v n1_623064_300800 0 0.0
iB00_5233_v n1_601546_304144 0 -2.249999999962582e-07
iB00_5234_v n1_601546_307488 0 2.2000000001539018e-07
iB00_5235_v n1_623064_304144 0 -4.2351647362715017e-19
iB00_5236_v n1_623064_307488 0 4.2351647362715017e-19
iB00_5237_v n1_601546_310832 0 -1.5500000001296066e-07
iB00_5238_v n1_601546_311086 0 0.08280450000000003
iB00_5239_v n1_623064_310832 0 0.0
iB00_5240_v n1_625064_311086 0 5.27355e-14
iB00_5241_v n1_601546_314176 0 6.999999999134435e-08
iB00_5242_v n1_601546_317520 0 -1.4999999999694077e-07
iB00_5243_v n1_623064_314176 0 -4.999999999714502e-09
iB00_5244_v n1_623064_317520 0 -2.1175823681357508e-19
iB00_5245_v n1_601546_320864 0 -6.999999998795622e-08
iB00_5246_v n1_601546_324208 0 3.149999999881546e-07
iB00_5247_v n1_623064_320864 0 5.0000000001380185e-09
iB00_5248_v n1_623064_324208 0 -2.1175823681357508e-19
iB00_5249_v n1_601546_327552 0 4.5000000008653705e-08
iB00_5250_v n1_601546_330896 0 -3.000000000074341e-07
iB00_5251_v n1_623064_327552 0 5.000000000349777e-09
iB00_5252_v n1_623064_330896 0 -2.1175823681357508e-19
iB00_5253_v n1_601546_332974 0 0.08490715
iB00_5254_v n1_601546_334240 0 1.4999999994273067e-08
iB00_5255_v n1_625064_332974 0 -9.999994724439047e-08
iB00_5256_v n1_623064_334240 0 -2.1175823681357508e-19
iB00_5257_v n1_601546_337584 0 -1.5000000003166913e-08
iB00_5258_v n1_601546_340928 0 -6.776263578034403e-18
iB00_5259_v n1_623064_337584 0 2.1175823681357508e-19
iB00_5260_v n1_623064_340928 0 4.2351647362715017e-19
iB00_5261_v n1_601546_344272 0 1.0000000007475817e-08
iB00_5262_v n1_601546_347616 0 -5.000000000349777e-09
iB00_5263_v n1_623064_344272 0 -4.99999999992626e-09
iB00_5264_v n1_623064_347616 0 2.1175823681357508e-19
iB00_5265_v n1_601546_350960 0 -1.5000000000625814e-08
iB00_5266_v n1_601546_354304 0 -1.500000000104933e-08
iB00_5267_v n1_623064_350960 0 -5.0000000001380185e-09
iB00_5268_v n1_623064_354304 0 -2.1175823681357508e-19
iB00_5269_v n1_601546_355470 0 0.08770010000000003
iB00_5270_v n1_601546_357648 0 -4.800000000606836e-07
iB00_5271_v n1_625064_355470 0 5.270839494568786e-14
iB00_5272_v n1_623064_357648 0 -4.2351647362715017e-19
iB00_5273_v n1_601546_360992 0 3.2500000002146494e-07
iB00_5274_v n1_601546_364336 0 -2.0000000001399107e-08
iB00_5275_v n1_623064_360992 0 4.2351647362715017e-19
iB00_5276_v n1_623064_364336 0 0.0
iB00_5277_v n1_601546_367680 0 -1.4999999999058803e-07
iB00_5278_v n1_601546_371024 0 3.2999999995532263e-07
iB00_5279_v n1_623064_367680 0 0.0
iB00_5280_v n1_623064_371024 0 -2.1175823681357508e-19
iB00_5281_v n1_601546_374368 0 -1.4499999998303847e-07
iB00_5282_v n1_601546_377358 0 0.07045950000000002
iB00_5283_v n1_623064_374368 0 -4.2351647362715017e-19
iB00_5284_v n1_625064_377358 0 5.27355e-14
iB00_5285_v n1_601546_377712 0 1.699999999729289e-07
iB00_5286_v n1_601546_381056 0 -6.499999995711325e-08
iB00_5287_v n1_623064_377712 0 -5.000000000349777e-09
iB00_5288_v n1_623064_381056 0 5.0000000001380185e-09
iB00_5289_v n1_601546_384400 0 5.999999998005688e-08
iB00_5290_v n1_601546_387744 0 -4.0000000002798214e-08
iB00_5291_v n1_623064_384400 0 4.99999999992626e-09
iB00_5292_v n1_623064_387744 0 4.2351647362715017e-19
iB00_5293_v n1_601546_391088 0 4.9999999966651834e-08
iB00_5294_v n1_601546_394432 0 -2.0499999993980195e-07
iB00_5295_v n1_623064_391088 0 0.0
iB00_5296_v n1_623064_394432 0 -2.1175823681357508e-19
iB00_5297_v n1_601546_397776 0 1.849999999968481e-07
iB00_5298_v n1_601546_399854 0 0.06560699999999997
iB00_5299_v n1_623064_397776 0 5.0000000001380185e-09
iB00_5300_v n1_625064_399854 0 5.000000527433726e-07
iB00_5301_v n1_601546_401120 0 -2.550000000144505e-07
iB00_5302_v n1_601546_404464 0 3.699999999852259e-07
iB00_5303_v n1_623064_401120 0 0.0
iB00_5304_v n1_623064_404464 0 -4.2351647362715017e-19
iB00_5305_v n1_601546_407808 0 8.500000003051016e-08
iB00_5306_v n1_601546_411152 0 -1.5499999997696176e-07
iB00_5307_v n1_623064_407808 0 4.99999999992626e-09
iB00_5308_v n1_623064_411152 0 0.0
iB00_5309_v n1_601546_414496 0 1.300000000095177e-07
iB00_5310_v n1_601546_417840 0 -3.000000004275624e-08
iB00_5311_v n1_623064_414496 0 0.0
iB00_5312_v n1_623064_417840 0 4.2351647362715017e-19
iB00_5313_v n1_601546_421184 0 -1.0999999996830806e-07
iB00_5314_v n1_601546_421742 0 0.06607049999999995
iB00_5315_v n1_623064_421184 0 -2.1175823681357508e-19
iB00_5316_v n1_625064_421742 0 5.000000526891625e-07
iB00_5317_v n1_601546_424528 0 1.7999999997871064e-07
iB00_5318_v n1_601546_427872 0 2.1000000002824315e-07
iB00_5319_v n1_623064_424528 0 -2.1175823681357508e-19
iB00_5320_v n1_623064_427872 0 4.2351647362715017e-19
iB00_5321_v n1_601546_431216 0 -2.100000000345959e-07
iB00_5322_v n1_601546_434560 0 -1.0999999999414256e-07
iB00_5323_v n1_623064_431216 0 0.0
iB00_5324_v n1_623064_434560 0 0.0
iB00_5325_v n1_601546_437904 0 5.000000009667139e-09
iB00_5326_v n1_601546_441248 0 1.7499999995125581e-07
iB00_5327_v n1_623064_437904 0 2.1175823681357508e-19
iB00_5328_v n1_623064_441248 0 -2.1175823681357508e-19
iB00_5329_v n1_601546_444238 0 0.06579250000000007
iB00_5330_v n1_601546_444592 0 -2.3900000000994306e-06
iB00_5331_v n1_625064_444238 0 5.27355e-14
iB00_5332_v n1_623064_444592 0 -4.2351647362715017e-19
iB00_5333_v n1_601546_447936 0 1.8349999999572674e-06
iB00_5334_v n1_601546_451280 0 -3.5000000001093184e-07
iB00_5335_v n1_623064_447936 0 4.2351647362715017e-19
iB00_5336_v n1_623064_451280 0 -4.2351647362715017e-19
iB00_5337_v n1_601546_454624 0 1.0099999999647758e-06
iB00_5338_v n1_601546_457968 0 8.800000000615607e-07
iB00_5339_v n1_623064_454624 0 -5.0000000001380185e-09
iB00_5340_v n1_623064_457968 0 2.1175823681357508e-19
iB00_5341_v n1_601546_461312 0 -7.150000000466299e-07
iB00_5342_v n1_601546_464656 0 1.2500000001009967e-06
iB00_5343_v n1_623064_461312 0 0.0
iB00_5344_v n1_623064_464656 0 0.0
iB00_5345_v n1_601546_466126 0 0.06439799999999991
iB00_5346_v n1_601546_468000 0 5.950000000077421e-07
iB00_5347_v n1_625064_466126 0 3.000000052891156e-06
iB00_5348_v n1_623064_468000 0 -2.1175823681357508e-19
iB00_5349_v n1_601546_471344 0 1.9000000000380475e-06
iB00_5350_v n1_601546_474688 0 1.7649999999947222e-06
iB00_5351_v n1_623064_471344 0 2.1175823681357508e-19
iB00_5352_v n1_623064_474688 0 0.0
iB00_5353_v n1_601546_478032 0 -4.7949999999644355e-06
iB00_5354_v n1_601546_481376 0 2.2300000000882378e-06
iB00_5355_v n1_623064_478032 0 0.0
iB00_5356_v n1_623064_481376 0 4.2351647362715017e-19
iB00_5357_v n1_601546_484720 0 -2.1600000000460715e-06
iB00_5358_v n1_601546_488064 0 2.1000000001740113e-06
iB00_5359_v n1_623064_484720 0 -4.99999999992626e-09
iB00_5360_v n1_623064_488064 0 -4.99999999992626e-09
iB00_5361_v n1_601546_488622 0 0.06440299999999993
iB00_5362_v n1_601546_491408 0 -2.334999999993939e-06
iB00_5363_v n1_625064_488622 0 2.0000000266161307e-06
iB00_5364_v n1_623064_491408 0 0.0
iB00_5365_v n1_601546_494752 0 -4.79999999992074e-07
iB00_5366_v n1_601546_498096 0 9.999999992568037e-08
iB00_5367_v n1_623064_494752 0 0.0
iB00_5368_v n1_623064_498096 0 4.2351647362715017e-19
iB00_5369_v n1_601546_501440 0 -5.400000000445522e-07
iB00_5370_v n1_601546_504784 0 2.6000000000192536e-06
iB00_5371_v n1_623064_501440 0 -5.000000000349777e-09
iB00_5372_v n1_623064_504784 0 9.99999999985252e-09
iB00_5373_v n1_601546_508128 0 -4.0000000001019445e-07
iB00_5374_v n1_601546_510510 0 0.0644005
iB00_5375_v n1_623064_508128 0 -4.99999999992626e-09
iB00_5376_v n1_625064_510510 0 -1.4999999734931875e-06
iB00_5377_v n1_601546_511472 0 1.4500000000582366e-06
iB00_5378_v n1_601546_514816 0 -2.549999999785363e-06
iB00_5379_v n1_623064_511472 0 1.999999999970504e-08
iB00_5380_v n1_623064_514816 0 0.0
iB00_5381_v n1_601546_518160 0 2.5500000000818244e-06
iB00_5382_v n1_601546_521504 0 -3.150000000206807e-06
iB00_5383_v n1_623064_518160 0 4.99999999992626e-09
iB00_5384_v n1_623064_521504 0 4.99999999992626e-09
iB00_5385_v n1_601546_524848 0 5.500000000062882e-07
iB00_5386_v n1_601546_528192 0 3.6500000001604693e-06
iB00_5387_v n1_623064_524848 0 -9.99999999985252e-09
iB00_5388_v n1_623064_528192 0 2.5000000000054818e-08
iB00_5389_v n1_601546_531536 0 -3.5000000001652226e-06
iB00_5390_v n1_601546_532398 0 0.06607450000000012
iB00_5391_v n1_623064_531536 0 4.2351647362715017e-19
iB00_5392_v n1_625064_532398 0 5.000000267551434e-07
iB00_5393_v n1_601546_534880 0 1.1999999999907728e-06
iB00_5394_v n1_601546_538224 0 -5.000000001705029e-07
iB00_5395_v n1_623064_534880 0 -9.999999999005488e-09
iB00_5396_v n1_623064_538224 0 0.0
iB00_5397_v n1_601546_541568 0 -1.6499999998867274e-06
iB00_5398_v n1_601546_544912 0 2.9999999999388155e-06
iB00_5399_v n1_623064_541568 0 -8.470329472543003e-19
iB00_5400_v n1_623064_544912 0 1.5000000000202297e-08
iB00_5401_v n1_601546_548256 0 -1.100000000078645e-06
iB00_5402_v n1_623064_548256 0 -2.0000000001399107e-08
iB00_5403_v n1_623064_551600 0 8.470329472543003e-19
iB00_5404_v n1_625064_551600 0 1.999999996345203e-07
iB00_5405_v n1_627064_551600 0 0.0
iB00_5406_v n1_625064_548256 0 -2.1799999994985932e-06
iB00_5407_v n1_627064_554894 0 -2.63678e-14
iB00_5408_v n1_625064_544912 0 3.534999999805988e-06
iB00_5409_v n1_627064_548256 0 0.0
iB00_5410_v n1_625064_541568 0 -1.750000000023319e-06
iB00_5411_v n1_627064_544912 0 0.0
iB00_5412_v n1_625064_538224 0 -2.249999999942253e-06
iB00_5413_v n1_627064_541568 0 0.0
iB00_5414_v n1_625064_534880 0 2.809999999617204e-06
iB00_5415_v n1_627064_538224 0 0.0
iB00_5416_v n1_627064_534880 0 0.0
iB00_5417_v n1_625064_531536 0 -2.2499999997893637e-06
iB00_5418_v n1_627064_532398 0 -2.63678e-14
iB00_5419_v n1_625064_528192 0 9.74999999696359e-07
iB00_5420_v n1_627064_531536 0 0.0
iB00_5421_v n1_625064_524848 0 1.5600000002361853e-06
iB00_5422_v n1_627064_528192 0 0.0
iB00_5423_v n1_625064_521504 0 -1.0500000012042421e-07
iB00_5424_v n1_627064_524848 0 0.0
iB00_5425_v n1_625064_518160 0 -3.654999999857158e-06
iB00_5426_v n1_627064_521504 0 0.0
iB00_5427_v n1_625064_514816 0 1.2499999998841563e-06
iB00_5428_v n1_627064_518160 0 0.0
iB00_5429_v n1_625064_511472 0 -7.000000015820984e-08
iB00_5430_v n1_627064_514816 0 0.0
iB00_5431_v n1_627064_511472 0 0.0
iB00_5432_v n1_625064_508128 0 1.0500000006452004e-07
iB00_5433_v n1_627064_510510 0 -2.63678e-14
iB00_5434_v n1_625064_504784 0 1.3399999998912993e-06
iB00_5435_v n1_627064_508128 0 0.0
iB00_5436_v n1_625064_501440 0 2.094999999905999e-06
iB00_5437_v n1_627064_504784 0 0.0
iB00_5438_v n1_625064_498096 0 -2.449999999862647e-06
iB00_5439_v n1_627064_501440 0 0.0
iB00_5440_v n1_625064_494752 0 2.880000000062558e-06
iB00_5441_v n1_627064_498096 0 0.0
iB00_5442_v n1_625064_491408 0 -1.7650000001988571e-06
iB00_5443_v n1_627064_494752 0 0.0
iB00_5444_v n1_627064_491408 0 0.0
iB00_5445_v n1_625064_488064 0 -2.045000000116377e-06
iB00_5446_v n1_627064_488622 0 -2.63678e-14
iB00_5447_v n1_625064_484720 0 -9.350000000243272e-07
iB00_5448_v n1_627064_488064 0 0.0
iB00_5449_v n1_625064_481376 0 5.70000000037757e-07
iB00_5450_v n1_627064_484720 0 0.0
iB00_5451_v n1_625064_478032 0 2.595000000070573e-06
iB00_5452_v n1_627064_481376 0 0.0
iB00_5453_v n1_625064_474688 0 2.3500000010283687e-07
iB00_5454_v n1_627064_478032 0 0.0
iB00_5455_v n1_625064_471344 0 -1.4300000001112593e-06
iB00_5456_v n1_627064_474688 0 0.0
iB00_5457_v n1_625064_468000 0 -2.3400000001380728e-06
iB00_5458_v n1_627064_471344 0 0.0
iB00_5459_v n1_627064_468000 0 0.0
iB00_5460_v n1_625064_464656 0 -2.8250000001163087e-06
iB00_5461_v n1_627064_466126 0 -5.27355e-14
iB00_5462_v n1_625064_461312 0 7.000000000337221e-07
iB00_5463_v n1_627064_464656 0 0.0
iB00_5464_v n1_625064_457968 0 1.700000000747846e-07
iB00_5465_v n1_627064_461312 0 0.0
iB00_5466_v n1_625064_454624 0 6.399999999784911e-07
iB00_5467_v n1_627064_457968 0 0.0
iB00_5468_v n1_625064_451280 0 2.154999999960595e-06
iB00_5469_v n1_627064_454624 0 0.0
iB00_5470_v n1_625064_447936 0 -2.4500000005779664e-07
iB00_5471_v n1_627064_451280 0 0.0
iB00_5472_v n1_625064_444592 0 -1.5549999998881285e-06
iB00_5473_v n1_627064_447936 0 0.0
iB00_5474_v n1_627064_444592 0 0.0
iB00_5475_v n1_625064_441248 0 -1.0699999999657967e-06
iB00_5476_v n1_627064_444238 0 -5.27355e-14
iB00_5477_v n1_625064_437904 0 6.550000000354446e-07
iB00_5478_v n1_627064_441248 0 0.0
iB00_5479_v n1_625064_434560 0 -1.4150000000714582e-06
iB00_5480_v n1_627064_437904 0 0.0
iB00_5481_v n1_625064_431216 0 2.7649999999787037e-06
iB00_5482_v n1_627064_434560 0 0.0
iB00_5483_v n1_625064_427872 0 -1.7849999999410641e-06
iB00_5484_v n1_627064_431216 0 0.0
iB00_5485_v n1_625064_424528 0 -6.000000002854952e-08
iB00_5486_v n1_627064_427872 0 0.0
iB00_5487_v n1_627064_424528 0 0.0
iB00_5488_v n1_625064_421184 0 1.0000000116531309e-08
iB00_5489_v n1_627064_421742 0 -5.27355e-14
iB00_5490_v n1_625064_417840 0 2.0999999996640974e-07
iB00_5491_v n1_627064_421184 0 0.0
iB00_5492_v n1_625064_414496 0 2.199999999802383e-07
iB00_5493_v n1_627064_417840 0 0.0
iB00_5494_v n1_625064_411152 0 -4.2999999995893003e-07
iB00_5495_v n1_627064_414496 0 0.0
iB00_5496_v n1_625064_407808 0 2.849999999640331e-07
iB00_5497_v n1_627064_411152 0 0.0
iB00_5498_v n1_625064_404464 0 -1.300000000192586e-07
iB00_5499_v n1_627064_407808 0 0.0
iB00_5500_v n1_625064_401120 0 -1.9499999999458305e-07
iB00_5501_v n1_627064_404464 0 0.0
iB00_5502_v n1_627064_401120 0 0.0
iB00_5503_v n1_625064_397776 0 -1.7500000002346537e-07
iB00_5504_v n1_627064_399854 0 -5.27355e-14
iB00_5505_v n1_625064_394432 0 -2.999999997435833e-08
iB00_5506_v n1_627064_397776 0 0.0
iB00_5507_v n1_625064_391088 0 -5.500000003307018e-08
iB00_5508_v n1_627064_394432 0 0.0
iB00_5509_v n1_625064_387744 0 2.49999999970902e-07
iB00_5510_v n1_627064_391088 0 0.0
iB00_5511_v n1_625064_384400 0 -1.399999999776065e-07
iB00_5512_v n1_627064_387744 0 0.0
iB00_5513_v n1_625064_381056 0 2.400000000364828e-07
iB00_5514_v n1_627064_384400 0 0.0
iB00_5515_v n1_625064_377712 0 -1.6000000001034582e-07
iB00_5516_v n1_627064_381056 0 0.0
iB00_5517_v n1_627064_377712 0 0.0
iB00_5518_v n1_625064_374368 0 -6.50000000045471e-08
iB00_5519_v n1_627064_377358 0 -5.27355e-14
iB00_5520_v n1_625064_371024 0 7.999999999437324e-08
iB00_5521_v n1_627064_374368 0 0.0
iB00_5522_v n1_625064_367680 0 -1.7499999997836087e-07
iB00_5523_v n1_627064_371024 0 0.0
iB00_5524_v n1_625064_364336 0 1.1999999998383069e-07
iB00_5525_v n1_627064_367680 0 0.0
iB00_5526_v n1_625064_360992 0 -9.499999997149389e-08
iB00_5527_v n1_627064_364336 0 0.0
iB00_5528_v n1_625064_357648 0 8.999999998173203e-08
iB00_5529_v n1_627064_360992 0 0.0
iB00_5530_v n1_627064_357648 0 0.0
iB00_5531_v n1_625064_354304 0 -6.999999998816797e-08
iB00_5532_v n1_627064_355470 0 -5.27355e-14
iB00_5533_v n1_625064_350960 0 1.5499999998987901e-07
iB00_5534_v n1_627064_354304 0 0.0
iB00_5535_v n1_625064_347616 0 -3.3000000000381526e-07
iB00_5536_v n1_627064_350960 0 0.0
iB00_5537_v n1_625064_344272 0 2.49999999996313e-08
iB00_5538_v n1_627064_347616 0 0.0
iB00_5539_v n1_625064_340928 0 2.1500000000529952e-07
iB00_5540_v n1_627064_344272 0 0.0
iB00_5541_v n1_625064_337584 0 -2.600000000014595e-07
iB00_5542_v n1_627064_340928 0 0.0
iB00_5543_v n1_625064_334240 0 1.6499999999608428e-07
iB00_5544_v n1_627064_337584 0 0.0
iB00_5545_v n1_627064_334240 0 0.0
iB00_5546_v n1_625064_330896 0 1.0000000006417026e-08
iB00_5547_v n1_627064_332974 0 -5.27355e-14
iB00_5548_v n1_625064_327552 0 1.9999999999789744e-07
iB00_5549_v n1_627064_330896 0 0.0
iB00_5550_v n1_625064_324208 0 -2.599999999959538e-07
iB00_5551_v n1_627064_327552 0 0.0
iB00_5552_v n1_625064_320864 0 1.649999999939667e-07
iB00_5553_v n1_627064_324208 0 0.0
iB00_5554_v n1_625064_317520 0 9.999999998370213e-09
iB00_5555_v n1_627064_320864 0 0.0
iB00_5556_v n1_625064_314176 0 -2.2500000000197567e-07
iB00_5557_v n1_627064_317520 0 0.0
iB00_5558_v n1_627064_314176 0 0.0
iB00_5559_v n1_625064_310832 0 1.149999999961864e-07
iB00_5560_v n1_627064_311086 0 -5.27355e-14
iB00_5561_v n1_625064_307488 0 3.3000000001969713e-07
iB00_5562_v n1_627064_310832 0 0.0
iB00_5563_v n1_625064_304144 0 -4.549999999907486e-07
iB00_5564_v n1_627064_307488 0 0.0
iB00_5565_v n1_625064_300800 0 3.649999999768293e-07
iB00_5566_v n1_627064_304144 0 0.0
iB00_5567_v n1_625064_297456 0 -1.2999999998897716e-07
iB00_5568_v n1_627064_300800 0 0.0
iB00_5569_v n1_625064_294112 0 1.349999999804331e-07
iB00_5570_v n1_627064_297456 0 0.0
iB00_5571_v n1_625064_290768 0 -3.0499999997580836e-07
iB00_5572_v n1_627064_294112 0 0.0
iB00_5573_v n1_627064_290768 0 0.0
iB00_5574_v n1_625064_287424 0 2.1999999996033303e-07
iB00_5575_v n1_627064_288590 0 -5.27355e-14
iB00_5576_v n1_625064_284080 0 -2.70000000014441e-07
iB00_5577_v n1_627064_287424 0 0.0
iB00_5578_v n1_625064_280736 0 1.4499999997350935e-07
iB00_5579_v n1_627064_284080 0 0.0
iB00_5580_v n1_625064_277392 0 -4.999999991455931e-09
iB00_5581_v n1_627064_280736 0 0.0
iB00_5582_v n1_625064_274048 0 -1.9999999995533404e-07
iB00_5583_v n1_627064_277392 0 0.0
iB00_5584_v n1_625064_270704 0 5.4999999980977655e-08
iB00_5585_v n1_627064_274048 0 0.0
iB00_5586_v n1_625064_267360 0 2.450000000266682e-07
iB00_5587_v n1_627064_270704 0 0.0
iB00_5588_v n1_627064_267360 0 0.0
iB00_5589_v n1_625064_264016 0 3.4249999999177245e-06
iB00_5590_v n1_627064_266702 0 -5.27355e-14
iB00_5591_v n1_625064_260672 0 -2.9849999998759328e-06
iB00_5592_v n1_627064_264016 0 0.0
iB00_5593_v n1_625064_257328 0 2.049999999916192e-06
iB00_5594_v n1_627064_260672 0 0.0
iB00_5595_v n1_625064_253984 0 -1.4849999999368064e-06
iB00_5596_v n1_627064_257328 0 0.0
iB00_5597_v n1_625064_250640 0 1.4150000000424474e-06
iB00_5598_v n1_627064_253984 0 0.0
iB00_5599_v n1_625064_247296 0 7.200000000215687e-07
iB00_5600_v n1_627064_250640 0 0.0
iB00_5601_v n1_627064_247296 0 0.0
iB00_5602_v n1_625064_243952 0 -2.1649999999989874e-06
iB00_5603_v n1_627064_244814 0 -5.27355e-14
iB00_5604_v n1_625064_240608 0 4.799999999505693e-07
iB00_5605_v n1_627064_243952 0 0.0
iB00_5606_v n1_625064_237264 0 -5.449999999913271e-07
iB00_5607_v n1_627064_240608 0 0.0
iB00_5608_v n1_625064_233920 0 -2.399999999630027e-07
iB00_5609_v n1_627064_237264 0 0.0
iB00_5610_v n1_625064_230576 0 1.380000000035552e-06
iB00_5611_v n1_627064_233920 0 0.0
iB00_5612_v n1_625064_227232 0 -7.250000000742228e-07
iB00_5613_v n1_627064_230576 0 0.0
iB00_5614_v n1_625064_223888 0 -1.6049999999966583e-06
iB00_5615_v n1_627064_227232 0 0.0
iB00_5616_v n1_627064_223888 0 0.0
iB00_5617_v n1_625064_220544 0 -1.7450000000574858e-06
iB00_5618_v n1_627064_222318 0 -5.27355e-14
iB00_5619_v n1_625064_217200 0 -1.1300000000396625e-06
iB00_5620_v n1_627064_220544 0 0.0
iB00_5621_v n1_625064_213856 0 5.950000000570818e-07
iB00_5622_v n1_627064_217200 0 0.0
iB00_5623_v n1_625064_210512 0 3.3949999999071556e-06
iB00_5624_v n1_627064_213856 0 0.0
iB00_5625_v n1_625064_207168 0 -2.774999999887712e-06
iB00_5626_v n1_627064_210512 0 0.0
iB00_5627_v n1_625064_203824 0 2.0199999999032935e-06
iB00_5628_v n1_627064_207168 0 0.0
iB00_5629_v n1_625064_200480 0 -2.2949999999513304e-06
iB00_5630_v n1_627064_203824 0 0.0
iB00_5631_v n1_627064_200480 0 0.0
iB00_5632_v n1_625064_197136 0 1.3950000002627591e-06
iB00_5633_v n1_627064_200430 0 -5.27355e-14
iB00_5634_v n1_625064_193792 0 -4.3600000001436455e-06
iB00_5635_v n1_627064_197136 0 0.0
iB00_5636_v n1_625064_190448 0 5.750000000110017e-07
iB00_5637_v n1_627064_193792 0 0.0
iB00_5638_v n1_625064_187104 0 1.1249999999491037e-06
iB00_5639_v n1_627064_190448 0 0.0
iB00_5640_v n1_625064_183760 0 2.2000000000734336e-06
iB00_5641_v n1_627064_187104 0 0.0
iB00_5642_v n1_625064_180416 0 -1.315000000017876e-06
iB00_5643_v n1_627064_183760 0 0.0
iB00_5644_v n1_627064_180416 0 0.0
iB00_5645_v n1_625064_177072 0 -4.1950000001990185e-06
iB00_5646_v n1_627064_177934 0 -2.63678e-14
iB00_5647_v n1_625064_173728 0 3.100000000326976e-07
iB00_5648_v n1_627064_177072 0 0.0
iB00_5649_v n1_625064_170384 0 -1.6999999995175307e-07
iB00_5650_v n1_627064_173728 0 0.0
iB00_5651_v n1_625064_167040 0 4.220000000004256e-06
iB00_5652_v n1_627064_170384 0 0.0
iB00_5653_v n1_625064_163696 0 -1.6900000000102278e-06
iB00_5654_v n1_627064_167040 0 0.0
iB00_5655_v n1_625064_160352 0 1.9250000001029003e-06
iB00_5656_v n1_627064_163696 0 0.0
iB00_5657_v n1_625064_157008 0 -1.5500000021751912e-07
iB00_5658_v n1_627064_160352 0 0.0
iB00_5659_v n1_627064_157008 0 0.0
iB00_5660_v n1_625064_153664 0 -4.695000000056119e-06
iB00_5661_v n1_627064_156046 0 -2.63678e-14
iB00_5662_v n1_625064_150320 0 4.704999999837437e-06
iB00_5663_v n1_627064_153664 0 0.0
iB00_5664_v n1_625064_146976 0 -2.4149999997763424e-06
iB00_5665_v n1_627064_150320 0 0.0
iB00_5666_v n1_625064_143632 0 -1.4000000001292777e-06
iB00_5667_v n1_627064_146976 0 0.0
iB00_5668_v n1_625064_140288 0 2.369999999892626e-06
iB00_5669_v n1_627064_143632 0 0.0
iB00_5670_v n1_625064_136944 0 -1.4900000000855987e-06
iB00_5671_v n1_627064_140288 0 0.0
iB00_5672_v n1_625064_133600 0 1.5800000000630956e-06
iB00_5673_v n1_627064_136944 0 0.0
iB00_5674_v n1_627064_133600 0 0.0
iB00_5675_v n1_625064_130256 0 -5.000000001078225e-07
iB00_5676_v n1_627064_133550 0 -2.63678e-14
iB00_5677_v n1_625064_126912 0 1.2000000006514585e-07
iB00_5678_v n1_627064_130256 0 0.0
iB00_5679_v n1_625064_123568 0 6.049999997458615e-07
iB00_5680_v n1_627064_126912 0 0.0
iB00_5681_v n1_625064_120224 0 1.000000002348474e-07
iB00_5682_v n1_627064_123568 0 0.0
iB00_5683_v n1_625064_116880 0 -2.3500000002033586e-06
iB00_5684_v n1_627064_120224 0 0.0
iB00_5685_v n1_625064_113536 0 2.350000000106797e-06
iB00_5686_v n1_627064_116880 0 0.0
iB00_5687_v n1_627064_113536 0 0.0
iB00_5688_v n1_625064_110192 0 -2.100000000427274e-06
iB00_5689_v n1_627064_111662 0 -2.63678e-14
iB00_5690_v n1_625064_106848 0 -8.046812998915853e-17
iB00_5691_v n1_627064_110192 0 0.0
iB00_5692_v n1_625064_103504 0 4.400000000148561e-06
iB00_5693_v n1_627064_106848 0 0.0
iB00_5694_v n1_625064_100160 0 -1.2499999996825624e-06
iB00_5695_v n1_627064_103504 0 0.0
iB00_5696_v n1_625064_96816 0 6.99999999439105e-07
iB00_5697_v n1_627064_100160 0 0.0
iB00_5698_v n1_625064_93472 0 -2.2499999993882936e-06
iB00_5699_v n1_627064_96816 0 0.0
iB00_5700_v n1_625064_90128 0 2.1999999994085128e-06
iB00_5701_v n1_627064_93472 0 0.0
iB00_5702_v n1_625064_89166 0 2.6454533008646308e-14
iB00_5703_v n1_627064_90128 0 0.0
iB00_5704_v n1_625064_86784 0 -2.4000000000052625e-06
iB00_5705_v n1_627064_89166 0 -2.63678e-14
iB00_5706_v n1_601546_86784 0 -3.9999999975015533e-07
iB00_5707_v n1_601546_83440 0 2.9499999999082127e-06
iB00_5708_v n1_623064_86784 0 3.3881317890172014e-18
iB00_5709_v n1_579050_83440 0 5.000000000383658e-07
iB00_5710_v n1_579050_80096 0 -3.2000000001628707e-06
iB00_5711_v n1_556858_80096 0 -3.0999999999390348e-06
iB00_5712_v n1_556858_76752 0 2.849999999870724e-06
iB00_5713_v n1_534666_76752 0 3.2500000000172907e-06
iB00_5714_v n1_534666_73408 0 -4.0657581468206416e-17
iB00_5715_v n1_512170_73408 0 -1.499999999901645e-07
iB00_5716_v n1_512170_70064 0 -9.999999997989048e-08
iB00_5717_v n1_489978_70064 0 1.0000000000021927e-07
iB00_5718_v n1_534666_70064 0 -3.1999999998206694e-06
iB00_5719_v n1_512170_67278 0 0.07473349999999995
iB00_5720_v n1_534666_67278 0 0.07061900000000007
iB00_5721_v n1_556858_67278 0 0.07029999999999992
iB00_5722_v n1_534666_66720 0 -2.4999999997683126e-07
iB00_5723_v n1_556858_70064 0 2.6499999999278837e-06
iB00_5724_v n1_579050_70064 0 -1.7500000001630794e-06
iB00_5725_v n1_556858_73408 0 -3.4999999999263593e-06
iB00_5726_v n1_579050_73408 0 2.700000000053354e-06
iB00_5727_v n1_601546_73408 0 1.8500000004140205e-06
iB00_5728_v n1_579050_76752 0 7.000000002319279e-07
iB00_5729_v n1_601546_76752 0 -3.6000000003602595e-06
iB00_5730_v n1_623064_76752 0 -1.6940658945086007e-18
iB00_5731_v n1_601546_80096 0 -5.999999997505939e-07
iB00_5732_v n1_623064_80096 0 5.00000000018037e-08
iB00_5733_v n1_625064_80096 0 5.499999999707128e-07
iB00_5734_v n1_627064_80096 0 0.0
iB00_5735_v n1_625064_76752 0 -4.5000000033810583e-07
iB00_5736_v n1_625064_83440 0 8.000000002880513e-07
iB00_5737_v n1_627064_83440 0 0.0
iB00_5738_v n1_623064_83440 0 0.0
iB00_5739_v n1_627064_86784 0 0.0
iB00_5740_v n1_625064_73408 0 7.962109704190423e-16
iB00_5741_v n1_627064_76752 0 0.0
iB00_5742_v n1_625064_70064 0 -1.000000000191928e-06
iB00_5743_v n1_627064_73408 0 0.0
iB00_5744_v n1_623064_73408 0 0.0
iB00_5745_v n1_601546_70064 0 -9.999999999954164e-07
iB00_5746_v n1_601546_67278 0 0.07260499999999967
iB00_5747_v n1_623064_70064 0 6.776263578034403e-18
iB00_5748_v n1_579050_67278 0 0.07135500000000015
iB00_5749_v n1_579050_66720 0 3.550000000153474e-06
iB00_5750_v n1_556858_66720 0 -4.250000000056753e-06
iB00_5751_v n1_556858_63376 0 4.099999999988661e-06
iB00_5752_v n1_579050_63376 0 -4.350000000134899e-06
iB00_5753_v n1_579050_60032 0 1.2499999999925765e-06
iB00_5754_v n1_601546_60032 0 -7.50000000038914e-07
iB00_5755_v n1_601546_63376 0 -3.299999999824277e-06
iB00_5756_v n1_623064_63376 0 3.3881317890172014e-18
iB00_5757_v n1_601546_66720 0 -1.9999999991234712e-07
iB00_5758_v n1_623064_66720 0 6.776263578034403e-18
iB00_5759_v n1_625064_66720 0 3.9899999999294666e-05
iB00_5760_v n1_627064_66720 0 0.0
iB00_5761_v n1_625064_63376 0 -4.2749999999483875e-05
iB00_5762_v n1_625064_67278 0 -1.4999999973673225e-05
iB00_5763_v n1_627064_67278 0 -2.63678e-14
iB00_5764_v n1_627064_70064 0 0.0
iB00_5765_v n1_625064_60032 0 1.3300000000005446e-05
iB00_5766_v n1_627064_63376 0 0.0
iB00_5767_v n1_625064_56688 0 -1.7750000001065525e-05
iB00_5768_v n1_627064_60032 0 0.0
iB00_5769_v n1_623064_60032 0 2.0000000000043854e-07
iB00_5770_v n1_601546_56688 0 9.500000001613253e-07
iB00_5771_v n1_623064_56688 0 2.4999999999716005e-07
iB00_5772_v n1_627064_56688 0 0.0
iB00_5773_v n1_625064_53344 0 3.76500000003841e-05
iB00_5774_v n1_627064_53344 0 0.0
iB00_5775_v n1_623064_53344 0 -1.4999999999694077e-07
iB00_5776_v n1_627064_50000 0 0.0
iB00_5777_v n1_46000_113536 0 -4.600000000309936e-06
iB00_5778_v n1_44000_116880 0 0.0
iB00_5779_v n1_46000_111662 0 5.00000002685852e-06
iB00_5780_v n1_48000_113536 0 -1.6940658945086007e-18
iB00_5781_v n1_44000_113536 0 0.0
iB00_5782_v n1_65594_111662 0 0.07329000000000005
iB00_5783_v n1_65594_110192 0 1.9499999997975997e-06
iB00_5784_v n1_44000_111662 0 -2.63678e-14
iB00_5785_v n1_46000_110192 0 -3.2102548700937983e-16
iB00_5786_v n1_46000_106848 0 -2.499999999551472e-06
iB00_5787_v n1_48000_110192 0 1.6940658945086007e-18
iB00_5788_v n1_44000_110192 0 0.0
iB00_5789_v n1_88090_110192 0 -3.949999999923958e-06
iB00_5790_v n1_65594_106848 0 -2.9499999999336237e-06
iB00_5791_v n1_65594_103504 0 0.0
iB00_5792_v n1_88090_106848 0 4.099999999880241e-06
iB00_5793_v n1_48000_106848 0 5.0000000000109636e-08
iB00_5794_v n1_44000_106848 0 0.0
iB00_5795_v n1_46000_103504 0 1.4999999977332408e-07
iB00_5796_v n1_46000_100160 0 1.5000000026799132e-07
iB00_5797_v n1_48000_103504 0 -5.00000000018037e-08
iB00_5798_v n1_44000_103504 0 0.0
iB00_5799_v n1_88090_103504 0 -4.500000000009867e-07
iB00_5800_v n1_65594_100160 0 2.5999999999938426e-06
iB00_5801_v n1_65594_96816 0 -3.099999999972916e-06
iB00_5802_v n1_88090_100160 0 -1.95000000001444e-06
iB00_5803_v n1_48000_100160 0 1.6940658945086007e-18
iB00_5804_v n1_44000_100160 0 0.0
iB00_5805_v n1_46000_96816 0 -4.999999980020986e-08
iB00_5806_v n1_46000_93472 0 1.6999999997123483e-06
iB00_5807_v n1_48000_96816 0 0.0
iB00_5808_v n1_44000_96816 0 0.0
iB00_5809_v n1_88090_96816 0 1.999999998784658e-07
iB00_5810_v n1_65594_93472 0 -4.9999999847643705e-08
iB00_5811_v n1_65594_90128 0 4.099999999880241e-06
iB00_5812_v n1_88090_93472 0 1.6500000001289788e-06
iB00_5813_v n1_48000_93472 0 -1.6940658945086007e-18
iB00_5814_v n1_44000_93472 0 0.0
iB00_5815_v n1_46000_90128 0 -2.599999999594043e-06
iB00_5816_v n1_46000_89166 0 2.6454533008646308e-14
iB00_5817_v n1_48000_90128 0 0.0
iB00_5818_v n1_44000_90128 0 0.0
iB00_5819_v n1_88090_90128 0 -1.9500000000483215e-06
iB00_5820_v n1_65594_89166 0 0.07552999999999976
iB00_5821_v n1_65594_86784 0 -1.3499999998098366e-06
iB00_5822_v n1_88090_89166 0 0.06440000000000004
iB00_5823_v n1_44000_89166 0 -2.63678e-14
iB00_5824_v n1_46000_86784 0 9.499999999156857e-07
iB00_5825_v n1_46000_83440 0 1.3499999998098366e-06
iB00_5826_v n1_48000_86784 0 0.0
iB00_5827_v n1_44000_86784 0 0.0
iB00_5828_v n1_88090_86784 0 3.39999999987193e-06
iB00_5829_v n1_65594_83440 0 -1.1000000000837271e-06
iB00_5830_v n1_65594_80096 0 3.000000000155656e-06
iB00_5831_v n1_88090_83440 0 -3.3000000000411173e-06
iB00_5832_v n1_48000_83440 0 0.0
iB00_5833_v n1_44000_83440 0 0.0
iB00_5834_v n1_46000_80096 0 1.8000000001005086e-06
iB00_5835_v n1_46000_76752 0 -1.7000000001460291e-06
iB00_5836_v n1_48000_80096 0 5.000000000349777e-08
iB00_5837_v n1_44000_80096 0 0.0
iB00_5838_v n1_88090_80096 0 2.199999999950614e-06
iB00_5839_v n1_65594_76752 0 4.9999999942511395e-08
iB00_5840_v n1_65594_73408 0 -7.50000000038914e-07
iB00_5841_v n1_88090_76752 0 6.000000002046035e-07
iB00_5842_v n1_48000_76752 0 1.6940658945086007e-18
iB00_5843_v n1_44000_76752 0 0.0
iB00_5844_v n1_46000_73408 0 1.4500000001895267e-06
iB00_5845_v n1_46000_70064 0 -3.5000000007598397e-06
iB00_5846_v n1_48000_73408 0 0.0
iB00_5847_v n1_44000_73408 0 0.0
iB00_5848_v n1_88090_73408 0 -2.3500000000153173e-06
iB00_5849_v n1_65594_70064 0 5.499999996047946e-07
iB00_5850_v n1_65594_67278 0 0.07846000000000025
iB00_5851_v n1_88090_70064 0 3.9999999998461405e-06
iB00_5852_v n1_48000_70064 0 0.0
iB00_5853_v n1_44000_70064 0 0.0
iB00_5854_v n1_46000_67278 0 2.0000000026899545e-05
iB00_5855_v n1_46000_66720 0 3.5500000005600496e-06
iB00_5856_v n1_44000_67278 0 -2.63678e-14
iB00_5857_v n1_88090_67278 0 0.07070500000000011
iB00_5858_v n1_65594_66720 0 8.500000001340009e-07
iB00_5859_v n1_65594_63376 0 -2.1000000002824315e-06
iB00_5860_v n1_88090_66720 0 2.0000000006820118e-07
iB00_5861_v n1_48000_66720 0 0.0
iB00_5862_v n1_44000_66720 0 0.0
iB00_5863_v n1_46000_63376 0 -2.094999999989347e-05
iB00_5864_v n1_46000_60032 0 1.8150000000334565e-05
iB00_5865_v n1_48000_63376 0 0.0
iB00_5866_v n1_44000_63376 0 0.0
iB00_5867_v n1_88090_63376 0 7.500000001134529e-07
iB00_5868_v n1_65594_60032 0 5.500000000316992e-07
iB00_5869_v n1_65594_56688 0 1.500000000077828e-06
iB00_5870_v n1_88090_60032 0 1.0000000003410059e-07
iB00_5871_v n1_48000_60032 0 -1.500000000003289e-07
iB00_5872_v n1_44000_60032 0 0.0
iB00_5873_v n1_46000_56688 0 -1.3800000000277593e-05
iB00_5874_v n1_46000_53344 0 -2.500000000418834e-06
iB00_5875_v n1_48000_56688 0 -2.0000000000043854e-07
iB00_5876_v n1_44000_56688 0 0.0
iB00_5877_v n1_88090_56688 0 -2.30000000017445e-06
iB00_5878_v n1_65594_53344 0 2.0000000027148909e-07
iB00_5879_v n1_65594_50000 0 -1.500000000077828e-06
iB00_5880_v n1_88090_53344 0 2.500000000418834e-06
iB00_5881_v n1_48000_53344 0 6.776263578034403e-18
iB00_5882_v n1_44000_53344 0 0.0
iB00_5883_v n1_46000_50000 0 1.5150000000361868e-05
iB00_5884_v n1_46000_46000 0 -1.7268050000000024
iB00_5885_v n1_48000_50000 0 -1.500000000104933e-07
iB00_5886_v n1_44000_50000 0 0.0
iB00_5887_v n1_88090_50000 0 -2.1500000002181666e-06
iB00_5888_v n1_65594_46000 0 -1.999999997299301e-05
iB00_5889_v n1_65594_44000 0 -2.63678e-14
iB00_5890_v n1_88090_46000 0 2.6237692574149207e-14
iB00_5891_v n1_28_46000 0 -4.543669999999922
iB00_5892_v n1_46000_28 0 -2.499999999985153e-05
iB00_5893_v n1_46000_0 0 -5.82945
iB00_5894_v n1_46000_48000 0 0.0
iB00_5895_v n1_0_46000 0 -7.7443e-14
iB00_5896_v n1_110282_46000 0 2.63678e-14
iB00_5897_v n1_88090_44000 0 -2.63678e-14
iB00_5898_v n1_110282_50000 0 3.250000000024067e-06
iB00_5899_v n1_132778_50000 0 -1.999999999733335e-07
iB00_5900_v n1_110282_53344 0 -1.2500000000535629e-06
iB00_5901_v n1_110282_56688 0 -5.999999999877631e-07
iB00_5902_v n1_132778_53344 0 1.0000000003410059e-07
iB00_5903_v n1_132778_56688 0 -2.4999999995311433e-07
iB00_5904_v n1_110282_60032 0 1.900000000024495e-06
iB00_5905_v n1_110282_63376 0 -1.8500000000887598e-06
iB00_5906_v n1_132778_60032 0 4.499999999908223e-07
iB00_5907_v n1_132778_63376 0 -2.5000000001071257e-07
iB00_5908_v n1_110282_66720 0 -1.0000000000699553e-07
iB00_5909_v n1_110282_67278 0 0.07111999999999993
iB00_5910_v n1_132778_66720 0 2.4999999992262115e-07
iB00_5911_v n1_132778_67278 0 0.07061650000000008
iB00_5912_v n1_110282_70064 0 -4.699999999891721e-06
iB00_5913_v n1_110282_73408 0 1.8499999999803396e-06
iB00_5914_v n1_132778_70064 0 2.099999999957171e-06
iB00_5915_v n1_132778_73408 0 -2.150000000018267e-06
iB00_5916_v n1_110282_76752 0 1.2999999999283116e-06
iB00_5917_v n1_110282_80096 0 -1.0500000000327955e-06
iB00_5918_v n1_132778_76752 0 -1.0500000000327955e-06
iB00_5919_v n1_132778_80096 0 5.50000000028311e-07
iB00_5920_v n1_110282_83440 0 -9.999999991551598e-08
iB00_5921_v n1_110282_86784 0 -7.000000001302839e-07
iB00_5922_v n1_132778_83440 0 -2.0499999999401206e-06
iB00_5923_v n1_132778_86784 0 1.3000000000435081e-06
iB00_5924_v n1_110282_89166 0 0.06440000000000004
iB00_5925_v n1_110282_90128 0 1.6999999999291887e-06
iB00_5926_v n1_132778_89166 0 0.06440000000000004
iB00_5927_v n1_132778_90128 0 -2.200000000031929e-06
iB00_5928_v n1_110282_93472 0 -4.00000000024594e-07
iB00_5929_v n1_110282_96816 0 9.499999998902747e-07
iB00_5930_v n1_132778_93472 0 -2.4999999997683126e-07
iB00_5931_v n1_132778_96816 0 3.10000000007456e-06
iB00_5932_v n1_110282_100160 0 7.000000001675534e-07
iB00_5933_v n1_110282_103504 0 -1.5500000000948783e-06
iB00_5934_v n1_132778_100160 0 -2.250000000116742e-06
iB00_5935_v n1_132778_103504 0 3.900000000015328e-06
iB00_5936_v n1_110282_106848 0 -9.500000002019829e-07
iB00_5937_v n1_154970_100160 0 -6.500000000014253e-07
iB00_5938_v n1_154970_96816 0 2.7499999999619842e-06
iB00_5939_v n1_177466_96816 0 4.0000000004153467e-07
iB00_5940_v n1_154970_93472 0 -3.6499999999029713e-06
iB00_5941_v n1_154970_90128 0 4.999999980020986e-08
iB00_5942_v n1_177466_93472 0 -3.5000000001093184e-07
iB00_5943_v n1_177466_90128 0 9.999999994262103e-08
iB00_5944_v n1_154970_89166 0 0.06440200000000008
iB00_5945_v n1_154970_86784 0 -2.9999999999388155e-07
iB00_5946_v n1_177466_89166 0 0.07355649999999997
iB00_5947_v n1_177466_86784 0 -1.5000000003251616e-07
iB00_5948_v n1_154970_83440 0 -4.9999999979780845e-08
iB00_5949_v n1_154970_80096 0 1.4999999999694077e-07
iB00_5950_v n1_177466_83440 0 -2.0000000001399107e-07
iB00_5951_v n1_177466_80096 0 2.0000000000043854e-07
iB00_5952_v n1_154970_76752 0 1.000000000239362e-07
iB00_5953_v n1_154970_73408 0 -2.5000000003104136e-07
iB00_5954_v n1_177466_76752 0 0.0
iB00_5955_v n1_177466_73408 0 1.0000000003240652e-07
iB00_5956_v n1_154970_70064 0 4.0000000005169906e-07
iB00_5957_v n1_154970_67278 0 0.07267200000000024
iB00_5958_v n1_177466_70064 0 -9.999999997989048e-08
iB00_5959_v n1_177466_67278 0 0.07946599999999994
iB00_5960_v n1_154970_66720 0 -3.500000000278725e-07
iB00_5961_v n1_154970_63376 0 2.4999999997683126e-07
iB00_5962_v n1_177466_66720 0 1.0000000003410059e-07
iB00_5963_v n1_177466_63376 0 3.5575383784680614e-17
iB00_5964_v n1_154970_60032 0 -4.999999995267579e-08
iB00_5965_v n1_154970_56688 0 0.0
iB00_5966_v n1_177466_60032 0 -1.4999999999694077e-07
iB00_5967_v n1_177466_56688 0 1.5000000001896363e-07
iB00_5968_v n1_154970_53344 0 -2.99999999980329e-07
iB00_5969_v n1_154970_50000 0 4.499999999366122e-07
iB00_5970_v n1_177466_53344 0 -2.4999999997683126e-07
iB00_5971_v n1_132778_46000 0 1.000000026275125e-06
iB00_5972_v n1_177466_50000 0 4.9999999971310515e-08
iB00_5973_v n1_154970_46000 0 -2.999999973701123e-06
iB00_5974_v n1_154970_44000 0 -2.63678e-14
iB00_5975_v n1_177466_46000 0 1.000000026361858e-06
iB00_5976_v n1_132778_44000 0 -2.63678e-14
iB00_5977_v n1_110282_44000 0 -2.63678e-14
iB00_5978_v n1_199658_46000 0 -9.999999736479452e-07
iB00_5979_v n1_177466_44000 0 -2.63678e-14
iB00_5980_v n1_199658_50000 0 -1.9999999998688602e-07
iB00_5981_v n1_221850_50000 0 -4.999999999502744e-08
iB00_5982_v n1_199658_53344 0 1.9999999999027415e-07
iB00_5983_v n1_199658_56688 0 -2.9999999999388155e-07
iB00_5984_v n1_221850_53344 0 -5.000000004415535e-08
iB00_5985_v n1_221850_56688 0 -3.9999999998224236e-07
iB00_5986_v n1_199658_60032 0 3.0000000000912814e-07
iB00_5987_v n1_199658_63376 0 -3.499999999838268e-07
iB00_5988_v n1_221850_60032 0 0.0
iB00_5989_v n1_221850_63376 0 -1.5246593050577406e-17
iB00_5990_v n1_199658_66720 0 2.499999999836075e-07
iB00_5991_v n1_199658_67278 0 0.08428349999999994
iB00_5992_v n1_221850_66720 0 2.0000000001399107e-07
iB00_5993_v n1_221850_67278 0 0.085529
iB00_5994_v n1_199658_70064 0 1.9999999999874448e-07
iB00_5995_v n1_199658_73408 0 -2.4999999997683126e-07
iB00_5996_v n1_221850_70064 0 1.4999999996983572e-07
iB00_5997_v n1_221850_73408 0 -1.4999999994442473e-07
iB00_5998_v n1_199658_76752 0 -1.9999999997841569e-07
iB00_5999_v n1_199658_80096 0 3.999999999195619e-07
iB00_6000_v n1_221850_76752 0 -1.5000000005115088e-07
iB00_6001_v n1_221850_80096 0 5.082197683525802e-17
iB00_6002_v n1_199658_83440 0 -5.000000000095667e-07
iB00_6003_v n1_199658_86784 0 3.0000000004809166e-07
iB00_6004_v n1_221850_83440 0 9.999999997989048e-08
iB00_6005_v n1_221850_86784 0 -1.0164395367051604e-17
iB00_6006_v n1_199658_89166 0 0.08201950000000008
iB00_6007_v n1_199658_90128 0 9.999999997989048e-08
iB00_6008_v n1_221850_89166 0 0.08186
iB00_6009_v n1_221850_90128 0 -3.8963515573697816e-17
iB00_6010_v n1_199658_93472 0 -3.999999999297263e-07
iB00_6011_v n1_244346_89166 0 0.08084950000000003
iB00_6012_v n1_244346_86784 0 3.499999999838268e-07
iB00_6013_v n1_266538_86784 0 5.499999998182469e-08
iB00_6014_v n1_244346_83440 0 -4.000000000110415e-07
iB00_6015_v n1_244346_80096 0 2.0000000001399107e-07
iB00_6016_v n1_266538_83440 0 -8.99999999656384e-08
iB00_6017_v n1_266538_80096 0 1.7999999999649834e-07
iB00_6018_v n1_244346_76752 0 2.4999999997174906e-07
iB00_6019_v n1_244346_73408 0 -1.9999999998688602e-07
iB00_6020_v n1_266538_76752 0 2.1499999998115908e-07
iB00_6021_v n1_266538_73408 0 -4.3000000001822234e-07
iB00_6022_v n1_244346_70064 0 -2.0000000000552074e-07
iB00_6023_v n1_244346_67278 0 0.08886900000000005
iB00_6024_v n1_266538_70064 0 1.4499999998981473e-07
iB00_6025_v n1_266538_67278 0 0.08454349999999998
iB00_6026_v n1_244346_66720 0 1.4999999998169418e-07
iB00_6027_v n1_244346_63376 0 1.0000000003410059e-07
iB00_6028_v n1_266538_66720 0 1.8000000001259196e-07
iB00_6029_v n1_266538_63376 0 -1.9999999997418052e-07
iB00_6030_v n1_244346_60032 0 4.999999998486304e-08
iB00_6031_v n1_244346_56688 0 -5.0000000017050295e-08
iB00_6032_v n1_266538_60032 0 1.0999999999414256e-07
iB00_6033_v n1_266538_56688 0 1.3000000001756452e-07
iB00_6034_v n1_244346_53344 0 -2.499999999836075e-07
iB00_6035_v n1_244346_50000 0 -5.0000000017050295e-08
iB00_6036_v n1_266538_53344 0 -1.0000000000699553e-07
iB00_6037_v n1_221850_46000 0 5.000000526891625e-07
iB00_6038_v n1_266538_50000 0 -1.500000000003289e-07
iB00_6039_v n1_244346_46000 0 1.0000000527079708e-06
iB00_6040_v n1_244346_44000 0 -5.27355e-14
iB00_6041_v n1_266538_46000 0 5.000000527272033e-07
iB00_6042_v n1_221850_44000 0 -5.27355e-14
iB00_6043_v n1_199658_44000 0 -2.63678e-14
iB00_6044_v n1_289034_46000 0 5.276260505431214e-14
iB00_6045_v n1_266538_44000 0 -5.27355e-14
iB00_6046_v n1_289034_50000 0 -3.79999999999478e-07
iB00_6047_v n1_311226_50000 0 1.4499999999786155e-07
iB00_6048_v n1_289034_53344 0 7.000000002014347e-08
iB00_6049_v n1_289034_56688 0 -6.500000003842842e-08
iB00_6050_v n1_311226_53344 0 2.0000000004109612e-07
iB00_6051_v n1_311226_56688 0 -3.1500000000933044e-07
iB00_6052_v n1_289034_60032 0 1.4000000000555858e-07
iB00_6053_v n1_289034_63376 0 2.150000000353692e-07
iB00_6054_v n1_311226_60032 0 1.2000000000839464e-07
iB00_6055_v n1_311226_63376 0 1.499999999406131e-08
iB00_6056_v n1_289034_66720 0 -3.3500000000818845e-07
iB00_6057_v n1_289034_67278 0 0.08630300000000009
iB00_6058_v n1_311226_66720 0 -1.0999999999414256e-07
iB00_6059_v n1_311226_67278 0 0.08805199999999996
iB00_6060_v n1_289034_70064 0 8.999999998850829e-08
iB00_6061_v n1_289034_73408 0 -1.8999999997263393e-07
iB00_6062_v n1_311226_70064 0 -3.75000000019457e-07
iB00_6063_v n1_311226_73408 0 3.2000000000099813e-07
iB00_6064_v n1_289034_76752 0 -9.000000002154257e-08
iB00_6065_v n1_289034_80096 0 -1.1499999997416355e-07
iB00_6066_v n1_311226_76752 0 5.000000034231095e-09
iB00_6067_v n1_311226_80096 0 -3.24999999997748e-07
iB00_6068_v n1_289034_83440 0 2.2999999998390248e-07
iB00_6069_v n1_333722_76752 0 -5.000000000540359e-08
iB00_6070_v n1_333722_73408 0 -1.350000000026677e-07
iB00_6071_v n1_355914_73408 0 -3.849999999913574e-07
iB00_6072_v n1_333722_70064 0 1.8000000002233284e-07
iB00_6073_v n1_333722_67278 0 0.08655074999999997
iB00_6074_v n1_355914_70064 0 2.800000000195875e-07
iB00_6075_v n1_355914_67278 0 0.08538124999999999
iB00_6076_v n1_333722_66720 0 9.500000000749279e-08
iB00_6077_v n1_333722_63376 0 -1.0499999995991147e-07
iB00_6078_v n1_355914_66720 0 6.000000000419732e-08
iB00_6079_v n1_355914_63376 0 1.2999999995361354e-07
iB00_6080_v n1_333722_60032 0 9.000000000290785e-08
iB00_6081_v n1_333722_56688 0 1.7499999997836087e-07
iB00_6082_v n1_355914_60032 0 1.000000001425208e-08
iB00_6083_v n1_355914_56688 0 -2.799999999962941e-07
iB00_6084_v n1_333722_53344 0 -3.5499999997422393e-07
iB00_6085_v n1_333722_50000 0 1.4999999994273067e-08
iB00_6086_v n1_355914_53344 0 2.6000000004529344e-07
iB00_6087_v n1_311226_46000 0 5.270839494568786e-14
iB00_6088_v n1_355914_50000 0 1.349999999687864e-07
iB00_6089_v n1_333722_46000 0 5.275998821857586e-14
iB00_6090_v n1_333722_44000 0 -5.27355e-14
iB00_6091_v n1_355914_46000 0 -4.999999472614369e-07
iB00_6092_v n1_311226_44000 0 -5.27355e-14
iB00_6093_v n1_289034_44000 0 -5.27355e-14
iB00_6094_v n1_378410_46000 0 5.27355e-14
iB00_6095_v n1_355914_44000 0 -5.27355e-14
iB00_6096_v n1_378410_50000 0 1.4999999999694077e-07
iB00_6097_v n1_400602_50000 0 1.350000000077499e-07
iB00_6098_v n1_378410_53344 0 1.399999999928531e-07
iB00_6099_v n1_378410_56688 0 1.4999999994273067e-08
iB00_6100_v n1_400602_53344 0 -6.499999998421831e-08
iB00_6101_v n1_400602_56688 0 1.3999999998946496e-07
iB00_6102_v n1_378410_60032 0 -2.2000000000607281e-07
iB00_6103_v n1_378410_63376 0 -6.000000000419732e-08
iB00_6104_v n1_400602_60032 0 -2.500000000039363e-07
iB00_6105_v n1_400602_63376 0 2.549999999949687e-07
iB00_6106_v n1_378410_66720 0 1.0000000010863949e-08
iB00_6107_v n1_378410_67278 0 0.0876785
iB00_6108_v n1_400602_66720 0 -3.499999999838268e-07
iB00_6109_v n1_400602_67278 0 0.088463
iB00_6110_v n1_378410_70064 0 2.1499999998878238e-07
iB00_6111_v n1_422794_66720 0 -2.0000000001060294e-07
iB00_6112_v n1_422794_63376 0 1.9999999998688602e-07
iB00_6113_v n1_445290_63376 0 9.999999999683114e-08
iB00_6114_v n1_422794_60032 0 -4.999999997469865e-08
iB00_6115_v n1_422794_56688 0 0.0
iB00_6116_v n1_445290_60032 0 9.999999997989048e-08
iB00_6117_v n1_445290_56688 0 -2.999999999904934e-07
iB00_6118_v n1_422794_53344 0 3.499999999973793e-07
iB00_6119_v n1_422794_50000 0 -4.9999999962840186e-08
iB00_6120_v n1_445290_53344 0 -1.0000000000699553e-07
iB00_6121_v n1_400602_46000 0 5.27355e-14
iB00_6122_v n1_445290_50000 0 1.5000000000202297e-07
iB00_6123_v n1_422794_46000 0 -4.999999472072268e-07
iB00_6124_v n1_422794_44000 0 -5.27355e-14
iB00_6125_v n1_445290_46000 0 -9.999999473506247e-07
iB00_6126_v n1_400602_44000 0 -5.27355e-14
iB00_6127_v n1_378410_44000 0 -5.27355e-14
iB00_6128_v n1_467482_46000 0 5.000000529060029e-07
iB00_6129_v n1_445290_44000 0 -5.27355e-14
iB00_6130_v n1_467482_50000 0 -2.9999999999388155e-07
iB00_6131_v n1_489978_50000 0 2.0000000010885876e-07
iB00_6132_v n1_467482_53344 0 2.202285662861181e-17
iB00_6133_v n1_467482_56688 0 -5.0000000017050295e-08
iB00_6134_v n1_489978_53344 0 4.9999999962840186e-08
iB00_6135_v n1_489978_56688 0 -1.500000000003289e-07
iB00_6136_v n1_467482_60032 0 1.5000000003251616e-07
iB00_6137_v n1_512170_53344 0 -5.000000001027403e-08
iB00_6138_v n1_512170_50000 0 2.4999999997683126e-07
iB00_6139_v n1_489978_46000 0 3.0000000263066153e-06
iB00_6140_v n1_534666_50000 0 -4.9999999979780845e-08
iB00_6141_v n1_512170_46000 0 -1.499999973623295e-06
iB00_6142_v n1_512170_44000 0 -2.63678e-14
iB00_6143_v n1_534666_46000 0 -9.999999737780527e-07
iB00_6144_v n1_489978_44000 0 -2.63678e-14
iB00_6145_v n1_467482_44000 0 -5.27355e-14
iB00_6146_v n1_556858_46000 0 2.6454533008646308e-14
iB00_6147_v n1_534666_44000 0 -2.63678e-14
iB00_6148_v n1_556858_44000 0 -2.63678e-14
iB00_6149_v n1_579050_44000 0 -2.63678e-14
.op
.print tran v(n1_625064_28) v(n1_625064_0) v(n1_625064_46000) v(n1_625064_50000) v(n1_671036_46000) v(n1_601546_46000) v(n1_625064_48000) v(n1_671064_46000) v(n1_579050_46000) v(n1_601546_44000) v(n1_601546_50000) v(n1_601546_53344) v(n1_623064_50000) v(n1_579050_50000) v(n1_556858_50000) v(n1_579050_53344) v(n1_579050_56688) v(n1_556858_53344) v(n1_534666_53344) v(n1_556858_56688) v(n1_556858_60032) v(n1_534666_56688) v(n1_512170_56688) v(n1_534666_60032) v(n1_534666_63376) v(n1_512170_60032) v(n1_489978_60032) v(n1_512170_63376) v(n1_512170_66720) v(n1_489978_63376) v(n1_467482_63376) v(n1_489978_66720) v(n1_489978_67278) v(n1_467482_66720) v(n1_445290_66720) v(n1_467482_67278) v(n1_467482_70064) v(n1_445290_67278) v(n1_422794_67278) v(n1_445290_70064) v(n1_445290_73408) v(n1_422794_70064) v(n1_400602_70064) v(n1_422794_73408) v(n1_422794_76752) v(n1_400602_73408) v(n1_378410_73408) v(n1_400602_76752) v(n1_400602_80096) v(n1_378410_76752) v(n1_355914_76752) v(n1_378410_80096) v(n1_378410_83440) v(n1_355914_80096) v(n1_333722_80096) v(n1_355914_83440) v(n1_355914_86784) v(n1_333722_83440) v(n1_311226_83440) v(n1_333722_86784) v(n1_333722_89166) v(n1_311226_86784) v(n1_289034_86784) v(n1_311226_89166) v(n1_311226_90128) v(n1_289034_89166) v(n1_266538_89166) v(n1_289034_90128) v(n1_289034_93472) v(n1_266538_90128) v(n1_244346_90128) v(n1_266538_93472) v(n1_266538_96816) v(n1_244346_93472) v(n1_221850_93472) v(n1_244346_96816) v(n1_244346_100160) v(n1_221850_96816) v(n1_199658_96816) v(n1_221850_100160) v(n1_221850_103504) v(n1_199658_100160) v(n1_177466_100160) v(n1_199658_103504) v(n1_199658_106848) v(n1_177466_103504) v(n1_154970_103504) v(n1_177466_106848) v(n1_177466_110192) v(n1_154970_106848) v(n1_132778_106848) v(n1_154970_110192) v(n1_154970_111662) v(n1_132778_110192) v(n1_110282_110192) v(n1_132778_111662) v(n1_132778_113536) v(n1_110282_111662) v(n1_88090_111662) v(n1_110282_113536) v(n1_110282_116880) v(n1_88090_113536) v(n1_65594_113536) v(n1_88090_116880) v(n1_88090_120224) v(n1_65594_116880) v(n1_48000_116880) v(n1_65594_120224) v(n1_65594_123568) v(n1_48000_120224) v(n1_46000_120224) v(n1_44000_120224) v(n1_46000_116880) v(n1_46000_123568) v(n1_46000_126912) v(n1_48000_123568) v(n1_44000_123568) v(n1_88090_123568) v(n1_65594_126912) v(n1_65594_130256) v(n1_88090_126912) v(n1_48000_126912) v(n1_44000_126912) v(n1_46000_130256) v(n1_46000_133550) v(n1_48000_130256) v(n1_44000_130256) v(n1_88090_130256) v(n1_65594_133550) v(n1_65594_133600) v(n1_88090_133550) v(n1_44000_133550) v(n1_46000_133600) v(n1_46000_136944) v(n1_48000_133600) v(n1_44000_133600) v(n1_88090_133600) v(n1_65594_136944) v(n1_65594_140288) v(n1_88090_136944) v(n1_48000_136944) v(n1_44000_136944) v(n1_46000_140288) v(n1_46000_143632) v(n1_48000_140288) v(n1_44000_140288) v(n1_88090_140288) v(n1_65594_143632) v(n1_65594_146976) v(n1_88090_143632) v(n1_48000_143632) v(n1_44000_143632) v(n1_46000_146976) v(n1_46000_150320) v(n1_48000_146976) v(n1_44000_146976) v(n1_88090_146976) v(n1_65594_150320) v(n1_65594_153664) v(n1_88090_150320) v(n1_48000_150320) v(n1_44000_150320) v(n1_46000_153664) v(n1_46000_156046) v(n1_48000_153664) v(n1_44000_153664) v(n1_88090_153664) v(n1_65594_156046) v(n1_65594_157008) v(n1_88090_156046) v(n1_44000_156046) v(n1_46000_157008) v(n1_46000_160352) v(n1_48000_157008) v(n1_44000_157008) v(n1_88090_157008) v(n1_65594_160352) v(n1_65594_163696) v(n1_88090_160352) v(n1_48000_160352) v(n1_44000_160352) v(n1_46000_163696) v(n1_46000_167040) v(n1_48000_163696) v(n1_44000_163696) v(n1_88090_163696) v(n1_65594_167040) v(n1_65594_170384) v(n1_88090_167040) v(n1_48000_167040) v(n1_44000_167040) v(n1_46000_170384) v(n1_46000_173728) v(n1_48000_170384) v(n1_44000_170384) v(n1_88090_170384) v(n1_65594_173728) v(n1_65594_177072) v(n1_88090_173728) v(n1_48000_173728) v(n1_44000_173728) v(n1_46000_177072) v(n1_46000_177934) v(n1_48000_177072) v(n1_44000_177072) v(n1_88090_177072) v(n1_65594_177934) v(n1_65594_180416) v(n1_88090_177934) v(n1_44000_177934) v(n1_46000_180416) v(n1_46000_183760) v(n1_48000_180416) v(n1_44000_180416) v(n1_88090_180416) v(n1_65594_183760) v(n1_65594_187104) v(n1_88090_183760) v(n1_48000_183760) v(n1_44000_183760) v(n1_46000_187104) v(n1_46000_190448) v(n1_48000_187104) v(n1_44000_187104) v(n1_88090_187104) v(n1_65594_190448) v(n1_65594_193792) v(n1_88090_190448) v(n1_48000_190448) v(n1_44000_190448) v(n1_46000_193792) v(n1_46000_197136) v(n1_48000_193792) v(n1_44000_193792) v(n1_88090_193792) v(n1_65594_197136) v(n1_65594_200430) v(n1_88090_197136) v(n1_48000_197136) v(n1_44000_197136) v(n1_46000_200430) v(n1_46000_200480) v(n1_44000_200430) v(n1_88090_200430) v(n1_65594_200480) v(n1_65594_203824) v(n1_88090_200480) v(n1_48000_200480) v(n1_44000_200480) v(n1_46000_203824) v(n1_46000_207168) v(n1_48000_203824) v(n1_44000_203824) v(n1_88090_203824) v(n1_65594_207168) v(n1_65594_210512) v(n1_88090_207168) v(n1_48000_207168) v(n1_44000_207168) v(n1_46000_210512) v(n1_46000_213856) v(n1_48000_210512) v(n1_44000_210512) v(n1_88090_210512) v(n1_65594_213856) v(n1_65594_217200) v(n1_88090_213856) v(n1_48000_213856) v(n1_44000_213856) v(n1_46000_217200) v(n1_46000_220544) v(n1_48000_217200) v(n1_44000_217200) v(n1_88090_217200) v(n1_65594_220544) v(n1_65594_222318) v(n1_88090_220544) v(n1_48000_220544) v(n1_44000_220544) v(n1_46000_222318) v(n1_46000_223888) v(n1_44000_222318) v(n1_88090_222318) v(n1_65594_223888) v(n1_65594_227232) v(n1_88090_223888) v(n1_48000_223888) v(n1_44000_223888) v(n1_46000_227232) v(n1_46000_230576) v(n1_48000_227232) v(n1_44000_227232) v(n1_88090_227232) v(n1_65594_230576) v(n1_65594_233920) v(n1_88090_230576) v(n1_48000_230576) v(n1_44000_230576) v(n1_46000_233920) v(n1_46000_237264) v(n1_48000_233920) v(n1_44000_233920) v(n1_88090_233920) v(n1_65594_237264) v(n1_65594_240608) v(n1_88090_237264) v(n1_48000_237264) v(n1_44000_237264) v(n1_46000_240608) v(n1_46000_243952) v(n1_48000_240608) v(n1_44000_240608) v(n1_88090_240608) v(n1_65594_243952) v(n1_65594_244814) v(n1_88090_243952) v(n1_48000_243952) v(n1_44000_243952) v(n1_46000_244814) v(n1_46000_247296) v(n1_44000_244814) v(n1_88090_244814) v(n1_65594_247296) v(n1_65594_250640) v(n1_88090_247296) v(n1_48000_247296) v(n1_44000_247296) v(n1_46000_250640) v(n1_46000_253984) v(n1_48000_250640) v(n1_44000_250640) v(n1_88090_250640) v(n1_65594_253984) v(n1_65594_257328) v(n1_88090_253984) v(n1_48000_253984) v(n1_44000_253984) v(n1_46000_257328) v(n1_46000_260672) v(n1_48000_257328) v(n1_44000_257328) v(n1_88090_257328) v(n1_65594_260672) v(n1_65594_264016) v(n1_88090_260672) v(n1_48000_260672) v(n1_44000_260672) v(n1_46000_264016) v(n1_46000_266702) v(n1_48000_264016) v(n1_44000_264016) v(n1_88090_264016) v(n1_65594_266702) v(n1_65594_267360) v(n1_88090_266702) v(n1_44000_266702) v(n1_46000_267360) v(n1_46000_270704) v(n1_48000_267360) v(n1_44000_267360) v(n1_88090_267360) v(n1_65594_270704) v(n1_65594_274048) v(n1_88090_270704) v(n1_48000_270704) v(n1_44000_270704) v(n1_46000_274048) v(n1_46000_277392) v(n1_48000_274048) v(n1_44000_274048) v(n1_88090_274048) v(n1_65594_277392) v(n1_65594_280736) v(n1_88090_277392) v(n1_48000_277392) v(n1_44000_277392) v(n1_46000_280736) v(n1_46000_284080) v(n1_48000_280736) v(n1_44000_280736) v(n1_88090_280736) v(n1_65594_284080) v(n1_65594_287424) v(n1_88090_284080) v(n1_48000_284080) v(n1_44000_284080) v(n1_46000_287424) v(n1_46000_288590) v(n1_48000_287424) v(n1_44000_287424) v(n1_88090_287424) v(n1_65594_288590) v(n1_65594_290768) v(n1_88090_288590) v(n1_44000_288590) v(n1_46000_290768) v(n1_46000_294112) v(n1_48000_290768) v(n1_44000_290768) v(n1_88090_290768) v(n1_65594_294112) v(n1_65594_297456) v(n1_88090_294112) v(n1_48000_294112) v(n1_44000_294112) v(n1_46000_297456) v(n1_46000_300800) v(n1_48000_297456) v(n1_44000_297456) v(n1_88090_297456) v(n1_65594_300800) v(n1_65594_304144) v(n1_88090_300800) v(n1_48000_300800) v(n1_44000_300800) v(n1_46000_304144) v(n1_46000_307488) v(n1_48000_304144) v(n1_44000_304144) v(n1_88090_304144) v(n1_65594_307488) v(n1_65594_310832) v(n1_88090_307488) v(n1_48000_307488) v(n1_44000_307488) v(n1_46000_310832) v(n1_46000_311086) v(n1_48000_310832) v(n1_44000_310832) v(n1_88090_310832) v(n1_65594_311086) v(n1_65594_314176) v(n1_88090_311086) v(n1_44000_311086) v(n1_46000_314176) v(n1_46000_317520) v(n1_48000_314176) v(n1_44000_314176) v(n1_88090_314176) v(n1_65594_317520) v(n1_65594_320864) v(n1_88090_317520) v(n1_48000_317520) v(n1_44000_317520) v(n1_46000_320864) v(n1_46000_324208) v(n1_48000_320864) v(n1_44000_320864) v(n1_88090_320864) v(n1_65594_324208) v(n1_65594_327552) v(n1_88090_324208) v(n1_48000_324208) v(n1_44000_324208) v(n1_46000_327552) v(n1_46000_330896) v(n1_48000_327552) v(n1_44000_327552) v(n1_88090_327552) v(n1_65594_330896) v(n1_65594_332974) v(n1_88090_330896) v(n1_48000_330896) v(n1_44000_330896) v(n1_46000_332974) v(n1_46000_334240) v(n1_44000_332974) v(n1_88090_332974) v(n1_65594_334240) v(n1_65594_337584) v(n1_88090_334240) v(n1_48000_334240) v(n1_44000_334240) v(n1_46000_337584) v(n1_46000_340928) v(n1_48000_337584) v(n1_44000_337584) v(n1_88090_337584) v(n1_65594_340928) v(n1_65594_344272) v(n1_88090_340928) v(n1_48000_340928) v(n1_44000_340928) v(n1_46000_344272) v(n1_46000_347616) v(n1_48000_344272) v(n1_44000_344272) v(n1_88090_344272) v(n1_65594_347616) v(n1_65594_350960) v(n1_88090_347616) v(n1_48000_347616) v(n1_44000_347616) v(n1_46000_350960) v(n1_46000_354304) v(n1_48000_350960) v(n1_44000_350960) v(n1_88090_350960) v(n1_65594_354304) v(n1_65594_355470) v(n1_88090_354304) v(n1_48000_354304) v(n1_44000_354304) v(n1_46000_355470) v(n1_46000_357648) v(n1_44000_355470) v(n1_88090_355470) v(n1_65594_357648) v(n1_65594_360992) v(n1_88090_357648) v(n1_48000_357648) v(n1_44000_357648) v(n1_46000_360992) v(n1_46000_364336) v(n1_48000_360992) v(n1_44000_360992) v(n1_88090_360992) v(n1_65594_364336) v(n1_65594_367680) v(n1_88090_364336) v(n1_48000_364336) v(n1_44000_364336) v(n1_46000_367680) v(n1_46000_371024) v(n1_48000_367680) v(n1_44000_367680) v(n1_88090_367680) v(n1_65594_371024) v(n1_65594_374368) v(n1_88090_371024) v(n1_48000_371024) v(n1_44000_371024) v(n1_46000_374368) v(n1_46000_377358) v(n1_48000_374368) v(n1_44000_374368) v(n1_88090_374368) v(n1_65594_377358) v(n1_65594_377712) v(n1_88090_377358) v(n1_44000_377358) v(n1_46000_377712) v(n1_46000_381056) v(n1_48000_377712) v(n1_44000_377712) v(n1_88090_377712) v(n1_65594_381056) v(n1_65594_384400) v(n1_88090_381056) v(n1_48000_381056) v(n1_44000_381056) v(n1_46000_384400) v(n1_46000_387744) v(n1_48000_384400) v(n1_44000_384400) v(n1_88090_384400) v(n1_65594_387744) v(n1_65594_391088) v(n1_88090_387744) v(n1_48000_387744) v(n1_44000_387744) v(n1_46000_391088) v(n1_46000_394432) v(n1_48000_391088) v(n1_44000_391088) v(n1_88090_391088) v(n1_65594_394432) v(n1_65594_397776) v(n1_88090_394432) v(n1_48000_394432) v(n1_44000_394432) v(n1_46000_397776) v(n1_46000_399854) v(n1_48000_397776) v(n1_44000_397776) v(n1_88090_397776) v(n1_65594_399854) v(n1_65594_401120) v(n1_88090_399854) v(n1_44000_399854) v(n1_46000_401120) v(n1_46000_404464) v(n1_48000_401120) v(n1_44000_401120) v(n1_88090_401120) v(n1_65594_404464) v(n1_65594_407808) v(n1_88090_404464) v(n1_48000_404464) v(n1_44000_404464) v(n1_46000_407808) v(n1_46000_411152) v(n1_48000_407808) v(n1_44000_407808) v(n1_88090_407808) v(n1_65594_411152) v(n1_65594_414496) v(n1_88090_411152) v(n1_48000_411152) v(n1_44000_411152) v(n1_46000_414496) v(n1_46000_417840) v(n1_48000_414496) v(n1_44000_414496) v(n1_88090_414496) v(n1_65594_417840) v(n1_65594_421184) v(n1_88090_417840) v(n1_48000_417840) v(n1_44000_417840) v(n1_46000_421184) v(n1_46000_421742) v(n1_48000_421184) v(n1_44000_421184) v(n1_88090_421184) v(n1_65594_421742) v(n1_65594_424528) v(n1_88090_421742) v(n1_44000_421742) v(n1_46000_424528) v(n1_46000_427872) v(n1_48000_424528) v(n1_44000_424528) v(n1_88090_424528) v(n1_65594_427872) v(n1_65594_431216) v(n1_88090_427872) v(n1_48000_427872) v(n1_44000_427872) v(n1_46000_431216) v(n1_46000_434560) v(n1_48000_431216) v(n1_44000_431216) v(n1_88090_431216) v(n1_65594_434560) v(n1_65594_437904) v(n1_88090_434560) v(n1_48000_434560) v(n1_44000_434560) v(n1_46000_437904) v(n1_46000_441248) v(n1_48000_437904) v(n1_44000_437904) v(n1_88090_437904) v(n1_65594_441248) v(n1_65594_444238) v(n1_88090_441248) v(n1_48000_441248) v(n1_44000_441248) v(n1_46000_444238) v(n1_46000_444592) v(n1_44000_444238) v(n1_88090_444238) v(n1_65594_444592) v(n1_65594_447936) v(n1_88090_444592) v(n1_48000_444592) v(n1_44000_444592) v(n1_46000_447936) v(n1_46000_451280) v(n1_48000_447936) v(n1_44000_447936) v(n1_88090_447936) v(n1_65594_451280) v(n1_65594_454624) v(n1_88090_451280) v(n1_48000_451280) v(n1_44000_451280) v(n1_46000_454624) v(n1_46000_457968) v(n1_48000_454624) v(n1_44000_454624) v(n1_88090_454624) v(n1_65594_457968) v(n1_65594_461312) v(n1_88090_457968) v(n1_48000_457968) v(n1_44000_457968) v(n1_46000_461312) v(n1_46000_464656) v(n1_48000_461312) v(n1_44000_461312) v(n1_88090_461312) v(n1_65594_464656) v(n1_65594_466126) v(n1_88090_464656) v(n1_48000_464656) v(n1_44000_464656) v(n1_46000_466126) v(n1_46000_468000) v(n1_44000_466126) v(n1_88090_466126) v(n1_65594_468000) v(n1_65594_471344) v(n1_88090_468000) v(n1_48000_468000) v(n1_44000_468000) v(n1_46000_471344) v(n1_46000_474688) v(n1_48000_471344) v(n1_44000_471344) v(n1_88090_471344) v(n1_65594_474688) v(n1_65594_478032) v(n1_88090_474688) v(n1_48000_474688) v(n1_44000_474688) v(n1_46000_478032) v(n1_46000_481376) v(n1_48000_478032) v(n1_44000_478032) v(n1_88090_478032) v(n1_65594_481376) v(n1_65594_484720) v(n1_88090_481376) v(n1_48000_481376) v(n1_44000_481376) v(n1_46000_484720) v(n1_46000_488064) v(n1_48000_484720) v(n1_44000_484720) v(n1_88090_484720) v(n1_65594_488064) v(n1_65594_488622) v(n1_88090_488064) v(n1_48000_488064) v(n1_44000_488064) v(n1_46000_488622) v(n1_46000_491408) v(n1_44000_488622) v(n1_88090_488622) v(n1_65594_491408) v(n1_65594_494752) v(n1_88090_491408) v(n1_48000_491408) v(n1_44000_491408) v(n1_46000_494752) v(n1_46000_498096) v(n1_48000_494752) v(n1_44000_494752) v(n1_88090_494752) v(n1_65594_498096) v(n1_65594_501440) v(n1_88090_498096) v(n1_48000_498096) v(n1_44000_498096) v(n1_46000_501440) v(n1_46000_504784) v(n1_48000_501440) v(n1_44000_501440) v(n1_88090_501440) v(n1_65594_504784) v(n1_65594_508128) v(n1_88090_504784) v(n1_48000_504784) v(n1_44000_504784) v(n1_46000_508128) v(n1_46000_510510) v(n1_48000_508128) v(n1_44000_508128) v(n1_88090_508128) v(n1_65594_510510) v(n1_65594_511472) v(n1_88090_510510) v(n1_44000_510510) v(n1_46000_511472) v(n1_46000_514816) v(n1_48000_511472) v(n1_44000_511472) v(n1_88090_511472) v(n1_65594_514816) v(n1_65594_518160) v(n1_88090_514816) v(n1_48000_514816) v(n1_44000_514816) v(n1_46000_518160) v(n1_46000_521504) v(n1_48000_518160) v(n1_44000_518160) v(n1_88090_518160) v(n1_65594_521504) v(n1_65594_524848) v(n1_88090_521504) v(n1_48000_521504) v(n1_44000_521504) v(n1_46000_524848) v(n1_46000_528192) v(n1_48000_524848) v(n1_44000_524848) v(n1_88090_524848) v(n1_65594_528192) v(n1_65594_531536) v(n1_88090_528192) v(n1_48000_528192) v(n1_44000_528192) v(n1_46000_531536) v(n1_46000_532398) v(n1_48000_531536) v(n1_44000_531536) v(n1_88090_531536) v(n1_65594_532398) v(n1_65594_534880) v(n1_88090_532398) v(n1_44000_532398) v(n1_46000_534880) v(n1_46000_538224) v(n1_48000_534880) v(n1_44000_534880) v(n1_88090_534880) v(n1_65594_538224) v(n1_65594_541568) v(n1_88090_538224) v(n1_48000_538224) v(n1_44000_538224) v(n1_46000_541568) v(n1_46000_544912) v(n1_48000_541568) v(n1_44000_541568) v(n1_88090_541568) v(n1_65594_544912) v(n1_65594_548256) v(n1_88090_544912) v(n1_48000_544912) v(n1_44000_544912) v(n1_46000_548256) v(n1_46000_551600) v(n1_48000_548256) v(n1_44000_548256) v(n1_88090_548256) v(n1_65594_551600) v(n1_65594_554894) v(n1_88090_551600) v(n1_48000_551600) v(n1_44000_551600) v(n1_46000_554894) v(n1_46000_554944) v(n1_44000_554894) v(n1_88090_554894) v(n1_65594_554944) v(n1_65594_558288) v(n1_88090_554944) v(n1_48000_554944) v(n1_44000_554944) v(n1_46000_558288) v(n1_46000_561632) v(n1_48000_558288) v(n1_44000_558288) v(n1_88090_558288) v(n1_65594_561632) v(n1_65594_564976) v(n1_88090_561632) v(n1_48000_561632) v(n1_44000_561632) v(n1_46000_564976) v(n1_46000_568320) v(n1_48000_564976) v(n1_44000_564976) v(n1_88090_564976) v(n1_65594_568320) v(n1_65594_571664) v(n1_88090_568320) v(n1_48000_568320) v(n1_44000_568320) v(n1_46000_571664) v(n1_46000_575008) v(n1_48000_571664) v(n1_44000_571664) v(n1_88090_571664) v(n1_65594_575008) v(n1_65594_576782) v(n1_88090_575008) v(n1_48000_575008) v(n1_44000_575008) v(n1_46000_576782) v(n1_46000_578352) v(n1_44000_576782) v(n1_88090_576782) v(n1_65594_578352) v(n1_65594_581696) v(n1_88090_578352) v(n1_48000_578352) v(n1_44000_578352) v(n1_46000_581696) v(n1_46000_585040) v(n1_48000_581696) v(n1_44000_581696) v(n1_88090_581696) v(n1_65594_585040) v(n1_65594_588384) v(n1_88090_585040) v(n1_48000_585040) v(n1_44000_585040) v(n1_46000_588384) v(n1_46000_591728) v(n1_48000_588384) v(n1_44000_588384) v(n1_88090_588384) v(n1_65594_591728) v(n1_65594_595072) v(n1_88090_591728) v(n1_48000_591728) v(n1_44000_591728) v(n1_46000_595072) v(n1_46000_598416) v(n1_48000_595072) v(n1_44000_595072) v(n1_88090_595072) v(n1_65594_598416) v(n1_65594_599278) v(n1_88090_598416) v(n1_48000_598416) v(n1_44000_598416) v(n1_46000_599278) v(n1_46000_601760) v(n1_44000_599278) v(n1_88090_599278) v(n1_65594_601760) v(n1_65594_605104) v(n1_88090_601760) v(n1_48000_601760) v(n1_44000_601760) v(n1_46000_605104) v(n1_46000_608448) v(n1_48000_605104) v(n1_44000_605104) v(n1_88090_605104) v(n1_65594_608448) v(n1_65594_611792) v(n1_88090_608448) v(n1_48000_608448) v(n1_44000_608448) v(n1_46000_611792) v(n1_46000_615136) v(n1_48000_611792) v(n1_44000_611792) v(n1_88090_611792) v(n1_65594_615136) v(n1_65594_618480) v(n1_88090_615136) v(n1_48000_615136) v(n1_44000_615136) v(n1_46000_618480) v(n1_46000_624152) v(n1_48000_618480) v(n1_44000_618480) v(n1_88090_618480) v(n1_65594_624152) v(n1_65594_626152) v(n1_88090_624152) v(n1_28_624152) v(n1_46000_670124) v(n1_46000_670152) v(n1_46000_622152) v(n1_0_624152) v(n1_110282_624152) v(n1_88090_626152) v(n1_110282_618480) v(n1_132778_618480) v(n1_110282_615136) v(n1_110282_626152) v(n1_132778_624152) v(n1_154970_624152) v(n1_132778_626152) v(n1_132778_615136) v(n1_154970_618480) v(n1_177466_618480) v(n1_154970_615136) v(n1_154970_626152) v(n1_177466_624152) v(n1_199658_624152) v(n1_177466_626152) v(n1_177466_615136) v(n1_199658_618480) v(n1_221850_618480) v(n1_199658_615136) v(n1_199658_626152) v(n1_221850_624152) v(n1_244346_624152) v(n1_221850_626152) v(n1_221850_615136) v(n1_244346_618480) v(n1_266538_618480) v(n1_244346_615136) v(n1_244346_626152) v(n1_266538_624152) v(n1_289034_624152) v(n1_266538_626152) v(n1_266538_615136) v(n1_289034_618480) v(n1_311226_618480) v(n1_289034_615136) v(n1_289034_626152) v(n1_311226_624152) v(n1_333722_624152) v(n1_311226_626152) v(n1_311226_615136) v(n1_333722_618480) v(n1_355914_618480) v(n1_333722_615136) v(n1_333722_626152) v(n1_355914_624152) v(n1_378410_624152) v(n1_355914_626152) v(n1_355914_615136) v(n1_378410_618480) v(n1_400602_618480) v(n1_378410_615136) v(n1_378410_626152) v(n1_400602_624152) v(n1_422794_624152) v(n1_400602_626152) v(n1_400602_615136) v(n1_422794_618480) v(n1_445290_618480) v(n1_422794_615136) v(n1_422794_626152) v(n1_445290_624152) v(n1_467482_624152) v(n1_445290_626152) v(n1_445290_615136) v(n1_467482_618480) v(n1_489978_618480) v(n1_467482_615136) v(n1_467482_626152) v(n1_489978_624152) v(n1_512170_624152) v(n1_489978_626152) v(n1_489978_615136) v(n1_512170_618480) v(n1_534666_618480) v(n1_512170_615136) v(n1_512170_626152) v(n1_534666_624152) v(n1_556858_624152) v(n1_534666_626152) v(n1_534666_615136) v(n1_556858_618480) v(n1_579050_618480) v(n1_556858_615136) v(n1_556858_626152) v(n1_579050_624152) v(n1_601546_624152) v(n1_579050_626152) v(n1_579050_615136) v(n1_601546_618480) v(n1_623064_618480) v(n1_601546_615136) v(n1_601546_626152) v(n1_625064_624152) v(n1_671036_624152) v(n1_625064_618480) v(n1_625064_670124) v(n1_625064_670152) v(n1_625064_622152) v(n1_671064_624152) v(n1_625064_615136) v(n1_627064_618480) v(n1_625064_611792) v(n1_627064_615136) v(n1_623064_615136) v(n1_601546_611792) v(n1_601546_608448) v(n1_623064_611792) v(n1_579050_611792) v(n1_556858_611792) v(n1_579050_608448) v(n1_556858_608448) v(n1_534666_611792) v(n1_512170_611792) v(n1_534666_608448) v(n1_512170_608448) v(n1_489978_611792) v(n1_467482_611792) v(n1_489978_608448) v(n1_467482_608448) v(n1_445290_611792) v(n1_422794_611792) v(n1_445290_608448) v(n1_422794_608448) v(n1_400602_611792) v(n1_378410_611792) v(n1_400602_608448) v(n1_378410_608448) v(n1_355914_611792) v(n1_333722_611792) v(n1_355914_608448) v(n1_333722_608448) v(n1_311226_611792) v(n1_289034_611792) v(n1_311226_608448) v(n1_289034_608448) v(n1_266538_611792) v(n1_244346_611792) v(n1_266538_608448) v(n1_244346_608448) v(n1_221850_611792) v(n1_199658_611792) v(n1_221850_608448) v(n1_199658_608448) v(n1_177466_611792) v(n1_154970_611792) v(n1_177466_608448) v(n1_154970_608448) v(n1_132778_611792) v(n1_110282_611792) v(n1_132778_608448) v(n1_110282_608448) v(n1_110282_605104) v(n1_110282_601760) v(n1_132778_605104) v(n1_132778_601760) v(n1_110282_599278) v(n1_110282_598416) v(n1_132778_599278) v(n1_132778_598416) v(n1_110282_595072) v(n1_110282_591728) v(n1_132778_595072) v(n1_132778_591728) v(n1_110282_588384) v(n1_110282_585040) v(n1_132778_588384) v(n1_132778_585040) v(n1_110282_581696) v(n1_110282_578352) v(n1_132778_581696) v(n1_132778_578352) v(n1_110282_576782) v(n1_110282_575008) v(n1_132778_576782) v(n1_132778_575008) v(n1_110282_571664) v(n1_110282_568320) v(n1_132778_571664) v(n1_132778_568320) v(n1_110282_564976) v(n1_110282_561632) v(n1_132778_564976) v(n1_132778_561632) v(n1_110282_558288) v(n1_110282_554944) v(n1_132778_558288) v(n1_132778_554944) v(n1_110282_554894) v(n1_110282_551600) v(n1_132778_554894) v(n1_132778_551600) v(n1_110282_548256) v(n1_110282_544912) v(n1_132778_548256) v(n1_132778_544912) v(n1_110282_541568) v(n1_110282_538224) v(n1_132778_541568) v(n1_132778_538224) v(n1_110282_534880) v(n1_110282_532398) v(n1_132778_534880) v(n1_132778_532398) v(n1_110282_531536) v(n1_110282_528192) v(n1_132778_531536) v(n1_132778_528192) v(n1_110282_524848) v(n1_110282_521504) v(n1_132778_524848) v(n1_132778_521504) v(n1_110282_518160) v(n1_110282_514816) v(n1_132778_518160) v(n1_132778_514816) v(n1_110282_511472) v(n1_110282_510510) v(n1_132778_511472) v(n1_132778_510510) v(n1_110282_508128) v(n1_110282_504784) v(n1_132778_508128) v(n1_132778_504784) v(n1_110282_501440) v(n1_110282_498096) v(n1_132778_501440) v(n1_132778_498096) v(n1_110282_494752) v(n1_110282_491408) v(n1_132778_494752) v(n1_132778_491408) v(n1_110282_488622) v(n1_110282_488064) v(n1_132778_488622) v(n1_132778_488064) v(n1_110282_484720) v(n1_110282_481376) v(n1_132778_484720) v(n1_132778_481376) v(n1_110282_478032) v(n1_110282_474688) v(n1_132778_478032) v(n1_132778_474688) v(n1_110282_471344) v(n1_110282_468000) v(n1_132778_471344) v(n1_132778_468000) v(n1_110282_466126) v(n1_110282_464656) v(n1_132778_466126) v(n1_132778_464656) v(n1_110282_461312) v(n1_110282_457968) v(n1_132778_461312) v(n1_132778_457968) v(n1_110282_454624) v(n1_110282_451280) v(n1_132778_454624) v(n1_132778_451280) v(n1_110282_447936) v(n1_110282_444592) v(n1_132778_447936) v(n1_132778_444592) v(n1_110282_444238) v(n1_110282_441248) v(n1_132778_444238) v(n1_132778_441248) v(n1_110282_437904) v(n1_110282_434560) v(n1_132778_437904) v(n1_132778_434560) v(n1_110282_431216) v(n1_110282_427872) v(n1_132778_431216) v(n1_132778_427872) v(n1_110282_424528) v(n1_110282_421742) v(n1_132778_424528) v(n1_132778_421742) v(n1_110282_421184) v(n1_110282_417840) v(n1_132778_421184) v(n1_132778_417840) v(n1_110282_414496) v(n1_110282_411152) v(n1_132778_414496) v(n1_132778_411152) v(n1_110282_407808) v(n1_110282_404464) v(n1_132778_407808) v(n1_132778_404464) v(n1_110282_401120) v(n1_110282_399854) v(n1_132778_401120) v(n1_132778_399854) v(n1_110282_397776) v(n1_110282_394432) v(n1_132778_397776) v(n1_132778_394432) v(n1_110282_391088) v(n1_110282_387744) v(n1_132778_391088) v(n1_132778_387744) v(n1_110282_384400) v(n1_110282_381056) v(n1_132778_384400) v(n1_132778_381056) v(n1_110282_377712) v(n1_110282_377358) v(n1_132778_377712) v(n1_132778_377358) v(n1_110282_374368) v(n1_110282_371024) v(n1_132778_374368) v(n1_132778_371024) v(n1_110282_367680) v(n1_110282_364336) v(n1_132778_367680) v(n1_132778_364336) v(n1_110282_360992) v(n1_110282_357648) v(n1_132778_360992) v(n1_132778_357648) v(n1_110282_355470) v(n1_110282_354304) v(n1_132778_355470) v(n1_132778_354304) v(n1_110282_350960) v(n1_110282_347616) v(n1_132778_350960) v(n1_132778_347616) v(n1_110282_344272) v(n1_110282_340928) v(n1_132778_344272) v(n1_132778_340928) v(n1_110282_337584) v(n1_110282_334240) v(n1_132778_337584) v(n1_132778_334240) v(n1_110282_332974) v(n1_110282_330896) v(n1_132778_332974) v(n1_132778_330896) v(n1_110282_327552) v(n1_110282_324208) v(n1_132778_327552) v(n1_132778_324208) v(n1_110282_320864) v(n1_110282_317520) v(n1_132778_320864) v(n1_132778_317520) v(n1_110282_314176) v(n1_110282_311086) v(n1_132778_314176) v(n1_132778_311086) v(n1_110282_310832) v(n1_110282_307488) v(n1_132778_310832) v(n1_132778_307488) v(n1_110282_304144) v(n1_110282_300800) v(n1_132778_304144) v(n1_132778_300800) v(n1_110282_297456) v(n1_110282_294112) v(n1_132778_297456) v(n1_132778_294112) v(n1_110282_290768) v(n1_110282_288590) v(n1_132778_290768) v(n1_132778_288590) v(n1_110282_287424) v(n1_110282_284080) v(n1_132778_287424) v(n1_132778_284080) v(n1_110282_280736) v(n1_110282_277392) v(n1_132778_280736) v(n1_132778_277392) v(n1_110282_274048) v(n1_110282_270704) v(n1_132778_274048) v(n1_132778_270704) v(n1_110282_267360) v(n1_110282_266702) v(n1_132778_267360) v(n1_132778_266702) v(n1_110282_264016) v(n1_110282_260672) v(n1_132778_264016) v(n1_132778_260672) v(n1_110282_257328) v(n1_110282_253984) v(n1_132778_257328) v(n1_132778_253984) v(n1_110282_250640) v(n1_110282_247296) v(n1_132778_250640) v(n1_132778_247296) v(n1_110282_244814) v(n1_110282_243952) v(n1_132778_244814) v(n1_132778_243952) v(n1_110282_240608) v(n1_110282_237264) v(n1_132778_240608) v(n1_132778_237264) v(n1_110282_233920) v(n1_110282_230576) v(n1_132778_233920) v(n1_132778_230576) v(n1_110282_227232) v(n1_110282_223888) v(n1_132778_227232) v(n1_132778_223888) v(n1_110282_222318) v(n1_110282_220544) v(n1_132778_222318) v(n1_132778_220544) v(n1_110282_217200) v(n1_110282_213856) v(n1_132778_217200) v(n1_132778_213856) v(n1_110282_210512) v(n1_110282_207168) v(n1_132778_210512) v(n1_132778_207168) v(n1_110282_203824) v(n1_110282_200480) v(n1_132778_203824) v(n1_132778_200480) v(n1_110282_200430) v(n1_110282_197136) v(n1_132778_200430) v(n1_132778_197136) v(n1_110282_193792) v(n1_110282_190448) v(n1_132778_193792) v(n1_132778_190448) v(n1_110282_187104) v(n1_110282_183760) v(n1_132778_187104) v(n1_132778_183760) v(n1_110282_180416) v(n1_110282_177934) v(n1_132778_180416) v(n1_132778_177934) v(n1_110282_177072) v(n1_110282_173728) v(n1_132778_177072) v(n1_132778_173728) v(n1_110282_170384) v(n1_110282_167040) v(n1_132778_170384) v(n1_132778_167040) v(n1_110282_163696) v(n1_110282_160352) v(n1_132778_163696) v(n1_132778_160352) v(n1_110282_157008) v(n1_110282_156046) v(n1_132778_157008) v(n1_132778_156046) v(n1_110282_153664) v(n1_110282_150320) v(n1_132778_153664) v(n1_132778_150320) v(n1_110282_146976) v(n1_110282_143632) v(n1_132778_146976) v(n1_132778_143632) v(n1_110282_140288) v(n1_110282_136944) v(n1_132778_140288) v(n1_132778_136944) v(n1_110282_133600) v(n1_110282_133550) v(n1_132778_133600) v(n1_132778_133550) v(n1_110282_130256) v(n1_110282_126912) v(n1_132778_130256) v(n1_132778_126912) v(n1_110282_123568) v(n1_110282_120224) v(n1_132778_123568) v(n1_132778_120224) v(n1_132778_116880) v(n1_154970_116880) v(n1_154970_120224) v(n1_177466_120224) v(n1_154970_123568) v(n1_154970_126912) v(n1_177466_123568) v(n1_177466_126912) v(n1_154970_130256) v(n1_154970_133550) v(n1_177466_130256) v(n1_177466_133550) v(n1_154970_133600) v(n1_154970_136944) v(n1_177466_133600) v(n1_177466_136944) v(n1_154970_140288) v(n1_154970_143632) v(n1_177466_140288) v(n1_177466_143632) v(n1_154970_146976) v(n1_154970_150320) v(n1_177466_146976) v(n1_177466_150320) v(n1_154970_153664) v(n1_154970_156046) v(n1_177466_153664) v(n1_177466_156046) v(n1_154970_157008) v(n1_154970_160352) v(n1_177466_157008) v(n1_177466_160352) v(n1_154970_163696) v(n1_154970_167040) v(n1_177466_163696) v(n1_177466_167040) v(n1_154970_170384) v(n1_154970_173728) v(n1_177466_170384) v(n1_177466_173728) v(n1_154970_177072) v(n1_154970_177934) v(n1_177466_177072) v(n1_177466_177934) v(n1_154970_180416) v(n1_154970_183760) v(n1_177466_180416) v(n1_177466_183760) v(n1_154970_187104) v(n1_154970_190448) v(n1_177466_187104) v(n1_177466_190448) v(n1_154970_193792) v(n1_154970_197136) v(n1_177466_193792) v(n1_177466_197136) v(n1_154970_200430) v(n1_154970_200480) v(n1_177466_200430) v(n1_177466_200480) v(n1_154970_203824) v(n1_154970_207168) v(n1_177466_203824) v(n1_177466_207168) v(n1_154970_210512) v(n1_154970_213856) v(n1_177466_210512) v(n1_177466_213856) v(n1_154970_217200) v(n1_154970_220544) v(n1_177466_217200) v(n1_177466_220544) v(n1_154970_222318) v(n1_154970_223888) v(n1_177466_222318) v(n1_177466_223888) v(n1_154970_227232) v(n1_154970_230576) v(n1_177466_227232) v(n1_177466_230576) v(n1_154970_233920) v(n1_154970_237264) v(n1_177466_233920) v(n1_177466_237264) v(n1_154970_240608) v(n1_154970_243952) v(n1_177466_240608) v(n1_177466_243952) v(n1_154970_244814) v(n1_154970_247296) v(n1_177466_244814) v(n1_177466_247296) v(n1_154970_250640) v(n1_154970_253984) v(n1_177466_250640) v(n1_177466_253984) v(n1_154970_257328) v(n1_154970_260672) v(n1_177466_257328) v(n1_177466_260672) v(n1_154970_264016) v(n1_154970_266702) v(n1_177466_264016) v(n1_177466_266702) v(n1_154970_267360) v(n1_154970_270704) v(n1_177466_267360) v(n1_177466_270704) v(n1_154970_274048) v(n1_154970_277392) v(n1_177466_274048) v(n1_177466_277392) v(n1_154970_280736) v(n1_154970_284080) v(n1_177466_280736) v(n1_177466_284080) v(n1_154970_287424) v(n1_154970_288590) v(n1_177466_287424) v(n1_177466_288590) v(n1_154970_290768) v(n1_154970_294112) v(n1_177466_290768) v(n1_177466_294112) v(n1_154970_297456) v(n1_154970_300800) v(n1_177466_297456) v(n1_177466_300800) v(n1_154970_304144) v(n1_154970_307488) v(n1_177466_304144) v(n1_177466_307488) v(n1_154970_310832) v(n1_154970_311086) v(n1_177466_310832) v(n1_177466_311086) v(n1_154970_314176) v(n1_154970_317520) v(n1_177466_314176) v(n1_177466_317520) v(n1_154970_320864) v(n1_154970_324208) v(n1_177466_320864) v(n1_177466_324208) v(n1_154970_327552) v(n1_154970_330896) v(n1_177466_327552) v(n1_177466_330896) v(n1_154970_332974) v(n1_154970_334240) v(n1_177466_332974) v(n1_177466_334240) v(n1_154970_337584) v(n1_154970_340928) v(n1_177466_337584) v(n1_177466_340928) v(n1_154970_344272) v(n1_154970_347616) v(n1_177466_344272) v(n1_177466_347616) v(n1_154970_350960) v(n1_154970_354304) v(n1_177466_350960) v(n1_177466_354304) v(n1_154970_355470) v(n1_154970_357648) v(n1_177466_355470) v(n1_177466_357648) v(n1_154970_360992) v(n1_154970_364336) v(n1_177466_360992) v(n1_177466_364336) v(n1_154970_367680) v(n1_154970_371024) v(n1_177466_367680) v(n1_177466_371024) v(n1_154970_374368) v(n1_154970_377358) v(n1_177466_374368) v(n1_177466_377358) v(n1_154970_377712) v(n1_154970_381056) v(n1_177466_377712) v(n1_177466_381056) v(n1_154970_384400) v(n1_154970_387744) v(n1_177466_384400) v(n1_177466_387744) v(n1_154970_391088) v(n1_154970_394432) v(n1_177466_391088) v(n1_177466_394432) v(n1_154970_397776) v(n1_154970_399854) v(n1_177466_397776) v(n1_177466_399854) v(n1_154970_401120) v(n1_154970_404464) v(n1_177466_401120) v(n1_177466_404464) v(n1_154970_407808) v(n1_154970_411152) v(n1_177466_407808) v(n1_177466_411152) v(n1_154970_414496) v(n1_154970_417840) v(n1_177466_414496) v(n1_177466_417840) v(n1_154970_421184) v(n1_154970_421742) v(n1_177466_421184) v(n1_177466_421742) v(n1_154970_424528) v(n1_154970_427872) v(n1_177466_424528) v(n1_177466_427872) v(n1_154970_431216) v(n1_154970_434560) v(n1_177466_431216) v(n1_177466_434560) v(n1_154970_437904) v(n1_154970_441248) v(n1_177466_437904) v(n1_177466_441248) v(n1_154970_444238) v(n1_154970_444592) v(n1_177466_444238) v(n1_177466_444592) v(n1_154970_447936) v(n1_154970_451280) v(n1_177466_447936) v(n1_177466_451280) v(n1_154970_454624) v(n1_154970_457968) v(n1_177466_454624) v(n1_177466_457968) v(n1_154970_461312) v(n1_154970_464656) v(n1_177466_461312) v(n1_177466_464656) v(n1_154970_466126) v(n1_154970_468000) v(n1_177466_466126) v(n1_177466_468000) v(n1_154970_471344) v(n1_154970_474688) v(n1_177466_471344) v(n1_177466_474688) v(n1_154970_478032) v(n1_154970_481376) v(n1_177466_478032) v(n1_177466_481376) v(n1_154970_484720) v(n1_154970_488064) v(n1_177466_484720) v(n1_177466_488064) v(n1_154970_488622) v(n1_154970_491408) v(n1_177466_488622) v(n1_177466_491408) v(n1_154970_494752) v(n1_154970_498096) v(n1_177466_494752) v(n1_177466_498096) v(n1_154970_501440) v(n1_154970_504784) v(n1_177466_501440) v(n1_177466_504784) v(n1_154970_508128) v(n1_154970_510510) v(n1_177466_508128) v(n1_177466_510510) v(n1_154970_511472) v(n1_154970_514816) v(n1_177466_511472) v(n1_177466_514816) v(n1_154970_518160) v(n1_154970_521504) v(n1_177466_518160) v(n1_177466_521504) v(n1_154970_524848) v(n1_154970_528192) v(n1_177466_524848) v(n1_177466_528192) v(n1_154970_531536) v(n1_154970_532398) v(n1_177466_531536) v(n1_177466_532398) v(n1_154970_534880) v(n1_154970_538224) v(n1_177466_534880) v(n1_177466_538224) v(n1_154970_541568) v(n1_154970_544912) v(n1_177466_541568) v(n1_177466_544912) v(n1_154970_548256) v(n1_154970_551600) v(n1_177466_548256) v(n1_177466_551600) v(n1_154970_554894) v(n1_154970_554944) v(n1_177466_554894) v(n1_177466_554944) v(n1_154970_558288) v(n1_154970_561632) v(n1_177466_558288) v(n1_177466_561632) v(n1_154970_564976) v(n1_154970_568320) v(n1_177466_564976) v(n1_177466_568320) v(n1_154970_571664) v(n1_154970_575008) v(n1_177466_571664) v(n1_177466_575008) v(n1_154970_576782) v(n1_154970_578352) v(n1_177466_576782) v(n1_177466_578352) v(n1_154970_581696) v(n1_154970_585040) v(n1_177466_581696) v(n1_177466_585040) v(n1_154970_588384) v(n1_154970_591728) v(n1_177466_588384) v(n1_177466_591728) v(n1_154970_595072) v(n1_154970_598416) v(n1_177466_595072) v(n1_177466_598416) v(n1_154970_599278) v(n1_154970_601760) v(n1_177466_599278) v(n1_177466_601760) v(n1_154970_605104) v(n1_177466_605104) v(n1_199658_605104) v(n1_221850_605104) v(n1_199658_601760) v(n1_221850_601760) v(n1_244346_605104) v(n1_266538_605104) v(n1_244346_601760) v(n1_266538_601760) v(n1_289034_605104) v(n1_311226_605104) v(n1_289034_601760) v(n1_311226_601760) v(n1_333722_605104) v(n1_355914_605104) v(n1_333722_601760) v(n1_355914_601760) v(n1_378410_605104) v(n1_400602_605104) v(n1_378410_601760) v(n1_400602_601760) v(n1_422794_605104) v(n1_445290_605104) v(n1_422794_601760) v(n1_445290_601760) v(n1_467482_605104) v(n1_489978_605104) v(n1_467482_601760) v(n1_489978_601760) v(n1_512170_605104) v(n1_534666_605104) v(n1_512170_601760) v(n1_534666_601760) v(n1_556858_605104) v(n1_579050_605104) v(n1_556858_601760) v(n1_579050_601760) v(n1_601546_605104) v(n1_623064_605104) v(n1_601546_601760) v(n1_623064_608448) v(n1_625064_608448) v(n1_627064_608448) v(n1_625064_605104) v(n1_627064_611792) v(n1_625064_601760) v(n1_627064_605104) v(n1_625064_599278) v(n1_627064_601760) v(n1_623064_601760) v(n1_601546_599278) v(n1_601546_598416) v(n1_579050_599278) v(n1_556858_599278) v(n1_579050_598416) v(n1_556858_598416) v(n1_534666_599278) v(n1_512170_599278) v(n1_534666_598416) v(n1_512170_598416) v(n1_489978_599278) v(n1_467482_599278) v(n1_489978_598416) v(n1_467482_598416) v(n1_445290_599278) v(n1_422794_599278) v(n1_445290_598416) v(n1_422794_598416) v(n1_400602_599278) v(n1_378410_599278) v(n1_400602_598416) v(n1_378410_598416) v(n1_355914_599278) v(n1_333722_599278) v(n1_355914_598416) v(n1_333722_598416) v(n1_311226_599278) v(n1_289034_599278) v(n1_311226_598416) v(n1_289034_598416) v(n1_266538_599278) v(n1_244346_599278) v(n1_266538_598416) v(n1_244346_598416) v(n1_221850_599278) v(n1_199658_599278) v(n1_221850_598416) v(n1_199658_598416) v(n1_199658_595072) v(n1_199658_591728) v(n1_221850_595072) v(n1_221850_591728) v(n1_199658_588384) v(n1_199658_585040) v(n1_221850_588384) v(n1_221850_585040) v(n1_199658_581696) v(n1_199658_578352) v(n1_221850_581696) v(n1_221850_578352) v(n1_199658_576782) v(n1_199658_575008) v(n1_221850_576782) v(n1_221850_575008) v(n1_199658_571664) v(n1_199658_568320) v(n1_221850_571664) v(n1_221850_568320) v(n1_199658_564976) v(n1_199658_561632) v(n1_221850_564976) v(n1_221850_561632) v(n1_199658_558288) v(n1_199658_554944) v(n1_221850_558288) v(n1_221850_554944) v(n1_199658_554894) v(n1_199658_551600) v(n1_221850_554894) v(n1_221850_551600) v(n1_199658_548256) v(n1_199658_544912) v(n1_221850_548256) v(n1_221850_544912) v(n1_199658_541568) v(n1_199658_538224) v(n1_221850_541568) v(n1_221850_538224) v(n1_199658_534880) v(n1_199658_532398) v(n1_221850_534880) v(n1_221850_532398) v(n1_199658_531536) v(n1_199658_528192) v(n1_221850_531536) v(n1_221850_528192) v(n1_199658_524848) v(n1_199658_521504) v(n1_221850_524848) v(n1_221850_521504) v(n1_199658_518160) v(n1_199658_514816) v(n1_221850_518160) v(n1_221850_514816) v(n1_199658_511472) v(n1_199658_510510) v(n1_221850_511472) v(n1_221850_510510) v(n1_199658_508128) v(n1_199658_504784) v(n1_221850_508128) v(n1_221850_504784) v(n1_199658_501440) v(n1_199658_498096) v(n1_221850_501440) v(n1_221850_498096) v(n1_199658_494752) v(n1_199658_491408) v(n1_221850_494752) v(n1_221850_491408) v(n1_199658_488622) v(n1_199658_488064) v(n1_221850_488622) v(n1_221850_488064) v(n1_199658_484720) v(n1_199658_481376) v(n1_221850_484720) v(n1_221850_481376) v(n1_199658_478032) v(n1_199658_474688) v(n1_221850_478032) v(n1_221850_474688) v(n1_199658_471344) v(n1_199658_468000) v(n1_221850_471344) v(n1_221850_468000) v(n1_199658_466126) v(n1_199658_464656) v(n1_221850_466126) v(n1_221850_464656) v(n1_199658_461312) v(n1_199658_457968) v(n1_221850_461312) v(n1_221850_457968) v(n1_199658_454624) v(n1_199658_451280) v(n1_221850_454624) v(n1_221850_451280) v(n1_199658_447936) v(n1_199658_444592) v(n1_221850_447936) v(n1_221850_444592) v(n1_199658_444238) v(n1_199658_441248) v(n1_221850_444238) v(n1_221850_441248) v(n1_199658_437904) v(n1_199658_434560) v(n1_221850_437904) v(n1_221850_434560) v(n1_199658_431216) v(n1_199658_427872) v(n1_221850_431216) v(n1_221850_427872) v(n1_199658_424528) v(n1_199658_421742) v(n1_221850_424528) v(n1_221850_421742) v(n1_199658_421184) v(n1_199658_417840) v(n1_221850_421184) v(n1_221850_417840) v(n1_199658_414496) v(n1_199658_411152) v(n1_221850_414496) v(n1_221850_411152) v(n1_199658_407808) v(n1_199658_404464) v(n1_221850_407808) v(n1_221850_404464) v(n1_199658_401120) v(n1_199658_399854) v(n1_221850_401120) v(n1_221850_399854) v(n1_199658_397776) v(n1_199658_394432) v(n1_221850_397776) v(n1_221850_394432) v(n1_199658_391088) v(n1_199658_387744) v(n1_221850_391088) v(n1_221850_387744) v(n1_199658_384400) v(n1_199658_381056) v(n1_221850_384400) v(n1_221850_381056) v(n1_199658_377712) v(n1_199658_377358) v(n1_221850_377712) v(n1_221850_377358) v(n1_199658_374368) v(n1_199658_371024) v(n1_221850_374368) v(n1_221850_371024) v(n1_199658_367680) v(n1_199658_364336) v(n1_221850_367680) v(n1_221850_364336) v(n1_199658_360992) v(n1_199658_357648) v(n1_221850_360992) v(n1_221850_357648) v(n1_199658_355470) v(n1_199658_354304) v(n1_221850_355470) v(n1_221850_354304) v(n1_199658_350960) v(n1_199658_347616) v(n1_221850_350960) v(n1_221850_347616) v(n1_199658_344272) v(n1_199658_340928) v(n1_221850_344272) v(n1_221850_340928) v(n1_199658_337584) v(n1_199658_334240) v(n1_221850_337584) v(n1_221850_334240) v(n1_199658_332974) v(n1_199658_330896) v(n1_221850_332974) v(n1_221850_330896) v(n1_199658_327552) v(n1_199658_324208) v(n1_221850_327552) v(n1_221850_324208) v(n1_199658_320864) v(n1_199658_317520) v(n1_221850_320864) v(n1_221850_317520) v(n1_199658_314176) v(n1_199658_311086) v(n1_221850_314176) v(n1_221850_311086) v(n1_199658_310832) v(n1_199658_307488) v(n1_221850_310832) v(n1_221850_307488) v(n1_199658_304144) v(n1_199658_300800) v(n1_221850_304144) v(n1_221850_300800) v(n1_199658_297456) v(n1_199658_294112) v(n1_221850_297456) v(n1_221850_294112) v(n1_199658_290768) v(n1_199658_288590) v(n1_221850_290768) v(n1_221850_288590) v(n1_199658_287424) v(n1_199658_284080) v(n1_221850_287424) v(n1_221850_284080) v(n1_199658_280736) v(n1_199658_277392) v(n1_221850_280736) v(n1_221850_277392) v(n1_199658_274048) v(n1_199658_270704) v(n1_221850_274048) v(n1_221850_270704) v(n1_199658_267360) v(n1_199658_266702) v(n1_221850_267360) v(n1_221850_266702) v(n1_199658_264016) v(n1_199658_260672) v(n1_221850_264016) v(n1_221850_260672) v(n1_199658_257328) v(n1_199658_253984) v(n1_221850_257328) v(n1_221850_253984) v(n1_199658_250640) v(n1_199658_247296) v(n1_221850_250640) v(n1_221850_247296) v(n1_199658_244814) v(n1_199658_243952) v(n1_221850_244814) v(n1_221850_243952) v(n1_199658_240608) v(n1_199658_237264) v(n1_221850_240608) v(n1_221850_237264) v(n1_199658_233920) v(n1_199658_230576) v(n1_221850_233920) v(n1_221850_230576) v(n1_199658_227232) v(n1_199658_223888) v(n1_221850_227232) v(n1_221850_223888) v(n1_199658_222318) v(n1_199658_220544) v(n1_221850_222318) v(n1_221850_220544) v(n1_199658_217200) v(n1_199658_213856) v(n1_221850_217200) v(n1_221850_213856) v(n1_199658_210512) v(n1_199658_207168) v(n1_221850_210512) v(n1_221850_207168) v(n1_199658_203824) v(n1_199658_200480) v(n1_221850_203824) v(n1_221850_200480) v(n1_199658_200430) v(n1_199658_197136) v(n1_221850_200430) v(n1_221850_197136) v(n1_199658_193792) v(n1_199658_190448) v(n1_221850_193792) v(n1_221850_190448) v(n1_199658_187104) v(n1_199658_183760) v(n1_221850_187104) v(n1_221850_183760) v(n1_199658_180416) v(n1_199658_177934) v(n1_221850_180416) v(n1_221850_177934) v(n1_199658_177072) v(n1_199658_173728) v(n1_221850_177072) v(n1_221850_173728) v(n1_199658_170384) v(n1_199658_167040) v(n1_221850_170384) v(n1_221850_167040) v(n1_199658_163696) v(n1_199658_160352) v(n1_221850_163696) v(n1_221850_160352) v(n1_199658_157008) v(n1_199658_156046) v(n1_221850_157008) v(n1_221850_156046) v(n1_199658_153664) v(n1_199658_150320) v(n1_221850_153664) v(n1_221850_150320) v(n1_199658_146976) v(n1_199658_143632) v(n1_221850_146976) v(n1_221850_143632) v(n1_199658_140288) v(n1_199658_136944) v(n1_221850_140288) v(n1_221850_136944) v(n1_199658_133600) v(n1_199658_133550) v(n1_221850_133600) v(n1_221850_133550) v(n1_199658_130256) v(n1_199658_126912) v(n1_221850_130256) v(n1_221850_126912) v(n1_199658_123568) v(n1_199658_120224) v(n1_221850_123568) v(n1_177466_116880) v(n1_221850_120224) v(n1_199658_116880) v(n1_199658_113536) v(n1_221850_116880) v(n1_177466_113536) v(n1_177466_111662) v(n1_154970_113536) v(n1_199658_111662) v(n1_199658_110192) v(n1_221850_110192) v(n1_221850_111662) v(n1_244346_111662) v(n1_221850_113536) v(n1_244346_113536) v(n1_266538_113536) v(n1_244346_116880) v(n1_244346_120224) v(n1_266538_116880) v(n1_266538_120224) v(n1_244346_123568) v(n1_244346_126912) v(n1_266538_123568) v(n1_266538_126912) v(n1_244346_130256) v(n1_244346_133550) v(n1_266538_130256) v(n1_266538_133550) v(n1_244346_133600) v(n1_244346_136944) v(n1_266538_133600) v(n1_266538_136944) v(n1_244346_140288) v(n1_244346_143632) v(n1_266538_140288) v(n1_266538_143632) v(n1_244346_146976) v(n1_244346_150320) v(n1_266538_146976) v(n1_266538_150320) v(n1_244346_153664) v(n1_244346_156046) v(n1_266538_153664) v(n1_266538_156046) v(n1_244346_157008) v(n1_244346_160352) v(n1_266538_157008) v(n1_266538_160352) v(n1_244346_163696) v(n1_244346_167040) v(n1_266538_163696) v(n1_266538_167040) v(n1_244346_170384) v(n1_244346_173728) v(n1_266538_170384) v(n1_266538_173728) v(n1_244346_177072) v(n1_244346_177934) v(n1_266538_177072) v(n1_266538_177934) v(n1_244346_180416) v(n1_244346_183760) v(n1_266538_180416) v(n1_266538_183760) v(n1_244346_187104) v(n1_244346_190448) v(n1_266538_187104) v(n1_266538_190448) v(n1_244346_193792) v(n1_244346_197136) v(n1_266538_193792) v(n1_266538_197136) v(n1_244346_200430) v(n1_244346_200480) v(n1_266538_200430) v(n1_266538_200480) v(n1_244346_203824) v(n1_244346_207168) v(n1_266538_203824) v(n1_266538_207168) v(n1_244346_210512) v(n1_244346_213856) v(n1_266538_210512) v(n1_266538_213856) v(n1_244346_217200) v(n1_244346_220544) v(n1_266538_217200) v(n1_266538_220544) v(n1_244346_222318) v(n1_244346_223888) v(n1_266538_222318) v(n1_266538_223888) v(n1_244346_227232) v(n1_244346_230576) v(n1_266538_227232) v(n1_266538_230576) v(n1_244346_233920) v(n1_244346_237264) v(n1_266538_233920) v(n1_266538_237264) v(n1_244346_240608) v(n1_244346_243952) v(n1_266538_240608) v(n1_266538_243952) v(n1_244346_244814) v(n1_244346_247296) v(n1_266538_244814) v(n1_266538_247296) v(n1_244346_250640) v(n1_244346_253984) v(n1_266538_250640) v(n1_266538_253984) v(n1_244346_257328) v(n1_244346_260672) v(n1_266538_257328) v(n1_266538_260672) v(n1_244346_264016) v(n1_244346_266702) v(n1_266538_264016) v(n1_266538_266702) v(n1_244346_267360) v(n1_244346_270704) v(n1_266538_267360) v(n1_266538_270704) v(n1_244346_274048) v(n1_244346_277392) v(n1_266538_274048) v(n1_266538_277392) v(n1_244346_280736) v(n1_244346_284080) v(n1_266538_280736) v(n1_266538_284080) v(n1_244346_287424) v(n1_244346_288590) v(n1_266538_287424) v(n1_266538_288590) v(n1_244346_290768) v(n1_244346_294112) v(n1_266538_290768) v(n1_266538_294112) v(n1_244346_297456) v(n1_244346_300800) v(n1_266538_297456) v(n1_266538_300800) v(n1_244346_304144) v(n1_244346_307488) v(n1_266538_304144) v(n1_266538_307488) v(n1_244346_310832) v(n1_244346_311086) v(n1_266538_310832) v(n1_266538_311086) v(n1_244346_314176) v(n1_244346_317520) v(n1_266538_314176) v(n1_266538_317520) v(n1_244346_320864) v(n1_244346_324208) v(n1_266538_320864) v(n1_266538_324208) v(n1_244346_327552) v(n1_244346_330896) v(n1_266538_327552) v(n1_266538_330896) v(n1_244346_332974) v(n1_244346_334240) v(n1_266538_332974) v(n1_266538_334240) v(n1_244346_337584) v(n1_244346_340928) v(n1_266538_337584) v(n1_266538_340928) v(n1_244346_344272) v(n1_244346_347616) v(n1_266538_344272) v(n1_266538_347616) v(n1_244346_350960) v(n1_244346_354304) v(n1_266538_350960) v(n1_266538_354304) v(n1_244346_355470) v(n1_244346_357648) v(n1_266538_355470) v(n1_266538_357648) v(n1_244346_360992) v(n1_244346_364336) v(n1_266538_360992) v(n1_266538_364336) v(n1_244346_367680) v(n1_244346_371024) v(n1_266538_367680) v(n1_266538_371024) v(n1_244346_374368) v(n1_244346_377358) v(n1_266538_374368) v(n1_266538_377358) v(n1_244346_377712) v(n1_244346_381056) v(n1_266538_377712) v(n1_266538_381056) v(n1_244346_384400) v(n1_244346_387744) v(n1_266538_384400) v(n1_266538_387744) v(n1_244346_391088) v(n1_244346_394432) v(n1_266538_391088) v(n1_266538_394432) v(n1_244346_397776) v(n1_244346_399854) v(n1_266538_397776) v(n1_266538_399854) v(n1_244346_401120) v(n1_244346_404464) v(n1_266538_401120) v(n1_266538_404464) v(n1_244346_407808) v(n1_244346_411152) v(n1_266538_407808) v(n1_266538_411152) v(n1_244346_414496) v(n1_244346_417840) v(n1_266538_414496) v(n1_266538_417840) v(n1_244346_421184) v(n1_244346_421742) v(n1_266538_421184) v(n1_266538_421742) v(n1_244346_424528) v(n1_244346_427872) v(n1_266538_424528) v(n1_266538_427872) v(n1_244346_431216) v(n1_244346_434560) v(n1_266538_431216) v(n1_266538_434560) v(n1_244346_437904) v(n1_244346_441248) v(n1_266538_437904) v(n1_266538_441248) v(n1_244346_444238) v(n1_244346_444592) v(n1_266538_444238) v(n1_266538_444592) v(n1_244346_447936) v(n1_244346_451280) v(n1_266538_447936) v(n1_266538_451280) v(n1_244346_454624) v(n1_244346_457968) v(n1_266538_454624) v(n1_266538_457968) v(n1_244346_461312) v(n1_244346_464656) v(n1_266538_461312) v(n1_266538_464656) v(n1_244346_466126) v(n1_244346_468000) v(n1_266538_466126) v(n1_266538_468000) v(n1_244346_471344) v(n1_244346_474688) v(n1_266538_471344) v(n1_266538_474688) v(n1_244346_478032) v(n1_244346_481376) v(n1_266538_478032) v(n1_266538_481376) v(n1_244346_484720) v(n1_244346_488064) v(n1_266538_484720) v(n1_266538_488064) v(n1_244346_488622) v(n1_244346_491408) v(n1_266538_488622) v(n1_266538_491408) v(n1_244346_494752) v(n1_244346_498096) v(n1_266538_494752) v(n1_266538_498096) v(n1_244346_501440) v(n1_244346_504784) v(n1_266538_501440) v(n1_266538_504784) v(n1_244346_508128) v(n1_244346_510510) v(n1_266538_508128) v(n1_266538_510510) v(n1_244346_511472) v(n1_244346_514816) v(n1_266538_511472) v(n1_266538_514816) v(n1_244346_518160) v(n1_244346_521504) v(n1_266538_518160) v(n1_266538_521504) v(n1_244346_524848) v(n1_244346_528192) v(n1_266538_524848) v(n1_266538_528192) v(n1_244346_531536) v(n1_244346_532398) v(n1_266538_531536) v(n1_266538_532398) v(n1_244346_534880) v(n1_244346_538224) v(n1_266538_534880) v(n1_266538_538224) v(n1_244346_541568) v(n1_244346_544912) v(n1_266538_541568) v(n1_266538_544912) v(n1_244346_548256) v(n1_244346_551600) v(n1_266538_548256) v(n1_266538_551600) v(n1_244346_554894) v(n1_244346_554944) v(n1_266538_554894) v(n1_266538_554944) v(n1_244346_558288) v(n1_244346_561632) v(n1_266538_558288) v(n1_266538_561632) v(n1_244346_564976) v(n1_244346_568320) v(n1_266538_564976) v(n1_266538_568320) v(n1_244346_571664) v(n1_244346_575008) v(n1_266538_571664) v(n1_266538_575008) v(n1_244346_576782) v(n1_244346_578352) v(n1_266538_576782) v(n1_266538_578352) v(n1_244346_581696) v(n1_244346_585040) v(n1_266538_581696) v(n1_266538_585040) v(n1_244346_588384) v(n1_244346_591728) v(n1_266538_588384) v(n1_266538_591728) v(n1_244346_595072) v(n1_266538_595072) v(n1_289034_595072) v(n1_311226_595072) v(n1_289034_591728) v(n1_311226_591728) v(n1_333722_595072) v(n1_355914_595072) v(n1_333722_591728) v(n1_355914_591728) v(n1_378410_595072) v(n1_400602_595072) v(n1_378410_591728) v(n1_400602_591728) v(n1_422794_595072) v(n1_445290_595072) v(n1_422794_591728) v(n1_445290_591728) v(n1_467482_595072) v(n1_489978_595072) v(n1_467482_591728) v(n1_489978_591728) v(n1_512170_595072) v(n1_534666_595072) v(n1_512170_591728) v(n1_534666_591728) v(n1_556858_595072) v(n1_579050_595072) v(n1_556858_591728) v(n1_579050_591728) v(n1_601546_595072) v(n1_623064_595072) v(n1_601546_591728) v(n1_623064_598416) v(n1_625064_598416) v(n1_627064_598416) v(n1_625064_595072) v(n1_627064_599278) v(n1_625064_591728) v(n1_627064_595072) v(n1_625064_588384) v(n1_627064_591728) v(n1_623064_591728) v(n1_601546_588384) v(n1_601546_585040) v(n1_623064_588384) v(n1_579050_588384) v(n1_556858_588384) v(n1_579050_585040) v(n1_556858_585040) v(n1_534666_588384) v(n1_512170_588384) v(n1_534666_585040) v(n1_512170_585040) v(n1_489978_588384) v(n1_467482_588384) v(n1_489978_585040) v(n1_467482_585040) v(n1_445290_588384) v(n1_422794_588384) v(n1_445290_585040) v(n1_422794_585040) v(n1_400602_588384) v(n1_378410_588384) v(n1_400602_585040) v(n1_378410_585040) v(n1_355914_588384) v(n1_333722_588384) v(n1_355914_585040) v(n1_333722_585040) v(n1_311226_588384) v(n1_289034_588384) v(n1_311226_585040) v(n1_289034_585040) v(n1_289034_581696) v(n1_289034_578352) v(n1_311226_581696) v(n1_311226_578352) v(n1_289034_576782) v(n1_289034_575008) v(n1_311226_576782) v(n1_311226_575008) v(n1_289034_571664) v(n1_289034_568320) v(n1_311226_571664) v(n1_311226_568320) v(n1_289034_564976) v(n1_289034_561632) v(n1_311226_564976) v(n1_311226_561632) v(n1_289034_558288) v(n1_289034_554944) v(n1_311226_558288) v(n1_311226_554944) v(n1_289034_554894) v(n1_289034_551600) v(n1_311226_554894) v(n1_311226_551600) v(n1_289034_548256) v(n1_289034_544912) v(n1_311226_548256) v(n1_311226_544912) v(n1_289034_541568) v(n1_289034_538224) v(n1_311226_541568) v(n1_311226_538224) v(n1_289034_534880) v(n1_289034_532398) v(n1_311226_534880) v(n1_311226_532398) v(n1_289034_531536) v(n1_289034_528192) v(n1_311226_531536) v(n1_311226_528192) v(n1_289034_524848) v(n1_289034_521504) v(n1_311226_524848) v(n1_311226_521504) v(n1_289034_518160) v(n1_289034_514816) v(n1_311226_518160) v(n1_311226_514816) v(n1_289034_511472) v(n1_289034_510510) v(n1_311226_511472) v(n1_311226_510510) v(n1_289034_508128) v(n1_289034_504784) v(n1_311226_508128) v(n1_311226_504784) v(n1_289034_501440) v(n1_289034_498096) v(n1_311226_501440) v(n1_311226_498096) v(n1_289034_494752) v(n1_289034_491408) v(n1_311226_494752) v(n1_311226_491408) v(n1_289034_488622) v(n1_289034_488064) v(n1_311226_488622) v(n1_311226_488064) v(n1_289034_484720) v(n1_289034_481376) v(n1_311226_484720) v(n1_311226_481376) v(n1_289034_478032) v(n1_289034_474688) v(n1_311226_478032) v(n1_311226_474688) v(n1_289034_471344) v(n1_289034_468000) v(n1_311226_471344) v(n1_311226_468000) v(n1_289034_466126) v(n1_289034_464656) v(n1_311226_466126) v(n1_311226_464656) v(n1_289034_461312) v(n1_289034_457968) v(n1_311226_461312) v(n1_311226_457968) v(n1_289034_454624) v(n1_289034_451280) v(n1_311226_454624) v(n1_311226_451280) v(n1_289034_447936) v(n1_289034_444592) v(n1_311226_447936) v(n1_311226_444592) v(n1_289034_444238) v(n1_289034_441248) v(n1_311226_444238) v(n1_311226_441248) v(n1_289034_437904) v(n1_289034_434560) v(n1_311226_437904) v(n1_311226_434560) v(n1_289034_431216) v(n1_289034_427872) v(n1_311226_431216) v(n1_311226_427872) v(n1_289034_424528) v(n1_289034_421742) v(n1_311226_424528) v(n1_311226_421742) v(n1_289034_421184) v(n1_289034_417840) v(n1_311226_421184) v(n1_311226_417840) v(n1_289034_414496) v(n1_289034_411152) v(n1_311226_414496) v(n1_311226_411152) v(n1_289034_407808) v(n1_289034_404464) v(n1_311226_407808) v(n1_311226_404464) v(n1_289034_401120) v(n1_289034_399854) v(n1_311226_401120) v(n1_311226_399854) v(n1_289034_397776) v(n1_289034_394432) v(n1_311226_397776) v(n1_311226_394432) v(n1_289034_391088) v(n1_289034_387744) v(n1_311226_391088) v(n1_311226_387744) v(n1_289034_384400) v(n1_289034_381056) v(n1_311226_384400) v(n1_311226_381056) v(n1_289034_377712) v(n1_289034_377358) v(n1_311226_377712) v(n1_311226_377358) v(n1_289034_374368) v(n1_289034_371024) v(n1_311226_374368) v(n1_311226_371024) v(n1_289034_367680) v(n1_289034_364336) v(n1_311226_367680) v(n1_311226_364336) v(n1_289034_360992) v(n1_289034_357648) v(n1_311226_360992) v(n1_311226_357648) v(n1_289034_355470) v(n1_289034_354304) v(n1_311226_355470) v(n1_311226_354304) v(n1_289034_350960) v(n1_289034_347616) v(n1_311226_350960) v(n1_311226_347616) v(n1_289034_344272) v(n1_289034_340928) v(n1_311226_344272) v(n1_311226_340928) v(n1_289034_337584) v(n1_289034_334240) v(n1_311226_337584) v(n1_311226_334240) v(n1_289034_332974) v(n1_289034_330896) v(n1_311226_332974) v(n1_311226_330896) v(n1_289034_327552) v(n1_289034_324208) v(n1_311226_327552) v(n1_311226_324208) v(n1_289034_320864) v(n1_289034_317520) v(n1_311226_320864) v(n1_311226_317520) v(n1_289034_314176) v(n1_289034_311086) v(n1_311226_314176) v(n1_311226_311086) v(n1_289034_310832) v(n1_289034_307488) v(n1_311226_310832) v(n1_311226_307488) v(n1_289034_304144) v(n1_289034_300800) v(n1_311226_304144) v(n1_311226_300800) v(n1_289034_297456) v(n1_289034_294112) v(n1_311226_297456) v(n1_311226_294112) v(n1_289034_290768) v(n1_289034_288590) v(n1_311226_290768) v(n1_311226_288590) v(n1_289034_287424) v(n1_289034_284080) v(n1_311226_287424) v(n1_311226_284080) v(n1_289034_280736) v(n1_289034_277392) v(n1_311226_280736) v(n1_311226_277392) v(n1_289034_274048) v(n1_289034_270704) v(n1_311226_274048) v(n1_311226_270704) v(n1_289034_267360) v(n1_289034_266702) v(n1_311226_267360) v(n1_311226_266702) v(n1_289034_264016) v(n1_289034_260672) v(n1_311226_264016) v(n1_311226_260672) v(n1_289034_257328) v(n1_289034_253984) v(n1_311226_257328) v(n1_311226_253984) v(n1_289034_250640) v(n1_289034_247296) v(n1_311226_250640) v(n1_311226_247296) v(n1_289034_244814) v(n1_289034_243952) v(n1_311226_244814) v(n1_311226_243952) v(n1_289034_240608) v(n1_289034_237264) v(n1_311226_240608) v(n1_311226_237264) v(n1_289034_233920) v(n1_289034_230576) v(n1_311226_233920) v(n1_311226_230576) v(n1_289034_227232) v(n1_289034_223888) v(n1_311226_227232) v(n1_311226_223888) v(n1_289034_222318) v(n1_289034_220544) v(n1_311226_222318) v(n1_311226_220544) v(n1_289034_217200) v(n1_289034_213856) v(n1_311226_217200) v(n1_311226_213856) v(n1_289034_210512) v(n1_289034_207168) v(n1_311226_210512) v(n1_311226_207168) v(n1_289034_203824) v(n1_289034_200480) v(n1_311226_203824) v(n1_311226_200480) v(n1_289034_200430) v(n1_289034_197136) v(n1_311226_200430) v(n1_311226_197136) v(n1_289034_193792) v(n1_289034_190448) v(n1_311226_193792) v(n1_311226_190448) v(n1_289034_187104) v(n1_289034_183760) v(n1_311226_187104) v(n1_311226_183760) v(n1_289034_180416) v(n1_289034_177934) v(n1_311226_180416) v(n1_311226_177934) v(n1_289034_177072) v(n1_289034_173728) v(n1_311226_177072) v(n1_311226_173728) v(n1_289034_170384) v(n1_289034_167040) v(n1_311226_170384) v(n1_311226_167040) v(n1_289034_163696) v(n1_289034_160352) v(n1_311226_163696) v(n1_311226_160352) v(n1_289034_157008) v(n1_289034_156046) v(n1_311226_157008) v(n1_311226_156046) v(n1_289034_153664) v(n1_289034_150320) v(n1_311226_153664) v(n1_311226_150320) v(n1_289034_146976) v(n1_289034_143632) v(n1_311226_146976) v(n1_311226_143632) v(n1_289034_140288) v(n1_289034_136944) v(n1_311226_140288) v(n1_311226_136944) v(n1_289034_133600) v(n1_289034_133550) v(n1_311226_133600) v(n1_311226_133550) v(n1_289034_130256) v(n1_289034_126912) v(n1_311226_130256) v(n1_311226_126912) v(n1_289034_123568) v(n1_289034_120224) v(n1_311226_123568) v(n1_311226_120224) v(n1_289034_116880) v(n1_289034_113536) v(n1_311226_116880) v(n1_266538_111662) v(n1_311226_113536) v(n1_289034_111662) v(n1_289034_110192) v(n1_311226_111662) v(n1_266538_110192) v(n1_266538_106848) v(n1_244346_110192) v(n1_244346_106848) v(n1_244346_103504) v(n1_221850_106848) v(n1_266538_103504) v(n1_266538_100160) v(n1_289034_100160) v(n1_289034_103504) v(n1_311226_103504) v(n1_289034_106848) v(n1_311226_106848) v(n1_333722_106848) v(n1_311226_110192) v(n1_333722_110192) v(n1_355914_110192) v(n1_333722_111662) v(n1_333722_113536) v(n1_355914_111662) v(n1_355914_113536) v(n1_333722_116880) v(n1_333722_120224) v(n1_355914_116880) v(n1_355914_120224) v(n1_333722_123568) v(n1_333722_126912) v(n1_355914_123568) v(n1_355914_126912) v(n1_333722_130256) v(n1_333722_133550) v(n1_355914_130256) v(n1_355914_133550) v(n1_333722_133600) v(n1_333722_136944) v(n1_355914_133600) v(n1_355914_136944) v(n1_333722_140288) v(n1_333722_143632) v(n1_355914_140288) v(n1_355914_143632) v(n1_333722_146976) v(n1_333722_150320) v(n1_355914_146976) v(n1_355914_150320) v(n1_333722_153664) v(n1_333722_156046) v(n1_355914_153664) v(n1_355914_156046) v(n1_333722_157008) v(n1_333722_160352) v(n1_355914_157008) v(n1_355914_160352) v(n1_333722_163696) v(n1_333722_167040) v(n1_355914_163696) v(n1_355914_167040) v(n1_333722_170384) v(n1_333722_173728) v(n1_355914_170384) v(n1_355914_173728) v(n1_333722_177072) v(n1_333722_177934) v(n1_355914_177072) v(n1_355914_177934) v(n1_333722_180416) v(n1_333722_183760) v(n1_355914_180416) v(n1_355914_183760) v(n1_333722_187104) v(n1_333722_190448) v(n1_355914_187104) v(n1_355914_190448) v(n1_333722_193792) v(n1_333722_197136) v(n1_355914_193792) v(n1_355914_197136) v(n1_333722_200430) v(n1_333722_200480) v(n1_355914_200430) v(n1_355914_200480) v(n1_333722_203824) v(n1_333722_207168) v(n1_355914_203824) v(n1_355914_207168) v(n1_333722_210512) v(n1_333722_213856) v(n1_355914_210512) v(n1_355914_213856) v(n1_333722_217200) v(n1_333722_220544) v(n1_355914_217200) v(n1_355914_220544) v(n1_333722_222318) v(n1_333722_223888) v(n1_355914_222318) v(n1_355914_223888) v(n1_333722_227232) v(n1_333722_230576) v(n1_355914_227232) v(n1_355914_230576) v(n1_333722_233920) v(n1_333722_237264) v(n1_355914_233920) v(n1_355914_237264) v(n1_333722_240608) v(n1_333722_243952) v(n1_355914_240608) v(n1_355914_243952) v(n1_333722_244814) v(n1_333722_247296) v(n1_355914_244814) v(n1_355914_247296) v(n1_333722_250640) v(n1_333722_253984) v(n1_355914_250640) v(n1_355914_253984) v(n1_333722_257328) v(n1_333722_260672) v(n1_355914_257328) v(n1_355914_260672) v(n1_333722_264016) v(n1_333722_266702) v(n1_355914_264016) v(n1_355914_266702) v(n1_333722_267360) v(n1_333722_270704) v(n1_355914_267360) v(n1_355914_270704) v(n1_333722_274048) v(n1_333722_277392) v(n1_355914_274048) v(n1_355914_277392) v(n1_333722_280736) v(n1_333722_284080) v(n1_355914_280736) v(n1_355914_284080) v(n1_333722_287424) v(n1_333722_288590) v(n1_355914_287424) v(n1_355914_288590) v(n1_333722_290768) v(n1_333722_294112) v(n1_355914_290768) v(n1_355914_294112) v(n1_333722_297456) v(n1_333722_300800) v(n1_355914_297456) v(n1_355914_300800) v(n1_333722_304144) v(n1_333722_307488) v(n1_355914_304144) v(n1_355914_307488) v(n1_333722_310832) v(n1_333722_311086) v(n1_355914_310832) v(n1_355914_311086) v(n1_333722_314176) v(n1_333722_317520) v(n1_355914_314176) v(n1_355914_317520) v(n1_333722_320864) v(n1_333722_324208) v(n1_355914_320864) v(n1_355914_324208) v(n1_333722_327552) v(n1_333722_330896) v(n1_355914_327552) v(n1_355914_330896) v(n1_333722_332974) v(n1_333722_334240) v(n1_355914_332974) v(n1_355914_334240) v(n1_333722_337584) v(n1_333722_340928) v(n1_355914_337584) v(n1_355914_340928) v(n1_333722_344272) v(n1_333722_347616) v(n1_355914_344272) v(n1_355914_347616) v(n1_333722_350960) v(n1_333722_354304) v(n1_355914_350960) v(n1_355914_354304) v(n1_333722_355470) v(n1_333722_357648) v(n1_355914_355470) v(n1_355914_357648) v(n1_333722_360992) v(n1_333722_364336) v(n1_355914_360992) v(n1_355914_364336) v(n1_333722_367680) v(n1_333722_371024) v(n1_355914_367680) v(n1_355914_371024) v(n1_333722_374368) v(n1_333722_377358) v(n1_355914_374368) v(n1_355914_377358) v(n1_333722_377712) v(n1_333722_381056) v(n1_355914_377712) v(n1_355914_381056) v(n1_333722_384400) v(n1_333722_387744) v(n1_355914_384400) v(n1_355914_387744) v(n1_333722_391088) v(n1_333722_394432) v(n1_355914_391088) v(n1_355914_394432) v(n1_333722_397776) v(n1_333722_399854) v(n1_355914_397776) v(n1_355914_399854) v(n1_333722_401120) v(n1_333722_404464) v(n1_355914_401120) v(n1_355914_404464) v(n1_333722_407808) v(n1_333722_411152) v(n1_355914_407808) v(n1_355914_411152) v(n1_333722_414496) v(n1_333722_417840) v(n1_355914_414496) v(n1_355914_417840) v(n1_333722_421184) v(n1_333722_421742) v(n1_355914_421184) v(n1_355914_421742) v(n1_333722_424528) v(n1_333722_427872) v(n1_355914_424528) v(n1_355914_427872) v(n1_333722_431216) v(n1_333722_434560) v(n1_355914_431216) v(n1_355914_434560) v(n1_333722_437904) v(n1_333722_441248) v(n1_355914_437904) v(n1_355914_441248) v(n1_333722_444238) v(n1_333722_444592) v(n1_355914_444238) v(n1_355914_444592) v(n1_333722_447936) v(n1_333722_451280) v(n1_355914_447936) v(n1_355914_451280) v(n1_333722_454624) v(n1_333722_457968) v(n1_355914_454624) v(n1_355914_457968) v(n1_333722_461312) v(n1_333722_464656) v(n1_355914_461312) v(n1_355914_464656) v(n1_333722_466126) v(n1_333722_468000) v(n1_355914_466126) v(n1_355914_468000) v(n1_333722_471344) v(n1_333722_474688) v(n1_355914_471344) v(n1_355914_474688) v(n1_333722_478032) v(n1_333722_481376) v(n1_355914_478032) v(n1_355914_481376) v(n1_333722_484720) v(n1_333722_488064) v(n1_355914_484720) v(n1_355914_488064) v(n1_333722_488622) v(n1_333722_491408) v(n1_355914_488622) v(n1_355914_491408) v(n1_333722_494752) v(n1_333722_498096) v(n1_355914_494752) v(n1_355914_498096) v(n1_333722_501440) v(n1_333722_504784) v(n1_355914_501440) v(n1_355914_504784) v(n1_333722_508128) v(n1_333722_510510) v(n1_355914_508128) v(n1_355914_510510) v(n1_333722_511472) v(n1_333722_514816) v(n1_355914_511472) v(n1_355914_514816) v(n1_333722_518160) v(n1_333722_521504) v(n1_355914_518160) v(n1_355914_521504) v(n1_333722_524848) v(n1_333722_528192) v(n1_355914_524848) v(n1_355914_528192) v(n1_333722_531536) v(n1_333722_532398) v(n1_355914_531536) v(n1_355914_532398) v(n1_333722_534880) v(n1_333722_538224) v(n1_355914_534880) v(n1_355914_538224) v(n1_333722_541568) v(n1_333722_544912) v(n1_355914_541568) v(n1_355914_544912) v(n1_333722_548256) v(n1_333722_551600) v(n1_355914_548256) v(n1_355914_551600) v(n1_333722_554894) v(n1_333722_554944) v(n1_355914_554894) v(n1_355914_554944) v(n1_333722_558288) v(n1_333722_561632) v(n1_355914_558288) v(n1_355914_561632) v(n1_333722_564976) v(n1_333722_568320) v(n1_355914_564976) v(n1_355914_568320) v(n1_333722_571664) v(n1_333722_575008) v(n1_355914_571664) v(n1_355914_575008) v(n1_333722_576782) v(n1_333722_578352) v(n1_355914_576782) v(n1_355914_578352) v(n1_333722_581696) v(n1_355914_581696) v(n1_378410_581696) v(n1_400602_581696) v(n1_378410_578352) v(n1_400602_578352) v(n1_422794_581696) v(n1_445290_581696) v(n1_422794_578352) v(n1_445290_578352) v(n1_467482_581696) v(n1_489978_581696) v(n1_467482_578352) v(n1_489978_578352) v(n1_512170_581696) v(n1_534666_581696) v(n1_512170_578352) v(n1_534666_578352) v(n1_556858_581696) v(n1_579050_581696) v(n1_556858_578352) v(n1_579050_578352) v(n1_601546_581696) v(n1_623064_581696) v(n1_601546_578352) v(n1_623064_585040) v(n1_625064_585040) v(n1_627064_585040) v(n1_625064_581696) v(n1_627064_588384) v(n1_625064_578352) v(n1_627064_581696) v(n1_625064_576782) v(n1_627064_578352) v(n1_623064_578352) v(n1_601546_576782) v(n1_601546_575008) v(n1_579050_576782) v(n1_556858_576782) v(n1_579050_575008) v(n1_556858_575008) v(n1_534666_576782) v(n1_512170_576782) v(n1_534666_575008) v(n1_512170_575008) v(n1_489978_576782) v(n1_467482_576782) v(n1_489978_575008) v(n1_467482_575008) v(n1_445290_576782) v(n1_422794_576782) v(n1_445290_575008) v(n1_422794_575008) v(n1_400602_576782) v(n1_378410_576782) v(n1_400602_575008) v(n1_378410_575008) v(n1_378410_571664) v(n1_378410_568320) v(n1_400602_571664) v(n1_400602_568320) v(n1_378410_564976) v(n1_378410_561632) v(n1_400602_564976) v(n1_400602_561632) v(n1_378410_558288) v(n1_378410_554944) v(n1_400602_558288) v(n1_400602_554944) v(n1_378410_554894) v(n1_378410_551600) v(n1_400602_554894) v(n1_400602_551600) v(n1_378410_548256) v(n1_378410_544912) v(n1_400602_548256) v(n1_400602_544912) v(n1_378410_541568) v(n1_378410_538224) v(n1_400602_541568) v(n1_400602_538224) v(n1_378410_534880) v(n1_378410_532398) v(n1_400602_534880) v(n1_400602_532398) v(n1_378410_531536) v(n1_378410_528192) v(n1_400602_531536) v(n1_400602_528192) v(n1_378410_524848) v(n1_378410_521504) v(n1_400602_524848) v(n1_400602_521504) v(n1_378410_518160) v(n1_378410_514816) v(n1_400602_518160) v(n1_400602_514816) v(n1_378410_511472) v(n1_378410_510510) v(n1_400602_511472) v(n1_400602_510510) v(n1_378410_508128) v(n1_378410_504784) v(n1_400602_508128) v(n1_400602_504784) v(n1_378410_501440) v(n1_378410_498096) v(n1_400602_501440) v(n1_400602_498096) v(n1_378410_494752) v(n1_378410_491408) v(n1_400602_494752) v(n1_400602_491408) v(n1_378410_488622) v(n1_378410_488064) v(n1_400602_488622) v(n1_400602_488064) v(n1_378410_484720) v(n1_378410_481376) v(n1_400602_484720) v(n1_400602_481376) v(n1_378410_478032) v(n1_378410_474688) v(n1_400602_478032) v(n1_400602_474688) v(n1_378410_471344) v(n1_378410_468000) v(n1_400602_471344) v(n1_400602_468000) v(n1_378410_466126) v(n1_378410_464656) v(n1_400602_466126) v(n1_400602_464656) v(n1_378410_461312) v(n1_378410_457968) v(n1_400602_461312) v(n1_400602_457968) v(n1_378410_454624) v(n1_378410_451280) v(n1_400602_454624) v(n1_400602_451280) v(n1_378410_447936) v(n1_378410_444592) v(n1_400602_447936) v(n1_400602_444592) v(n1_378410_444238) v(n1_378410_441248) v(n1_400602_444238) v(n1_400602_441248) v(n1_378410_437904) v(n1_378410_434560) v(n1_400602_437904) v(n1_400602_434560) v(n1_378410_431216) v(n1_378410_427872) v(n1_400602_431216) v(n1_400602_427872) v(n1_378410_424528) v(n1_378410_421742) v(n1_400602_424528) v(n1_400602_421742) v(n1_378410_421184) v(n1_378410_417840) v(n1_400602_421184) v(n1_400602_417840) v(n1_378410_414496) v(n1_378410_411152) v(n1_400602_414496) v(n1_400602_411152) v(n1_378410_407808) v(n1_378410_404464) v(n1_400602_407808) v(n1_400602_404464) v(n1_378410_401120) v(n1_378410_399854) v(n1_400602_401120) v(n1_400602_399854) v(n1_378410_397776) v(n1_378410_394432) v(n1_400602_397776) v(n1_400602_394432) v(n1_378410_391088) v(n1_378410_387744) v(n1_400602_391088) v(n1_400602_387744) v(n1_378410_384400) v(n1_378410_381056) v(n1_400602_384400) v(n1_400602_381056) v(n1_378410_377712) v(n1_378410_377358) v(n1_400602_377712) v(n1_400602_377358) v(n1_378410_374368) v(n1_378410_371024) v(n1_400602_374368) v(n1_400602_371024) v(n1_378410_367680) v(n1_378410_364336) v(n1_400602_367680) v(n1_400602_364336) v(n1_378410_360992) v(n1_378410_357648) v(n1_400602_360992) v(n1_400602_357648) v(n1_378410_355470) v(n1_378410_354304) v(n1_400602_355470) v(n1_400602_354304) v(n1_378410_350960) v(n1_378410_347616) v(n1_400602_350960) v(n1_400602_347616) v(n1_378410_344272) v(n1_378410_340928) v(n1_400602_344272) v(n1_400602_340928) v(n1_378410_337584) v(n1_378410_334240) v(n1_400602_337584) v(n1_400602_334240) v(n1_378410_332974) v(n1_378410_330896) v(n1_400602_332974) v(n1_400602_330896) v(n1_378410_327552) v(n1_378410_324208) v(n1_400602_327552) v(n1_400602_324208) v(n1_378410_320864) v(n1_378410_317520) v(n1_400602_320864) v(n1_400602_317520) v(n1_378410_314176) v(n1_378410_311086) v(n1_400602_314176) v(n1_400602_311086) v(n1_378410_310832) v(n1_378410_307488) v(n1_400602_310832) v(n1_400602_307488) v(n1_378410_304144) v(n1_378410_300800) v(n1_400602_304144) v(n1_400602_300800) v(n1_378410_297456) v(n1_378410_294112) v(n1_400602_297456) v(n1_400602_294112) v(n1_378410_290768) v(n1_378410_288590) v(n1_400602_290768) v(n1_400602_288590) v(n1_378410_287424) v(n1_378410_284080) v(n1_400602_287424) v(n1_400602_284080) v(n1_378410_280736) v(n1_378410_277392) v(n1_400602_280736) v(n1_400602_277392) v(n1_378410_274048) v(n1_378410_270704) v(n1_400602_274048) v(n1_400602_270704) v(n1_378410_267360) v(n1_378410_266702) v(n1_400602_267360) v(n1_400602_266702) v(n1_378410_264016) v(n1_378410_260672) v(n1_400602_264016) v(n1_400602_260672) v(n1_378410_257328) v(n1_378410_253984) v(n1_400602_257328) v(n1_400602_253984) v(n1_378410_250640) v(n1_378410_247296) v(n1_400602_250640) v(n1_400602_247296) v(n1_378410_244814) v(n1_378410_243952) v(n1_400602_244814) v(n1_400602_243952) v(n1_378410_240608) v(n1_378410_237264) v(n1_400602_240608) v(n1_400602_237264) v(n1_378410_233920) v(n1_378410_230576) v(n1_400602_233920) v(n1_400602_230576) v(n1_378410_227232) v(n1_378410_223888) v(n1_400602_227232) v(n1_400602_223888) v(n1_378410_222318) v(n1_378410_220544) v(n1_400602_222318) v(n1_400602_220544) v(n1_378410_217200) v(n1_378410_213856) v(n1_400602_217200) v(n1_400602_213856) v(n1_378410_210512) v(n1_378410_207168) v(n1_400602_210512) v(n1_400602_207168) v(n1_378410_203824) v(n1_378410_200480) v(n1_400602_203824) v(n1_400602_200480) v(n1_378410_200430) v(n1_378410_197136) v(n1_400602_200430) v(n1_400602_197136) v(n1_378410_193792) v(n1_378410_190448) v(n1_400602_193792) v(n1_400602_190448) v(n1_378410_187104) v(n1_378410_183760) v(n1_400602_187104) v(n1_400602_183760) v(n1_378410_180416) v(n1_378410_177934) v(n1_400602_180416) v(n1_400602_177934) v(n1_378410_177072) v(n1_378410_173728) v(n1_400602_177072) v(n1_400602_173728) v(n1_378410_170384) v(n1_378410_167040) v(n1_400602_170384) v(n1_400602_167040) v(n1_378410_163696) v(n1_378410_160352) v(n1_400602_163696) v(n1_400602_160352) v(n1_378410_157008) v(n1_378410_156046) v(n1_400602_157008) v(n1_400602_156046) v(n1_378410_153664) v(n1_378410_150320) v(n1_400602_153664) v(n1_400602_150320) v(n1_378410_146976) v(n1_378410_143632) v(n1_400602_146976) v(n1_400602_143632) v(n1_378410_140288) v(n1_378410_136944) v(n1_400602_140288) v(n1_400602_136944) v(n1_378410_133600) v(n1_378410_133550) v(n1_400602_133600) v(n1_400602_133550) v(n1_378410_130256) v(n1_378410_126912) v(n1_400602_130256) v(n1_400602_126912) v(n1_378410_123568) v(n1_378410_120224) v(n1_400602_123568) v(n1_400602_120224) v(n1_378410_116880) v(n1_378410_113536) v(n1_400602_116880) v(n1_400602_113536) v(n1_378410_111662) v(n1_378410_110192) v(n1_400602_111662) v(n1_355914_106848) v(n1_400602_110192) v(n1_378410_106848) v(n1_378410_103504) v(n1_400602_106848) v(n1_355914_103504) v(n1_355914_100160) v(n1_333722_103504) v(n1_333722_100160) v(n1_333722_96816) v(n1_311226_100160) v(n1_311226_96816) v(n1_311226_93472) v(n1_289034_96816) v(n1_333722_93472) v(n1_333722_90128) v(n1_355914_90128) v(n1_355914_93472) v(n1_378410_93472) v(n1_355914_96816) v(n1_378410_96816) v(n1_400602_96816) v(n1_378410_100160) v(n1_400602_100160) v(n1_422794_100160) v(n1_400602_103504) v(n1_422794_103504) v(n1_445290_103504) v(n1_422794_106848) v(n1_422794_110192) v(n1_445290_106848) v(n1_445290_110192) v(n1_422794_111662) v(n1_422794_113536) v(n1_445290_111662) v(n1_445290_113536) v(n1_422794_116880) v(n1_422794_120224) v(n1_445290_116880) v(n1_445290_120224) v(n1_422794_123568) v(n1_422794_126912) v(n1_445290_123568) v(n1_445290_126912) v(n1_422794_130256) v(n1_422794_133550) v(n1_445290_130256) v(n1_445290_133550) v(n1_422794_133600) v(n1_422794_136944) v(n1_445290_133600) v(n1_445290_136944) v(n1_422794_140288) v(n1_422794_143632) v(n1_445290_140288) v(n1_445290_143632) v(n1_422794_146976) v(n1_422794_150320) v(n1_445290_146976) v(n1_445290_150320) v(n1_422794_153664) v(n1_422794_156046) v(n1_445290_153664) v(n1_445290_156046) v(n1_422794_157008) v(n1_422794_160352) v(n1_445290_157008) v(n1_445290_160352) v(n1_422794_163696) v(n1_422794_167040) v(n1_445290_163696) v(n1_445290_167040) v(n1_422794_170384) v(n1_422794_173728) v(n1_445290_170384) v(n1_445290_173728) v(n1_422794_177072) v(n1_422794_177934) v(n1_445290_177072) v(n1_445290_177934) v(n1_422794_180416) v(n1_422794_183760) v(n1_445290_180416) v(n1_445290_183760) v(n1_422794_187104) v(n1_422794_190448) v(n1_445290_187104) v(n1_445290_190448) v(n1_422794_193792) v(n1_422794_197136) v(n1_445290_193792) v(n1_445290_197136) v(n1_422794_200430) v(n1_422794_200480) v(n1_445290_200430) v(n1_445290_200480) v(n1_422794_203824) v(n1_422794_207168) v(n1_445290_203824) v(n1_445290_207168) v(n1_422794_210512) v(n1_422794_213856) v(n1_445290_210512) v(n1_445290_213856) v(n1_422794_217200) v(n1_422794_220544) v(n1_445290_217200) v(n1_445290_220544) v(n1_422794_222318) v(n1_422794_223888) v(n1_445290_222318) v(n1_445290_223888) v(n1_422794_227232) v(n1_422794_230576) v(n1_445290_227232) v(n1_445290_230576) v(n1_422794_233920) v(n1_422794_237264) v(n1_445290_233920) v(n1_445290_237264) v(n1_422794_240608) v(n1_422794_243952) v(n1_445290_240608) v(n1_445290_243952) v(n1_422794_244814) v(n1_422794_247296) v(n1_445290_244814) v(n1_445290_247296) v(n1_422794_250640) v(n1_422794_253984) v(n1_445290_250640) v(n1_445290_253984) v(n1_422794_257328) v(n1_422794_260672) v(n1_445290_257328) v(n1_445290_260672) v(n1_422794_264016) v(n1_422794_266702) v(n1_445290_264016) v(n1_445290_266702) v(n1_422794_267360) v(n1_422794_270704) v(n1_445290_267360) v(n1_445290_270704) v(n1_422794_274048) v(n1_422794_277392) v(n1_445290_274048) v(n1_445290_277392) v(n1_422794_280736) v(n1_422794_284080) v(n1_445290_280736) v(n1_445290_284080) v(n1_422794_287424) v(n1_422794_288590) v(n1_445290_287424) v(n1_445290_288590) v(n1_422794_290768) v(n1_422794_294112) v(n1_445290_290768) v(n1_445290_294112) v(n1_422794_297456) v(n1_422794_300800) v(n1_445290_297456) v(n1_445290_300800) v(n1_422794_304144) v(n1_422794_307488) v(n1_445290_304144) v(n1_445290_307488) v(n1_422794_310832) v(n1_422794_311086) v(n1_445290_310832) v(n1_445290_311086) v(n1_422794_314176) v(n1_422794_317520) v(n1_445290_314176) v(n1_445290_317520) v(n1_422794_320864) v(n1_422794_324208) v(n1_445290_320864) v(n1_445290_324208) v(n1_422794_327552) v(n1_422794_330896) v(n1_445290_327552) v(n1_445290_330896) v(n1_422794_332974) v(n1_422794_334240) v(n1_445290_332974) v(n1_445290_334240) v(n1_422794_337584) v(n1_422794_340928) v(n1_445290_337584) v(n1_445290_340928) v(n1_422794_344272) v(n1_422794_347616) v(n1_445290_344272) v(n1_445290_347616) v(n1_422794_350960) v(n1_422794_354304) v(n1_445290_350960) v(n1_445290_354304) v(n1_422794_355470) v(n1_422794_357648) v(n1_445290_355470) v(n1_445290_357648) v(n1_422794_360992) v(n1_422794_364336) v(n1_445290_360992) v(n1_445290_364336) v(n1_422794_367680) v(n1_422794_371024) v(n1_445290_367680) v(n1_445290_371024) v(n1_422794_374368) v(n1_422794_377358) v(n1_445290_374368) v(n1_445290_377358) v(n1_422794_377712) v(n1_422794_381056) v(n1_445290_377712) v(n1_445290_381056) v(n1_422794_384400) v(n1_422794_387744) v(n1_445290_384400) v(n1_445290_387744) v(n1_422794_391088) v(n1_422794_394432) v(n1_445290_391088) v(n1_445290_394432) v(n1_422794_397776) v(n1_422794_399854) v(n1_445290_397776) v(n1_445290_399854) v(n1_422794_401120) v(n1_422794_404464) v(n1_445290_401120) v(n1_445290_404464) v(n1_422794_407808) v(n1_422794_411152) v(n1_445290_407808) v(n1_445290_411152) v(n1_422794_414496) v(n1_422794_417840) v(n1_445290_414496) v(n1_445290_417840) v(n1_422794_421184) v(n1_422794_421742) v(n1_445290_421184) v(n1_445290_421742) v(n1_422794_424528) v(n1_422794_427872) v(n1_445290_424528) v(n1_445290_427872) v(n1_422794_431216) v(n1_422794_434560) v(n1_445290_431216) v(n1_445290_434560) v(n1_422794_437904) v(n1_422794_441248) v(n1_445290_437904) v(n1_445290_441248) v(n1_422794_444238) v(n1_422794_444592) v(n1_445290_444238) v(n1_445290_444592) v(n1_422794_447936) v(n1_422794_451280) v(n1_445290_447936) v(n1_445290_451280) v(n1_422794_454624) v(n1_422794_457968) v(n1_445290_454624) v(n1_445290_457968) v(n1_422794_461312) v(n1_422794_464656) v(n1_445290_461312) v(n1_445290_464656) v(n1_422794_466126) v(n1_422794_468000) v(n1_445290_466126) v(n1_445290_468000) v(n1_422794_471344) v(n1_422794_474688) v(n1_445290_471344) v(n1_445290_474688) v(n1_422794_478032) v(n1_422794_481376) v(n1_445290_478032) v(n1_445290_481376) v(n1_422794_484720) v(n1_422794_488064) v(n1_445290_484720) v(n1_445290_488064) v(n1_422794_488622) v(n1_422794_491408) v(n1_445290_488622) v(n1_445290_491408) v(n1_422794_494752) v(n1_422794_498096) v(n1_445290_494752) v(n1_445290_498096) v(n1_422794_501440) v(n1_422794_504784) v(n1_445290_501440) v(n1_445290_504784) v(n1_422794_508128) v(n1_422794_510510) v(n1_445290_508128) v(n1_445290_510510) v(n1_422794_511472) v(n1_422794_514816) v(n1_445290_511472) v(n1_445290_514816) v(n1_422794_518160) v(n1_422794_521504) v(n1_445290_518160) v(n1_445290_521504) v(n1_422794_524848) v(n1_422794_528192) v(n1_445290_524848) v(n1_445290_528192) v(n1_422794_531536) v(n1_422794_532398) v(n1_445290_531536) v(n1_445290_532398) v(n1_422794_534880) v(n1_422794_538224) v(n1_445290_534880) v(n1_445290_538224) v(n1_422794_541568) v(n1_422794_544912) v(n1_445290_541568) v(n1_445290_544912) v(n1_422794_548256) v(n1_422794_551600) v(n1_445290_548256) v(n1_445290_551600) v(n1_422794_554894) v(n1_422794_554944) v(n1_445290_554894) v(n1_445290_554944) v(n1_422794_558288) v(n1_422794_561632) v(n1_445290_558288) v(n1_445290_561632) v(n1_422794_564976) v(n1_422794_568320) v(n1_445290_564976) v(n1_445290_568320) v(n1_422794_571664) v(n1_445290_571664) v(n1_467482_571664) v(n1_489978_571664) v(n1_467482_568320) v(n1_489978_568320) v(n1_512170_571664) v(n1_534666_571664) v(n1_512170_568320) v(n1_534666_568320) v(n1_556858_571664) v(n1_579050_571664) v(n1_556858_568320) v(n1_579050_568320) v(n1_601546_571664) v(n1_623064_571664) v(n1_601546_568320) v(n1_623064_575008) v(n1_625064_575008) v(n1_627064_575008) v(n1_625064_571664) v(n1_627064_576782) v(n1_625064_568320) v(n1_627064_571664) v(n1_625064_564976) v(n1_627064_568320) v(n1_623064_568320) v(n1_601546_564976) v(n1_601546_561632) v(n1_623064_564976) v(n1_579050_564976) v(n1_556858_564976) v(n1_579050_561632) v(n1_556858_561632) v(n1_534666_564976) v(n1_512170_564976) v(n1_534666_561632) v(n1_512170_561632) v(n1_489978_564976) v(n1_467482_564976) v(n1_489978_561632) v(n1_467482_561632) v(n1_467482_558288) v(n1_467482_554944) v(n1_489978_558288) v(n1_489978_554944) v(n1_467482_554894) v(n1_467482_551600) v(n1_489978_554894) v(n1_489978_551600) v(n1_467482_548256) v(n1_467482_544912) v(n1_489978_548256) v(n1_489978_544912) v(n1_467482_541568) v(n1_467482_538224) v(n1_489978_541568) v(n1_489978_538224) v(n1_467482_534880) v(n1_467482_532398) v(n1_489978_534880) v(n1_489978_532398) v(n1_467482_531536) v(n1_467482_528192) v(n1_489978_531536) v(n1_489978_528192) v(n1_467482_524848) v(n1_467482_521504) v(n1_489978_524848) v(n1_489978_521504) v(n1_467482_518160) v(n1_467482_514816) v(n1_489978_518160) v(n1_489978_514816) v(n1_467482_511472) v(n1_467482_510510) v(n1_489978_511472) v(n1_489978_510510) v(n1_467482_508128) v(n1_467482_504784) v(n1_489978_508128) v(n1_489978_504784) v(n1_467482_501440) v(n1_467482_498096) v(n1_489978_501440) v(n1_489978_498096) v(n1_467482_494752) v(n1_467482_491408) v(n1_489978_494752) v(n1_489978_491408) v(n1_467482_488622) v(n1_467482_488064) v(n1_489978_488622) v(n1_489978_488064) v(n1_467482_484720) v(n1_467482_481376) v(n1_489978_484720) v(n1_489978_481376) v(n1_467482_478032) v(n1_467482_474688) v(n1_489978_478032) v(n1_489978_474688) v(n1_467482_471344) v(n1_467482_468000) v(n1_489978_471344) v(n1_489978_468000) v(n1_467482_466126) v(n1_467482_464656) v(n1_489978_466126) v(n1_489978_464656) v(n1_467482_461312) v(n1_467482_457968) v(n1_489978_461312) v(n1_489978_457968) v(n1_467482_454624) v(n1_467482_451280) v(n1_489978_454624) v(n1_489978_451280) v(n1_467482_447936) v(n1_467482_444592) v(n1_489978_447936) v(n1_489978_444592) v(n1_467482_444238) v(n1_467482_441248) v(n1_489978_444238) v(n1_489978_441248) v(n1_467482_437904) v(n1_467482_434560) v(n1_489978_437904) v(n1_489978_434560) v(n1_467482_431216) v(n1_467482_427872) v(n1_489978_431216) v(n1_489978_427872) v(n1_467482_424528) v(n1_467482_421742) v(n1_489978_424528) v(n1_489978_421742) v(n1_467482_421184) v(n1_467482_417840) v(n1_489978_421184) v(n1_489978_417840) v(n1_467482_414496) v(n1_467482_411152) v(n1_489978_414496) v(n1_489978_411152) v(n1_467482_407808) v(n1_467482_404464) v(n1_489978_407808) v(n1_489978_404464) v(n1_467482_401120) v(n1_467482_399854) v(n1_489978_401120) v(n1_489978_399854) v(n1_467482_397776) v(n1_467482_394432) v(n1_489978_397776) v(n1_489978_394432) v(n1_467482_391088) v(n1_467482_387744) v(n1_489978_391088) v(n1_489978_387744) v(n1_467482_384400) v(n1_467482_381056) v(n1_489978_384400) v(n1_489978_381056) v(n1_467482_377712) v(n1_467482_377358) v(n1_489978_377712) v(n1_489978_377358) v(n1_467482_374368) v(n1_467482_371024) v(n1_489978_374368) v(n1_489978_371024) v(n1_467482_367680) v(n1_467482_364336) v(n1_489978_367680) v(n1_489978_364336) v(n1_467482_360992) v(n1_467482_357648) v(n1_489978_360992) v(n1_489978_357648) v(n1_467482_355470) v(n1_467482_354304) v(n1_489978_355470) v(n1_489978_354304) v(n1_467482_350960) v(n1_467482_347616) v(n1_489978_350960) v(n1_489978_347616) v(n1_467482_344272) v(n1_467482_340928) v(n1_489978_344272) v(n1_489978_340928) v(n1_467482_337584) v(n1_467482_334240) v(n1_489978_337584) v(n1_489978_334240) v(n1_467482_332974) v(n1_467482_330896) v(n1_489978_332974) v(n1_489978_330896) v(n1_467482_327552) v(n1_467482_324208) v(n1_489978_327552) v(n1_489978_324208) v(n1_467482_320864) v(n1_467482_317520) v(n1_489978_320864) v(n1_489978_317520) v(n1_467482_314176) v(n1_467482_311086) v(n1_489978_314176) v(n1_489978_311086) v(n1_467482_310832) v(n1_467482_307488) v(n1_489978_310832) v(n1_489978_307488) v(n1_467482_304144) v(n1_467482_300800) v(n1_489978_304144) v(n1_489978_300800) v(n1_467482_297456) v(n1_467482_294112) v(n1_489978_297456) v(n1_489978_294112) v(n1_467482_290768) v(n1_467482_288590) v(n1_489978_290768) v(n1_489978_288590) v(n1_467482_287424) v(n1_467482_284080) v(n1_489978_287424) v(n1_489978_284080) v(n1_467482_280736) v(n1_467482_277392) v(n1_489978_280736) v(n1_489978_277392) v(n1_467482_274048) v(n1_467482_270704) v(n1_489978_274048) v(n1_489978_270704) v(n1_467482_267360) v(n1_467482_266702) v(n1_489978_267360) v(n1_489978_266702) v(n1_467482_264016) v(n1_467482_260672) v(n1_489978_264016) v(n1_489978_260672) v(n1_467482_257328) v(n1_467482_253984) v(n1_489978_257328) v(n1_489978_253984) v(n1_467482_250640) v(n1_467482_247296) v(n1_489978_250640) v(n1_489978_247296) v(n1_467482_244814) v(n1_467482_243952) v(n1_489978_244814) v(n1_489978_243952) v(n1_467482_240608) v(n1_467482_237264) v(n1_489978_240608) v(n1_489978_237264) v(n1_467482_233920) v(n1_467482_230576) v(n1_489978_233920) v(n1_489978_230576) v(n1_467482_227232) v(n1_467482_223888) v(n1_489978_227232) v(n1_489978_223888) v(n1_467482_222318) v(n1_467482_220544) v(n1_489978_222318) v(n1_489978_220544) v(n1_467482_217200) v(n1_467482_213856) v(n1_489978_217200) v(n1_489978_213856) v(n1_467482_210512) v(n1_467482_207168) v(n1_489978_210512) v(n1_489978_207168) v(n1_467482_203824) v(n1_467482_200480) v(n1_489978_203824) v(n1_489978_200480) v(n1_467482_200430) v(n1_467482_197136) v(n1_489978_200430) v(n1_489978_197136) v(n1_467482_193792) v(n1_467482_190448) v(n1_489978_193792) v(n1_489978_190448) v(n1_467482_187104) v(n1_467482_183760) v(n1_489978_187104) v(n1_489978_183760) v(n1_467482_180416) v(n1_467482_177934) v(n1_489978_180416) v(n1_489978_177934) v(n1_467482_177072) v(n1_467482_173728) v(n1_489978_177072) v(n1_489978_173728) v(n1_467482_170384) v(n1_467482_167040) v(n1_489978_170384) v(n1_489978_167040) v(n1_467482_163696) v(n1_467482_160352) v(n1_489978_163696) v(n1_489978_160352) v(n1_467482_157008) v(n1_467482_156046) v(n1_489978_157008) v(n1_489978_156046) v(n1_467482_153664) v(n1_467482_150320) v(n1_489978_153664) v(n1_489978_150320) v(n1_467482_146976) v(n1_467482_143632) v(n1_489978_146976) v(n1_489978_143632) v(n1_467482_140288) v(n1_467482_136944) v(n1_489978_140288) v(n1_489978_136944) v(n1_467482_133600) v(n1_467482_133550) v(n1_489978_133600) v(n1_489978_133550) v(n1_467482_130256) v(n1_467482_126912) v(n1_489978_130256) v(n1_489978_126912) v(n1_467482_123568) v(n1_467482_120224) v(n1_489978_123568) v(n1_489978_120224) v(n1_467482_116880) v(n1_467482_113536) v(n1_489978_116880) v(n1_489978_113536) v(n1_467482_111662) v(n1_467482_110192) v(n1_489978_111662) v(n1_489978_110192) v(n1_467482_106848) v(n1_467482_103504) v(n1_489978_106848) v(n1_445290_100160) v(n1_489978_103504) v(n1_467482_100160) v(n1_467482_96816) v(n1_489978_100160) v(n1_445290_96816) v(n1_445290_93472) v(n1_422794_96816) v(n1_422794_93472) v(n1_422794_90128) v(n1_400602_93472) v(n1_400602_90128) v(n1_400602_89166) v(n1_378410_90128) v(n1_378410_89166) v(n1_378410_86784) v(n1_355914_89166) v(n1_400602_86784) v(n1_400602_83440) v(n1_422794_83440) v(n1_422794_86784) v(n1_445290_86784) v(n1_422794_89166) v(n1_445290_89166) v(n1_467482_89166) v(n1_445290_90128) v(n1_467482_90128) v(n1_489978_90128) v(n1_467482_93472) v(n1_489978_93472) v(n1_512170_93472) v(n1_489978_96816) v(n1_512170_96816) v(n1_534666_96816) v(n1_512170_100160) v(n1_512170_103504) v(n1_534666_100160) v(n1_534666_103504) v(n1_512170_106848) v(n1_512170_110192) v(n1_534666_106848) v(n1_534666_110192) v(n1_512170_111662) v(n1_512170_113536) v(n1_534666_111662) v(n1_534666_113536) v(n1_512170_116880) v(n1_512170_120224) v(n1_534666_116880) v(n1_534666_120224) v(n1_512170_123568) v(n1_512170_126912) v(n1_534666_123568) v(n1_534666_126912) v(n1_512170_130256) v(n1_512170_133550) v(n1_534666_130256) v(n1_534666_133550) v(n1_512170_133600) v(n1_512170_136944) v(n1_534666_133600) v(n1_534666_136944) v(n1_512170_140288) v(n1_512170_143632) v(n1_534666_140288) v(n1_534666_143632) v(n1_512170_146976) v(n1_512170_150320) v(n1_534666_146976) v(n1_534666_150320) v(n1_512170_153664) v(n1_512170_156046) v(n1_534666_153664) v(n1_534666_156046) v(n1_512170_157008) v(n1_512170_160352) v(n1_534666_157008) v(n1_534666_160352) v(n1_512170_163696) v(n1_512170_167040) v(n1_534666_163696) v(n1_534666_167040) v(n1_512170_170384) v(n1_512170_173728) v(n1_534666_170384) v(n1_534666_173728) v(n1_512170_177072) v(n1_512170_177934) v(n1_534666_177072) v(n1_534666_177934) v(n1_512170_180416) v(n1_512170_183760) v(n1_534666_180416) v(n1_534666_183760) v(n1_512170_187104) v(n1_512170_190448) v(n1_534666_187104) v(n1_534666_190448) v(n1_512170_193792) v(n1_512170_197136) v(n1_534666_193792) v(n1_534666_197136) v(n1_512170_200430) v(n1_512170_200480) v(n1_534666_200430) v(n1_534666_200480) v(n1_512170_203824) v(n1_512170_207168) v(n1_534666_203824) v(n1_534666_207168) v(n1_512170_210512) v(n1_512170_213856) v(n1_534666_210512) v(n1_534666_213856) v(n1_512170_217200) v(n1_512170_220544) v(n1_534666_217200) v(n1_534666_220544) v(n1_512170_222318) v(n1_512170_223888) v(n1_534666_222318) v(n1_534666_223888) v(n1_512170_227232) v(n1_512170_230576) v(n1_534666_227232) v(n1_534666_230576) v(n1_512170_233920) v(n1_512170_237264) v(n1_534666_233920) v(n1_534666_237264) v(n1_512170_240608) v(n1_512170_243952) v(n1_534666_240608) v(n1_534666_243952) v(n1_512170_244814) v(n1_512170_247296) v(n1_534666_244814) v(n1_534666_247296) v(n1_512170_250640) v(n1_512170_253984) v(n1_534666_250640) v(n1_534666_253984) v(n1_512170_257328) v(n1_512170_260672) v(n1_534666_257328) v(n1_534666_260672) v(n1_512170_264016) v(n1_512170_266702) v(n1_534666_264016) v(n1_534666_266702) v(n1_512170_267360) v(n1_512170_270704) v(n1_534666_267360) v(n1_534666_270704) v(n1_512170_274048) v(n1_512170_277392) v(n1_534666_274048) v(n1_534666_277392) v(n1_512170_280736) v(n1_512170_284080) v(n1_534666_280736) v(n1_534666_284080) v(n1_512170_287424) v(n1_512170_288590) v(n1_534666_287424) v(n1_534666_288590) v(n1_512170_290768) v(n1_512170_294112) v(n1_534666_290768) v(n1_534666_294112) v(n1_512170_297456) v(n1_512170_300800) v(n1_534666_297456) v(n1_534666_300800) v(n1_512170_304144) v(n1_512170_307488) v(n1_534666_304144) v(n1_534666_307488) v(n1_512170_310832) v(n1_512170_311086) v(n1_534666_310832) v(n1_534666_311086) v(n1_512170_314176) v(n1_512170_317520) v(n1_534666_314176) v(n1_534666_317520) v(n1_512170_320864) v(n1_512170_324208) v(n1_534666_320864) v(n1_534666_324208) v(n1_512170_327552) v(n1_512170_330896) v(n1_534666_327552) v(n1_534666_330896) v(n1_512170_332974) v(n1_512170_334240) v(n1_534666_332974) v(n1_534666_334240) v(n1_512170_337584) v(n1_512170_340928) v(n1_534666_337584) v(n1_534666_340928) v(n1_512170_344272) v(n1_512170_347616) v(n1_534666_344272) v(n1_534666_347616) v(n1_512170_350960) v(n1_512170_354304) v(n1_534666_350960) v(n1_534666_354304) v(n1_512170_355470) v(n1_512170_357648) v(n1_534666_355470) v(n1_534666_357648) v(n1_512170_360992) v(n1_512170_364336) v(n1_534666_360992) v(n1_534666_364336) v(n1_512170_367680) v(n1_512170_371024) v(n1_534666_367680) v(n1_534666_371024) v(n1_512170_374368) v(n1_512170_377358) v(n1_534666_374368) v(n1_534666_377358) v(n1_512170_377712) v(n1_512170_381056) v(n1_534666_377712) v(n1_534666_381056) v(n1_512170_384400) v(n1_512170_387744) v(n1_534666_384400) v(n1_534666_387744) v(n1_512170_391088) v(n1_512170_394432) v(n1_534666_391088) v(n1_534666_394432) v(n1_512170_397776) v(n1_512170_399854) v(n1_534666_397776) v(n1_534666_399854) v(n1_512170_401120) v(n1_512170_404464) v(n1_534666_401120) v(n1_534666_404464) v(n1_512170_407808) v(n1_512170_411152) v(n1_534666_407808) v(n1_534666_411152) v(n1_512170_414496) v(n1_512170_417840) v(n1_534666_414496) v(n1_534666_417840) v(n1_512170_421184) v(n1_512170_421742) v(n1_534666_421184) v(n1_534666_421742) v(n1_512170_424528) v(n1_512170_427872) v(n1_534666_424528) v(n1_534666_427872) v(n1_512170_431216) v(n1_512170_434560) v(n1_534666_431216) v(n1_534666_434560) v(n1_512170_437904) v(n1_512170_441248) v(n1_534666_437904) v(n1_534666_441248) v(n1_512170_444238) v(n1_512170_444592) v(n1_534666_444238) v(n1_534666_444592) v(n1_512170_447936) v(n1_512170_451280) v(n1_534666_447936) v(n1_534666_451280) v(n1_512170_454624) v(n1_512170_457968) v(n1_534666_454624) v(n1_534666_457968) v(n1_512170_461312) v(n1_512170_464656) v(n1_534666_461312) v(n1_534666_464656) v(n1_512170_466126) v(n1_512170_468000) v(n1_534666_466126) v(n1_534666_468000) v(n1_512170_471344) v(n1_512170_474688) v(n1_534666_471344) v(n1_534666_474688) v(n1_512170_478032) v(n1_512170_481376) v(n1_534666_478032) v(n1_534666_481376) v(n1_512170_484720) v(n1_512170_488064) v(n1_534666_484720) v(n1_534666_488064) v(n1_512170_488622) v(n1_512170_491408) v(n1_534666_488622) v(n1_534666_491408) v(n1_512170_494752) v(n1_512170_498096) v(n1_534666_494752) v(n1_534666_498096) v(n1_512170_501440) v(n1_512170_504784) v(n1_534666_501440) v(n1_534666_504784) v(n1_512170_508128) v(n1_512170_510510) v(n1_534666_508128) v(n1_534666_510510) v(n1_512170_511472) v(n1_512170_514816) v(n1_534666_511472) v(n1_534666_514816) v(n1_512170_518160) v(n1_512170_521504) v(n1_534666_518160) v(n1_534666_521504) v(n1_512170_524848) v(n1_512170_528192) v(n1_534666_524848) v(n1_534666_528192) v(n1_512170_531536) v(n1_512170_532398) v(n1_534666_531536) v(n1_534666_532398) v(n1_512170_534880) v(n1_512170_538224) v(n1_534666_534880) v(n1_534666_538224) v(n1_512170_541568) v(n1_512170_544912) v(n1_534666_541568) v(n1_534666_544912) v(n1_512170_548256) v(n1_512170_551600) v(n1_534666_548256) v(n1_534666_551600) v(n1_512170_554894) v(n1_512170_554944) v(n1_534666_554894) v(n1_534666_554944) v(n1_512170_558288) v(n1_534666_558288) v(n1_556858_558288) v(n1_579050_558288) v(n1_556858_554944) v(n1_579050_554944) v(n1_601546_558288) v(n1_623064_558288) v(n1_601546_554944) v(n1_623064_561632) v(n1_625064_561632) v(n1_627064_561632) v(n1_625064_558288) v(n1_627064_564976) v(n1_625064_554944) v(n1_627064_558288) v(n1_625064_554894) v(n1_627064_554944) v(n1_623064_554944) v(n1_601546_554894) v(n1_601546_551600) v(n1_579050_554894) v(n1_556858_554894) v(n1_579050_551600) v(n1_556858_551600) v(n1_556858_548256) v(n1_556858_544912) v(n1_579050_548256) v(n1_579050_544912) v(n1_556858_541568) v(n1_556858_538224) v(n1_579050_541568) v(n1_579050_538224) v(n1_556858_534880) v(n1_556858_532398) v(n1_579050_534880) v(n1_579050_532398) v(n1_556858_531536) v(n1_556858_528192) v(n1_579050_531536) v(n1_579050_528192) v(n1_556858_524848) v(n1_556858_521504) v(n1_579050_524848) v(n1_579050_521504) v(n1_556858_518160) v(n1_556858_514816) v(n1_579050_518160) v(n1_579050_514816) v(n1_556858_511472) v(n1_556858_510510) v(n1_579050_511472) v(n1_579050_510510) v(n1_556858_508128) v(n1_556858_504784) v(n1_579050_508128) v(n1_579050_504784) v(n1_556858_501440) v(n1_556858_498096) v(n1_579050_501440) v(n1_579050_498096) v(n1_556858_494752) v(n1_556858_491408) v(n1_579050_494752) v(n1_579050_491408) v(n1_556858_488622) v(n1_556858_488064) v(n1_579050_488622) v(n1_579050_488064) v(n1_556858_484720) v(n1_556858_481376) v(n1_579050_484720) v(n1_579050_481376) v(n1_556858_478032) v(n1_556858_474688) v(n1_579050_478032) v(n1_579050_474688) v(n1_556858_471344) v(n1_556858_468000) v(n1_579050_471344) v(n1_579050_468000) v(n1_556858_466126) v(n1_556858_464656) v(n1_579050_466126) v(n1_579050_464656) v(n1_556858_461312) v(n1_556858_457968) v(n1_579050_461312) v(n1_579050_457968) v(n1_556858_454624) v(n1_556858_451280) v(n1_579050_454624) v(n1_579050_451280) v(n1_556858_447936) v(n1_556858_444592) v(n1_579050_447936) v(n1_579050_444592) v(n1_556858_444238) v(n1_556858_441248) v(n1_579050_444238) v(n1_579050_441248) v(n1_556858_437904) v(n1_556858_434560) v(n1_579050_437904) v(n1_579050_434560) v(n1_556858_431216) v(n1_556858_427872) v(n1_579050_431216) v(n1_579050_427872) v(n1_556858_424528) v(n1_556858_421742) v(n1_579050_424528) v(n1_579050_421742) v(n1_556858_421184) v(n1_556858_417840) v(n1_579050_421184) v(n1_579050_417840) v(n1_556858_414496) v(n1_556858_411152) v(n1_579050_414496) v(n1_579050_411152) v(n1_556858_407808) v(n1_556858_404464) v(n1_579050_407808) v(n1_579050_404464) v(n1_556858_401120) v(n1_556858_399854) v(n1_579050_401120) v(n1_579050_399854) v(n1_556858_397776) v(n1_556858_394432) v(n1_579050_397776) v(n1_579050_394432) v(n1_556858_391088) v(n1_556858_387744) v(n1_579050_391088) v(n1_579050_387744) v(n1_556858_384400) v(n1_556858_381056) v(n1_579050_384400) v(n1_579050_381056) v(n1_556858_377712) v(n1_556858_377358) v(n1_579050_377712) v(n1_579050_377358) v(n1_556858_374368) v(n1_556858_371024) v(n1_579050_374368) v(n1_579050_371024) v(n1_556858_367680) v(n1_556858_364336) v(n1_579050_367680) v(n1_579050_364336) v(n1_556858_360992) v(n1_556858_357648) v(n1_579050_360992) v(n1_579050_357648) v(n1_556858_355470) v(n1_556858_354304) v(n1_579050_355470) v(n1_579050_354304) v(n1_556858_350960) v(n1_556858_347616) v(n1_579050_350960) v(n1_579050_347616) v(n1_556858_344272) v(n1_556858_340928) v(n1_579050_344272) v(n1_579050_340928) v(n1_556858_337584) v(n1_556858_334240) v(n1_579050_337584) v(n1_579050_334240) v(n1_556858_332974) v(n1_556858_330896) v(n1_579050_332974) v(n1_579050_330896) v(n1_556858_327552) v(n1_556858_324208) v(n1_579050_327552) v(n1_579050_324208) v(n1_556858_320864) v(n1_556858_317520) v(n1_579050_320864) v(n1_579050_317520) v(n1_556858_314176) v(n1_556858_311086) v(n1_579050_314176) v(n1_579050_311086) v(n1_556858_310832) v(n1_556858_307488) v(n1_579050_310832) v(n1_579050_307488) v(n1_556858_304144) v(n1_556858_300800) v(n1_579050_304144) v(n1_579050_300800) v(n1_556858_297456) v(n1_556858_294112) v(n1_579050_297456) v(n1_579050_294112) v(n1_556858_290768) v(n1_556858_288590) v(n1_579050_290768) v(n1_579050_288590) v(n1_556858_287424) v(n1_556858_284080) v(n1_579050_287424) v(n1_579050_284080) v(n1_556858_280736) v(n1_556858_277392) v(n1_579050_280736) v(n1_579050_277392) v(n1_556858_274048) v(n1_556858_270704) v(n1_579050_274048) v(n1_579050_270704) v(n1_556858_267360) v(n1_556858_266702) v(n1_579050_267360) v(n1_579050_266702) v(n1_556858_264016) v(n1_556858_260672) v(n1_579050_264016) v(n1_579050_260672) v(n1_556858_257328) v(n1_556858_253984) v(n1_579050_257328) v(n1_579050_253984) v(n1_556858_250640) v(n1_556858_247296) v(n1_579050_250640) v(n1_579050_247296) v(n1_556858_244814) v(n1_556858_243952) v(n1_579050_244814) v(n1_579050_243952) v(n1_556858_240608) v(n1_556858_237264) v(n1_579050_240608) v(n1_579050_237264) v(n1_556858_233920) v(n1_556858_230576) v(n1_579050_233920) v(n1_579050_230576) v(n1_556858_227232) v(n1_556858_223888) v(n1_579050_227232) v(n1_579050_223888) v(n1_556858_222318) v(n1_556858_220544) v(n1_579050_222318) v(n1_579050_220544) v(n1_556858_217200) v(n1_556858_213856) v(n1_579050_217200) v(n1_579050_213856) v(n1_556858_210512) v(n1_556858_207168) v(n1_579050_210512) v(n1_579050_207168) v(n1_556858_203824) v(n1_556858_200480) v(n1_579050_203824) v(n1_579050_200480) v(n1_556858_200430) v(n1_556858_197136) v(n1_579050_200430) v(n1_579050_197136) v(n1_556858_193792) v(n1_556858_190448) v(n1_579050_193792) v(n1_579050_190448) v(n1_556858_187104) v(n1_556858_183760) v(n1_579050_187104) v(n1_579050_183760) v(n1_556858_180416) v(n1_556858_177934) v(n1_579050_180416) v(n1_579050_177934) v(n1_556858_177072) v(n1_556858_173728) v(n1_579050_177072) v(n1_579050_173728) v(n1_556858_170384) v(n1_556858_167040) v(n1_579050_170384) v(n1_579050_167040) v(n1_556858_163696) v(n1_556858_160352) v(n1_579050_163696) v(n1_579050_160352) v(n1_556858_157008) v(n1_556858_156046) v(n1_579050_157008) v(n1_579050_156046) v(n1_556858_153664) v(n1_556858_150320) v(n1_579050_153664) v(n1_579050_150320) v(n1_556858_146976) v(n1_556858_143632) v(n1_579050_146976) v(n1_579050_143632) v(n1_556858_140288) v(n1_556858_136944) v(n1_579050_140288) v(n1_579050_136944) v(n1_556858_133600) v(n1_556858_133550) v(n1_579050_133600) v(n1_579050_133550) v(n1_556858_130256) v(n1_556858_126912) v(n1_579050_130256) v(n1_579050_126912) v(n1_556858_123568) v(n1_556858_120224) v(n1_579050_123568) v(n1_579050_120224) v(n1_556858_116880) v(n1_556858_113536) v(n1_579050_116880) v(n1_579050_113536) v(n1_556858_111662) v(n1_556858_110192) v(n1_579050_111662) v(n1_579050_110192) v(n1_556858_106848) v(n1_556858_103504) v(n1_579050_106848) v(n1_579050_103504) v(n1_556858_100160) v(n1_556858_96816) v(n1_579050_100160) v(n1_534666_93472) v(n1_579050_96816) v(n1_556858_93472) v(n1_556858_90128) v(n1_579050_93472) v(n1_534666_90128) v(n1_534666_89166) v(n1_512170_90128) v(n1_512170_89166) v(n1_512170_86784) v(n1_489978_89166) v(n1_489978_86784) v(n1_489978_83440) v(n1_467482_86784) v(n1_467482_83440) v(n1_467482_80096) v(n1_445290_83440) v(n1_445290_80096) v(n1_445290_76752) v(n1_422794_80096) v(n1_467482_76752) v(n1_467482_73408) v(n1_489978_73408) v(n1_489978_76752) v(n1_512170_76752) v(n1_489978_80096) v(n1_512170_80096) v(n1_534666_80096) v(n1_512170_83440) v(n1_534666_83440) v(n1_556858_83440) v(n1_534666_86784) v(n1_556858_86784) v(n1_579050_86784) v(n1_556858_89166) v(n1_579050_89166) v(n1_601546_89166) v(n1_579050_90128) v(n1_601546_90128) v(n1_623064_90128) v(n1_601546_93472) v(n1_601546_96816) v(n1_623064_93472) v(n1_623064_96816) v(n1_601546_100160) v(n1_601546_103504) v(n1_623064_100160) v(n1_623064_103504) v(n1_601546_106848) v(n1_601546_110192) v(n1_623064_106848) v(n1_623064_110192) v(n1_601546_111662) v(n1_601546_113536) v(n1_625064_111662) v(n1_623064_113536) v(n1_601546_116880) v(n1_601546_120224) v(n1_623064_116880) v(n1_623064_120224) v(n1_601546_123568) v(n1_601546_126912) v(n1_623064_123568) v(n1_623064_126912) v(n1_601546_130256) v(n1_601546_133550) v(n1_623064_130256) v(n1_625064_133550) v(n1_601546_133600) v(n1_601546_136944) v(n1_623064_133600) v(n1_623064_136944) v(n1_601546_140288) v(n1_601546_143632) v(n1_623064_140288) v(n1_623064_143632) v(n1_601546_146976) v(n1_601546_150320) v(n1_623064_146976) v(n1_623064_150320) v(n1_601546_153664) v(n1_601546_156046) v(n1_623064_153664) v(n1_625064_156046) v(n1_601546_157008) v(n1_601546_160352) v(n1_623064_157008) v(n1_623064_160352) v(n1_601546_163696) v(n1_601546_167040) v(n1_623064_163696) v(n1_623064_167040) v(n1_601546_170384) v(n1_601546_173728) v(n1_623064_170384) v(n1_623064_173728) v(n1_601546_177072) v(n1_601546_177934) v(n1_623064_177072) v(n1_625064_177934) v(n1_601546_180416) v(n1_601546_183760) v(n1_623064_180416) v(n1_623064_183760) v(n1_601546_187104) v(n1_601546_190448) v(n1_623064_187104) v(n1_623064_190448) v(n1_601546_193792) v(n1_601546_197136) v(n1_623064_193792) v(n1_623064_197136) v(n1_601546_200430) v(n1_601546_200480) v(n1_625064_200430) v(n1_623064_200480) v(n1_601546_203824) v(n1_601546_207168) v(n1_623064_203824) v(n1_623064_207168) v(n1_601546_210512) v(n1_601546_213856) v(n1_623064_210512) v(n1_623064_213856) v(n1_601546_217200) v(n1_601546_220544) v(n1_623064_217200) v(n1_623064_220544) v(n1_601546_222318) v(n1_601546_223888) v(n1_625064_222318) v(n1_623064_223888) v(n1_601546_227232) v(n1_601546_230576) v(n1_623064_227232) v(n1_623064_230576) v(n1_601546_233920) v(n1_601546_237264) v(n1_623064_233920) v(n1_623064_237264) v(n1_601546_240608) v(n1_601546_243952) v(n1_623064_240608) v(n1_623064_243952) v(n1_601546_244814) v(n1_601546_247296) v(n1_625064_244814) v(n1_623064_247296) v(n1_601546_250640) v(n1_601546_253984) v(n1_623064_250640) v(n1_623064_253984) v(n1_601546_257328) v(n1_601546_260672) v(n1_623064_257328) v(n1_623064_260672) v(n1_601546_264016) v(n1_601546_266702) v(n1_623064_264016) v(n1_625064_266702) v(n1_601546_267360) v(n1_601546_270704) v(n1_623064_267360) v(n1_623064_270704) v(n1_601546_274048) v(n1_601546_277392) v(n1_623064_274048) v(n1_623064_277392) v(n1_601546_280736) v(n1_601546_284080) v(n1_623064_280736) v(n1_623064_284080) v(n1_601546_287424) v(n1_601546_288590) v(n1_623064_287424) v(n1_625064_288590) v(n1_601546_290768) v(n1_601546_294112) v(n1_623064_290768) v(n1_623064_294112) v(n1_601546_297456) v(n1_601546_300800) v(n1_623064_297456) v(n1_623064_300800) v(n1_601546_304144) v(n1_601546_307488) v(n1_623064_304144) v(n1_623064_307488) v(n1_601546_310832) v(n1_601546_311086) v(n1_623064_310832) v(n1_625064_311086) v(n1_601546_314176) v(n1_601546_317520) v(n1_623064_314176) v(n1_623064_317520) v(n1_601546_320864) v(n1_601546_324208) v(n1_623064_320864) v(n1_623064_324208) v(n1_601546_327552) v(n1_601546_330896) v(n1_623064_327552) v(n1_623064_330896) v(n1_601546_332974) v(n1_601546_334240) v(n1_625064_332974) v(n1_623064_334240) v(n1_601546_337584) v(n1_601546_340928) v(n1_623064_337584) v(n1_623064_340928) v(n1_601546_344272) v(n1_601546_347616) v(n1_623064_344272) v(n1_623064_347616) v(n1_601546_350960) v(n1_601546_354304) v(n1_623064_350960) v(n1_623064_354304) v(n1_601546_355470) v(n1_601546_357648) v(n1_625064_355470) v(n1_623064_357648) v(n1_601546_360992) v(n1_601546_364336) v(n1_623064_360992) v(n1_623064_364336) v(n1_601546_367680) v(n1_601546_371024) v(n1_623064_367680) v(n1_623064_371024) v(n1_601546_374368) v(n1_601546_377358) v(n1_623064_374368) v(n1_625064_377358) v(n1_601546_377712) v(n1_601546_381056) v(n1_623064_377712) v(n1_623064_381056) v(n1_601546_384400) v(n1_601546_387744) v(n1_623064_384400) v(n1_623064_387744) v(n1_601546_391088) v(n1_601546_394432) v(n1_623064_391088) v(n1_623064_394432) v(n1_601546_397776) v(n1_601546_399854) v(n1_623064_397776) v(n1_625064_399854) v(n1_601546_401120) v(n1_601546_404464) v(n1_623064_401120) v(n1_623064_404464) v(n1_601546_407808) v(n1_601546_411152) v(n1_623064_407808) v(n1_623064_411152) v(n1_601546_414496) v(n1_601546_417840) v(n1_623064_414496) v(n1_623064_417840) v(n1_601546_421184) v(n1_601546_421742) v(n1_623064_421184) v(n1_625064_421742) v(n1_601546_424528) v(n1_601546_427872) v(n1_623064_424528) v(n1_623064_427872) v(n1_601546_431216) v(n1_601546_434560) v(n1_623064_431216) v(n1_623064_434560) v(n1_601546_437904) v(n1_601546_441248) v(n1_623064_437904) v(n1_623064_441248) v(n1_601546_444238) v(n1_601546_444592) v(n1_625064_444238) v(n1_623064_444592) v(n1_601546_447936) v(n1_601546_451280) v(n1_623064_447936) v(n1_623064_451280) v(n1_601546_454624) v(n1_601546_457968) v(n1_623064_454624) v(n1_623064_457968) v(n1_601546_461312) v(n1_601546_464656) v(n1_623064_461312) v(n1_623064_464656) v(n1_601546_466126) v(n1_601546_468000) v(n1_625064_466126) v(n1_623064_468000) v(n1_601546_471344) v(n1_601546_474688) v(n1_623064_471344) v(n1_623064_474688) v(n1_601546_478032) v(n1_601546_481376) v(n1_623064_478032) v(n1_623064_481376) v(n1_601546_484720) v(n1_601546_488064) v(n1_623064_484720) v(n1_623064_488064) v(n1_601546_488622) v(n1_601546_491408) v(n1_625064_488622) v(n1_623064_491408) v(n1_601546_494752) v(n1_601546_498096) v(n1_623064_494752) v(n1_623064_498096) v(n1_601546_501440) v(n1_601546_504784) v(n1_623064_501440) v(n1_623064_504784) v(n1_601546_508128) v(n1_601546_510510) v(n1_623064_508128) v(n1_625064_510510) v(n1_601546_511472) v(n1_601546_514816) v(n1_623064_511472) v(n1_623064_514816) v(n1_601546_518160) v(n1_601546_521504) v(n1_623064_518160) v(n1_623064_521504) v(n1_601546_524848) v(n1_601546_528192) v(n1_623064_524848) v(n1_623064_528192) v(n1_601546_531536) v(n1_601546_532398) v(n1_623064_531536) v(n1_625064_532398) v(n1_601546_534880) v(n1_601546_538224) v(n1_623064_534880) v(n1_623064_538224) v(n1_601546_541568) v(n1_601546_544912) v(n1_623064_541568) v(n1_623064_544912) v(n1_601546_548256) v(n1_623064_548256) v(n1_623064_551600) v(n1_625064_551600) v(n1_627064_551600) v(n1_625064_548256) v(n1_627064_554894) v(n1_625064_544912) v(n1_627064_548256) v(n1_625064_541568) v(n1_627064_544912) v(n1_625064_538224) v(n1_627064_541568) v(n1_625064_534880) v(n1_627064_538224) v(n1_627064_534880) v(n1_625064_531536) v(n1_627064_532398) v(n1_625064_528192) v(n1_627064_531536) v(n1_625064_524848) v(n1_627064_528192) v(n1_625064_521504) v(n1_627064_524848) v(n1_625064_518160) v(n1_627064_521504) v(n1_625064_514816) v(n1_627064_518160) v(n1_625064_511472) v(n1_627064_514816) v(n1_627064_511472) v(n1_625064_508128) v(n1_627064_510510) v(n1_625064_504784) v(n1_627064_508128) v(n1_625064_501440) v(n1_627064_504784) v(n1_625064_498096) v(n1_627064_501440) v(n1_625064_494752) v(n1_627064_498096) v(n1_625064_491408) v(n1_627064_494752) v(n1_627064_491408) v(n1_625064_488064) v(n1_627064_488622) v(n1_625064_484720) v(n1_627064_488064) v(n1_625064_481376) v(n1_627064_484720) v(n1_625064_478032) v(n1_627064_481376) v(n1_625064_474688) v(n1_627064_478032) v(n1_625064_471344) v(n1_627064_474688) v(n1_625064_468000) v(n1_627064_471344) v(n1_627064_468000) v(n1_625064_464656) v(n1_627064_466126) v(n1_625064_461312) v(n1_627064_464656) v(n1_625064_457968) v(n1_627064_461312) v(n1_625064_454624) v(n1_627064_457968) v(n1_625064_451280) v(n1_627064_454624) v(n1_625064_447936) v(n1_627064_451280) v(n1_625064_444592) v(n1_627064_447936) v(n1_627064_444592) v(n1_625064_441248) v(n1_627064_444238) v(n1_625064_437904) v(n1_627064_441248) v(n1_625064_434560) v(n1_627064_437904) v(n1_625064_431216) v(n1_627064_434560) v(n1_625064_427872) v(n1_627064_431216) v(n1_625064_424528) v(n1_627064_427872) v(n1_627064_424528) v(n1_625064_421184) v(n1_627064_421742) v(n1_625064_417840) v(n1_627064_421184) v(n1_625064_414496) v(n1_627064_417840) v(n1_625064_411152) v(n1_627064_414496) v(n1_625064_407808) v(n1_627064_411152) v(n1_625064_404464) v(n1_627064_407808) v(n1_625064_401120) v(n1_627064_404464) v(n1_627064_401120) v(n1_625064_397776) v(n1_627064_399854) v(n1_625064_394432) v(n1_627064_397776) v(n1_625064_391088) v(n1_627064_394432) v(n1_625064_387744) v(n1_627064_391088) v(n1_625064_384400) v(n1_627064_387744) v(n1_625064_381056) v(n1_627064_384400) v(n1_625064_377712) v(n1_627064_381056) v(n1_627064_377712) v(n1_625064_374368) v(n1_627064_377358) v(n1_625064_371024) v(n1_627064_374368) v(n1_625064_367680) v(n1_627064_371024) v(n1_625064_364336) v(n1_627064_367680) v(n1_625064_360992) v(n1_627064_364336) v(n1_625064_357648) v(n1_627064_360992) v(n1_627064_357648) v(n1_625064_354304) v(n1_627064_355470) v(n1_625064_350960) v(n1_627064_354304) v(n1_625064_347616) v(n1_627064_350960) v(n1_625064_344272) v(n1_627064_347616) v(n1_625064_340928) v(n1_627064_344272) v(n1_625064_337584) v(n1_627064_340928) v(n1_625064_334240) v(n1_627064_337584) v(n1_627064_334240) v(n1_625064_330896) v(n1_627064_332974) v(n1_625064_327552) v(n1_627064_330896) v(n1_625064_324208) v(n1_627064_327552) v(n1_625064_320864) v(n1_627064_324208) v(n1_625064_317520) v(n1_627064_320864) v(n1_625064_314176) v(n1_627064_317520) v(n1_627064_314176) v(n1_625064_310832) v(n1_627064_311086) v(n1_625064_307488) v(n1_627064_310832) v(n1_625064_304144) v(n1_627064_307488) v(n1_625064_300800) v(n1_627064_304144) v(n1_625064_297456) v(n1_627064_300800) v(n1_625064_294112) v(n1_627064_297456) v(n1_625064_290768) v(n1_627064_294112) v(n1_627064_290768) v(n1_625064_287424) v(n1_627064_288590) v(n1_625064_284080) v(n1_627064_287424) v(n1_625064_280736) v(n1_627064_284080) v(n1_625064_277392) v(n1_627064_280736) v(n1_625064_274048) v(n1_627064_277392) v(n1_625064_270704) v(n1_627064_274048) v(n1_625064_267360) v(n1_627064_270704) v(n1_627064_267360) v(n1_625064_264016) v(n1_627064_266702) v(n1_625064_260672) v(n1_627064_264016) v(n1_625064_257328) v(n1_627064_260672) v(n1_625064_253984) v(n1_627064_257328) v(n1_625064_250640) v(n1_627064_253984) v(n1_625064_247296) v(n1_627064_250640) v(n1_627064_247296) v(n1_625064_243952) v(n1_627064_244814) v(n1_625064_240608) v(n1_627064_243952) v(n1_625064_237264) v(n1_627064_240608) v(n1_625064_233920) v(n1_627064_237264) v(n1_625064_230576) v(n1_627064_233920) v(n1_625064_227232) v(n1_627064_230576) v(n1_625064_223888) v(n1_627064_227232) v(n1_627064_223888) v(n1_625064_220544) v(n1_627064_222318) v(n1_625064_217200) v(n1_627064_220544) v(n1_625064_213856) v(n1_627064_217200) v(n1_625064_210512) v(n1_627064_213856) v(n1_625064_207168) v(n1_627064_210512) v(n1_625064_203824) v(n1_627064_207168) v(n1_625064_200480) v(n1_627064_203824) v(n1_627064_200480) v(n1_625064_197136) v(n1_627064_200430) v(n1_625064_193792) v(n1_627064_197136) v(n1_625064_190448) v(n1_627064_193792) v(n1_625064_187104) v(n1_627064_190448) v(n1_625064_183760) v(n1_627064_187104) v(n1_625064_180416) v(n1_627064_183760) v(n1_627064_180416) v(n1_625064_177072) v(n1_627064_177934) v(n1_625064_173728) v(n1_627064_177072) v(n1_625064_170384) v(n1_627064_173728) v(n1_625064_167040) v(n1_627064_170384) v(n1_625064_163696) v(n1_627064_167040) v(n1_625064_160352) v(n1_627064_163696) v(n1_625064_157008) v(n1_627064_160352) v(n1_627064_157008) v(n1_625064_153664) v(n1_627064_156046) v(n1_625064_150320) v(n1_627064_153664) v(n1_625064_146976) v(n1_627064_150320) v(n1_625064_143632) v(n1_627064_146976) v(n1_625064_140288) v(n1_627064_143632) v(n1_625064_136944) v(n1_627064_140288) v(n1_625064_133600) v(n1_627064_136944) v(n1_627064_133600) v(n1_625064_130256) v(n1_627064_133550) v(n1_625064_126912) v(n1_627064_130256) v(n1_625064_123568) v(n1_627064_126912) v(n1_625064_120224) v(n1_627064_123568) v(n1_625064_116880) v(n1_627064_120224) v(n1_625064_113536) v(n1_627064_116880) v(n1_627064_113536) v(n1_625064_110192) v(n1_627064_111662) v(n1_625064_106848) v(n1_627064_110192) v(n1_625064_103504) v(n1_627064_106848) v(n1_625064_100160) v(n1_627064_103504) v(n1_625064_96816) v(n1_627064_100160) v(n1_625064_93472) v(n1_627064_96816) v(n1_625064_90128) v(n1_627064_93472) v(n1_625064_89166) v(n1_627064_90128) v(n1_625064_86784) v(n1_627064_89166) v(n1_601546_86784) v(n1_601546_83440) v(n1_623064_86784) v(n1_579050_83440) v(n1_579050_80096) v(n1_556858_80096) v(n1_556858_76752) v(n1_534666_76752) v(n1_534666_73408) v(n1_512170_73408) v(n1_512170_70064) v(n1_489978_70064) v(n1_534666_70064) v(n1_512170_67278) v(n1_534666_67278) v(n1_556858_67278) v(n1_534666_66720) v(n1_556858_70064) v(n1_579050_70064) v(n1_556858_73408) v(n1_579050_73408) v(n1_601546_73408) v(n1_579050_76752) v(n1_601546_76752) v(n1_623064_76752) v(n1_601546_80096) v(n1_623064_80096) v(n1_625064_80096) v(n1_627064_80096) v(n1_625064_76752) v(n1_625064_83440) v(n1_627064_83440) v(n1_623064_83440) v(n1_627064_86784) v(n1_625064_73408) v(n1_627064_76752) v(n1_625064_70064) v(n1_627064_73408) v(n1_623064_73408) v(n1_601546_70064) v(n1_601546_67278) v(n1_623064_70064) v(n1_579050_67278) v(n1_579050_66720) v(n1_556858_66720) v(n1_556858_63376) v(n1_579050_63376) v(n1_579050_60032) v(n1_601546_60032) v(n1_601546_63376) v(n1_623064_63376) v(n1_601546_66720) v(n1_623064_66720) v(n1_625064_66720) v(n1_627064_66720) v(n1_625064_63376) v(n1_625064_67278) v(n1_627064_67278) v(n1_627064_70064) v(n1_625064_60032) v(n1_627064_63376) v(n1_625064_56688) v(n1_627064_60032) v(n1_623064_60032) v(n1_601546_56688) v(n1_623064_56688) v(n1_627064_56688) v(n1_625064_53344) v(n1_627064_53344) v(n1_623064_53344) v(n1_627064_50000) v(n1_46000_113536) v(n1_44000_116880) v(n1_46000_111662) v(n1_48000_113536) v(n1_44000_113536) v(n1_65594_111662) v(n1_65594_110192) v(n1_44000_111662) v(n1_46000_110192) v(n1_46000_106848) v(n1_48000_110192) v(n1_44000_110192) v(n1_88090_110192) v(n1_65594_106848) v(n1_65594_103504) v(n1_88090_106848) v(n1_48000_106848) v(n1_44000_106848) v(n1_46000_103504) v(n1_46000_100160) v(n1_48000_103504) v(n1_44000_103504) v(n1_88090_103504) v(n1_65594_100160) v(n1_65594_96816) v(n1_88090_100160) v(n1_48000_100160) v(n1_44000_100160) v(n1_46000_96816) v(n1_46000_93472) v(n1_48000_96816) v(n1_44000_96816) v(n1_88090_96816) v(n1_65594_93472) v(n1_65594_90128) v(n1_88090_93472) v(n1_48000_93472) v(n1_44000_93472) v(n1_46000_90128) v(n1_46000_89166) v(n1_48000_90128) v(n1_44000_90128) v(n1_88090_90128) v(n1_65594_89166) v(n1_65594_86784) v(n1_88090_89166) v(n1_44000_89166) v(n1_46000_86784) v(n1_46000_83440) v(n1_48000_86784) v(n1_44000_86784) v(n1_88090_86784) v(n1_65594_83440) v(n1_65594_80096) v(n1_88090_83440) v(n1_48000_83440) v(n1_44000_83440) v(n1_46000_80096) v(n1_46000_76752) v(n1_48000_80096) v(n1_44000_80096) v(n1_88090_80096) v(n1_65594_76752) v(n1_65594_73408) v(n1_88090_76752) v(n1_48000_76752) v(n1_44000_76752) v(n1_46000_73408) v(n1_46000_70064) v(n1_48000_73408) v(n1_44000_73408) v(n1_88090_73408) v(n1_65594_70064) v(n1_65594_67278) v(n1_88090_70064) v(n1_48000_70064) v(n1_44000_70064) v(n1_46000_67278) v(n1_46000_66720) v(n1_44000_67278) v(n1_88090_67278) v(n1_65594_66720) v(n1_65594_63376) v(n1_88090_66720) v(n1_48000_66720) v(n1_44000_66720) v(n1_46000_63376) v(n1_46000_60032) v(n1_48000_63376) v(n1_44000_63376) v(n1_88090_63376) v(n1_65594_60032) v(n1_65594_56688) v(n1_88090_60032) v(n1_48000_60032) v(n1_44000_60032) v(n1_46000_56688) v(n1_46000_53344) v(n1_48000_56688) v(n1_44000_56688) v(n1_88090_56688) v(n1_65594_53344) v(n1_65594_50000) v(n1_88090_53344) v(n1_48000_53344) v(n1_44000_53344) v(n1_46000_50000) v(n1_46000_46000) v(n1_48000_50000) v(n1_44000_50000) v(n1_88090_50000) v(n1_65594_46000) v(n1_65594_44000) v(n1_88090_46000) v(n1_28_46000) v(n1_46000_28) v(n1_46000_0) v(n1_46000_48000) v(n1_0_46000) v(n1_110282_46000) v(n1_88090_44000) v(n1_110282_50000) v(n1_132778_50000) v(n1_110282_53344) v(n1_110282_56688) v(n1_132778_53344) v(n1_132778_56688) v(n1_110282_60032) v(n1_110282_63376) v(n1_132778_60032) v(n1_132778_63376) v(n1_110282_66720) v(n1_110282_67278) v(n1_132778_66720) v(n1_132778_67278) v(n1_110282_70064) v(n1_110282_73408) v(n1_132778_70064) v(n1_132778_73408) v(n1_110282_76752) v(n1_110282_80096) v(n1_132778_76752) v(n1_132778_80096) v(n1_110282_83440) v(n1_110282_86784) v(n1_132778_83440) v(n1_132778_86784) v(n1_110282_89166) v(n1_110282_90128) v(n1_132778_89166) v(n1_132778_90128) v(n1_110282_93472) v(n1_110282_96816) v(n1_132778_93472) v(n1_132778_96816) v(n1_110282_100160) v(n1_110282_103504) v(n1_132778_100160) v(n1_132778_103504) v(n1_110282_106848) v(n1_154970_100160) v(n1_154970_96816) v(n1_177466_96816) v(n1_154970_93472) v(n1_154970_90128) v(n1_177466_93472) v(n1_177466_90128) v(n1_154970_89166) v(n1_154970_86784) v(n1_177466_89166) v(n1_177466_86784) v(n1_154970_83440) v(n1_154970_80096) v(n1_177466_83440) v(n1_177466_80096) v(n1_154970_76752) v(n1_154970_73408) v(n1_177466_76752) v(n1_177466_73408) v(n1_154970_70064) v(n1_154970_67278) v(n1_177466_70064) v(n1_177466_67278) v(n1_154970_66720) v(n1_154970_63376) v(n1_177466_66720) v(n1_177466_63376) v(n1_154970_60032) v(n1_154970_56688) v(n1_177466_60032) v(n1_177466_56688) v(n1_154970_53344) v(n1_154970_50000) v(n1_177466_53344) v(n1_132778_46000) v(n1_177466_50000) v(n1_154970_46000) v(n1_154970_44000) v(n1_177466_46000) v(n1_132778_44000) v(n1_110282_44000) v(n1_199658_46000) v(n1_177466_44000) v(n1_199658_50000) v(n1_221850_50000) v(n1_199658_53344) v(n1_199658_56688) v(n1_221850_53344) v(n1_221850_56688) v(n1_199658_60032) v(n1_199658_63376) v(n1_221850_60032) v(n1_221850_63376) v(n1_199658_66720) v(n1_199658_67278) v(n1_221850_66720) v(n1_221850_67278) v(n1_199658_70064) v(n1_199658_73408) v(n1_221850_70064) v(n1_221850_73408) v(n1_199658_76752) v(n1_199658_80096) v(n1_221850_76752) v(n1_221850_80096) v(n1_199658_83440) v(n1_199658_86784) v(n1_221850_83440) v(n1_221850_86784) v(n1_199658_89166) v(n1_199658_90128) v(n1_221850_89166) v(n1_221850_90128) v(n1_199658_93472) v(n1_244346_89166) v(n1_244346_86784) v(n1_266538_86784) v(n1_244346_83440) v(n1_244346_80096) v(n1_266538_83440) v(n1_266538_80096) v(n1_244346_76752) v(n1_244346_73408) v(n1_266538_76752) v(n1_266538_73408) v(n1_244346_70064) v(n1_244346_67278) v(n1_266538_70064) v(n1_266538_67278) v(n1_244346_66720) v(n1_244346_63376) v(n1_266538_66720) v(n1_266538_63376) v(n1_244346_60032) v(n1_244346_56688) v(n1_266538_60032) v(n1_266538_56688) v(n1_244346_53344) v(n1_244346_50000) v(n1_266538_53344) v(n1_221850_46000) v(n1_266538_50000) v(n1_244346_46000) v(n1_244346_44000) v(n1_266538_46000) v(n1_221850_44000) v(n1_199658_44000) v(n1_289034_46000) v(n1_266538_44000) v(n1_289034_50000) v(n1_311226_50000) v(n1_289034_53344) v(n1_289034_56688) v(n1_311226_53344) v(n1_311226_56688) v(n1_289034_60032) v(n1_289034_63376) v(n1_311226_60032) v(n1_311226_63376) v(n1_289034_66720) v(n1_289034_67278) v(n1_311226_66720) v(n1_311226_67278) v(n1_289034_70064) v(n1_289034_73408) v(n1_311226_70064) v(n1_311226_73408) v(n1_289034_76752) v(n1_289034_80096) v(n1_311226_76752) v(n1_311226_80096) v(n1_289034_83440) v(n1_333722_76752) v(n1_333722_73408) v(n1_355914_73408) v(n1_333722_70064) v(n1_333722_67278) v(n1_355914_70064) v(n1_355914_67278) v(n1_333722_66720) v(n1_333722_63376) v(n1_355914_66720) v(n1_355914_63376) v(n1_333722_60032) v(n1_333722_56688) v(n1_355914_60032) v(n1_355914_56688) v(n1_333722_53344) v(n1_333722_50000) v(n1_355914_53344) v(n1_311226_46000) v(n1_355914_50000) v(n1_333722_46000) v(n1_333722_44000) v(n1_355914_46000) v(n1_311226_44000) v(n1_289034_44000) v(n1_378410_46000) v(n1_355914_44000) v(n1_378410_50000) v(n1_400602_50000) v(n1_378410_53344) v(n1_378410_56688) v(n1_400602_53344) v(n1_400602_56688) v(n1_378410_60032) v(n1_378410_63376) v(n1_400602_60032) v(n1_400602_63376) v(n1_378410_66720) v(n1_378410_67278) v(n1_400602_66720) v(n1_400602_67278) v(n1_378410_70064) v(n1_422794_66720) v(n1_422794_63376) v(n1_445290_63376) v(n1_422794_60032) v(n1_422794_56688) v(n1_445290_60032) v(n1_445290_56688) v(n1_422794_53344) v(n1_422794_50000) v(n1_445290_53344) v(n1_400602_46000) v(n1_445290_50000) v(n1_422794_46000) v(n1_422794_44000) v(n1_445290_46000) v(n1_400602_44000) v(n1_378410_44000) v(n1_467482_46000) v(n1_445290_44000) v(n1_467482_50000) v(n1_489978_50000) v(n1_467482_53344) v(n1_467482_56688) v(n1_489978_53344) v(n1_489978_56688) v(n1_467482_60032) v(n1_512170_53344) v(n1_512170_50000) v(n1_489978_46000) v(n1_534666_50000) v(n1_512170_46000) v(n1_512170_44000) v(n1_534666_46000) v(n1_489978_44000) v(n1_467482_44000) v(n1_556858_46000) v(n1_534666_44000) v(n1_556858_44000) v(n1_579050_44000)
.end
